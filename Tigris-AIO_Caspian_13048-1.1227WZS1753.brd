# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
81102_ILIM: length 3.3
  BOTTOM w0.203: 15.03,237.2 15.55,237.72 U35.25
  BOTTOM w0.254: v2(13.46,235.57) 13.46,235.7 14.36,236.6 R675.1 14.45,236.62 15.03,237.2
81102_IOUT: length 11.3
  BOTTOM w0.203: 13.84,236.84 15.13,238.12 U35.26
  BOTTOM w0.254: R689.1 9.78,233.54 10.03,233.79 v2(10.41,233.79) 10.79,233.79 11.05,233.54 11.05,232.97 C390.1 R688.1 12.78,233.55 12.78,235.76 13.84,236.83 13.84,236.84
81102_RAMP: length 5.9
  BOTTOM w0.203: U35.27 14.68,238.53 v2(12.87,236.71) 12.34,236.18 12.24,236.18 C385.1
  BOTTOM w0.508: R677.2 C385.1
81102_TSENSE: length 7.2
  BOTTOM w0.203: U35.8 19.67,241.01 20.02,241.37 20.02,241.72 21.13,242.83 21.13,242.86 v2(21.34,243.06) 21.59,243.32 22.95,243.32 C369.1
  BOTTOM w0.254: C369.1 24.69,244.04 R650.1
81102_TSENSE_R: length 29.8
  TOP w0.254: R39.1 v3(19.81,221.5)
  L3 w0.254: v3(19.81,221.5) 17.73,223.58 17.73,228.13 23.39,233.79 23.39,240.39 23.7,240.7 25.2,240.7 v3(25.27,240.62)
  BOTTOM w0.254: v3(25.27,240.62) 25.64,240.99 v2(25.64,241.66) R650.2 R635.1
81102_VCC: length 5.3
  BOTTOM w0.203: U35.2 16.65,242.06 16.1,242.6
  BOTTOM w0.508: v2(16.1,242.62) 16.1,242.6 15.7,243.01 C372.1 R631.1
81102_VSN: length 9.1
  BOTTOM w0.203: U35.31 15.14,240.12 14.39,240.88 13.06,240.88 12.4,241.54 R656.1
  BOTTOM w0.254: R656.1 11.37,240.9 10.48,240.9 C377.1 9.97,240.46 9.28,241.14 8.27,241.14 v2(8.13,241.28)
81102_VSP: length 5.8
  BOTTOM w0.203: U35.32 15.39,240.53 14.35,241.56 v2(13.72,241.56) 13.04,241.56 C375.1
  BOTTOM w0.254: R651.2 C375.1
+VGA_CORE_PHASE1: length 16.3
  TOP w0.254: PR47.2 33.66,130.54 32.89,129.78 v1(32.89,126.35) 32.89,116.32 v3(32.79,116.21)
  BOTTOM w0.254: v3(32.79,116.21) 32.92,116.09 33.38,116.09 PG3.1
A20GATE: length 125.1
  TOP w0.102: v4(132.36,79.37) 132.07,79.37 U29.N30 ; v3(57.61,39.99) 57.61,39.98 56.15,38.51 56.15,38.26 56.07,38.18 U24.119
  L3 w0.127: v3(125.87,90.79) 125.87,89.82 126.48,89.21 126.48,88.66 125.67,87.84 123.91,87.84 123,86.93 123,85.26 124.19,84.07 124.19,81.26 124.58,80.87 124.58,79.74 120.41,75.56 120.3,75.56 119.89,75.15 118.17,75.15 112.27,69.24 112.27,68.53 103.42,59.69 94.28,59.69 90.04,55.44 70.7,55.44 69.28,54.02 68.35,54.02 66.38,52.05 65.62,52.05 63.84,50.28 63.04,50.28 61.64,48.88 59.09,48.88 58.13,47.92 58.13,40.51 v3(57.61,39.99)
  BOTTOM w0.102: v3(125.87,90.79) 125.6,91.06 R918.1 126.08,91.61 129.11,88.58 130.13,88.58 131.06,87.65 131.06,84.84 131.16,84.74 131.16,84.16 131.3,84.02 131.44,83.87 131.44,82.87 131.55,82.77 131.55,82.03 131.6,81.98 131.6,80.24 132.36,79.48 v4(132.36,79.37) 132.36,78.67 v2(132.28,78.59)
AD+_2: length 13.9
  L4 w0.635: v3(14.58,138.9) 14.58,143.49 v3(14.83,143.75)
  BOTTOM w0.635: R822.1 17.02,146.58 R825.2 17.02,146.45 C451.2 17.07,145.32 17.07,144.51 16.38,143.82 U6.4 v3(14.83,143.75) v2(13.97,143.75) ; v3(14.58,138.9) 15.44,138.03 U40.4
ADAPTOR_PSID: length 265.3
  TOP w0.102: v3(29.97,147.02) v1(29.97,148.95) 29.54,149.39 29.54,150.66 28.66,151.53 R152.2 28.14,151.81 26.09,151.81 D5.3 24.88,151.99 23.75,150.86 16.87,150.86 16.51,151.23 R151.2 ; v3(155.52,60.44) 154.97,60.44 154.26,61.15 154.02,61.15 153.42,61.75 153.42,62.31 147.77,67.96 145.57,67.96 145.51,67.89 U29.AV8
  L3 w0.127: v3(154.56,54.85) 154.39,55.01 149.93,55.01 146.16,51.24 143.25,51.24 141.84,49.83 140.19,49.83 138.35,47.99 128.14,47.99 127.58,47.43 127.19,47.43 126.5,48.12 123.4,48.12 122.8,48.72 120.8,48.72 120.35,48.27 116.66,48.27 114.52,50.42 114.52,50.47 114.21,50.78 114.21,53.03 110.87,56.37 v3(110.87,57.64) ; v3(69.17,67.72) 68.81,68.08 56.82,68.08 56.79,68.06 54.48,68.06 53.95,68.06 53.92,68.08 51.87,68.08 50.98,68.97 35.94,68.97 35.28,68.31 30.78,68.31 30.35,68.74 30.35,71.22 30.85,71.71 30.85,73.09 30.85,73.1 30.85,73.41 30.85,73.41 30.85,75.77 28.62,78 23.67,82.95 23.67,98.24 23.63,98.28 23.63,117.97 25.02,119.36 25.02,128.58 30.73,134.3 30.73,146.64 30.35,147.02 v3(29.97,147.02)
  L4 w0.127: v3(154.56,54.85) 154.79,55.08 154.79,58.79 155.22,59.23 155.22,60.21 155.45,60.44 v3(155.52,60.44)
  BOTTOM w0.102: v3(110.87,57.64) 109.97,57.64 109.09,58.52 109.09,59.17 103.28,64.98 103.28,66.2 102.36,67.12 87.12,67.12 85.29,65.29 81.23,65.29 81.06,65.46 71.93,65.46 71.77,65.31 71.35,65.31 71.05,65.61 71.05,65.76 69.27,67.55 69.27,67.62 v3(69.17,67.72)
ADAPTOR_PSID_R: length 3.5
  TOP w0.102: R151.1 15.98,152.79 16.43,153.25 v1(16.81,153.25) 17.32,152.74 Q37.S
AMD_RST#: length 5.4
  TOP w0.102: U13.AL27 92.07,96.34 92.09,96.33 92.09,96.31 93.23,95.17 v1(93.55,95.17) C752.1 R1160.1
AMP_SPKR_L: length 4
  TOP w0.203: R1233.1 155.32,41.87 R511.2 155.55,42.1 C274.1 157.15,42.1 v1(157.78,42.73)
AMP_SPKR_R: length 5.5
  TOP w0.203: v1(167.23,37.63) 166.57,37.63 166.17,38.03 R526.2 165.86,38.03 164.54,36.71 R1234.1 164.54,36.61 165.74,35.42 C287.1
APL5336_VCNTL: length 7
  BOTTOM w0.508: R860.1 129.61,107.58 128.4,108.79 C482.1 127.76,108.82 126.7,109.89 v2(126.7,110.17) 126.7,110.68 127.84,111.82 U41.6
ATX_ON*: length 8.9
  TOP w0.102: R157.2 R159.2 C115.1 15.02,147.25 12.06,147.25 ATX2.8
AUD_BEEP_C: length 5.5
  TOP w0.102: C166.2 184.48,94.48 184.48,94.04 v1(184.18,93.74) 183.18,92.74 181.36,92.74 181.12,92.51 U16.2
AUD_BEEP_R: length 4.9
  TOP w0.102: R227.2 R228.2 186.5,96.95 186.89,96.55 v1(186.89,96.38) 186.89,96 186.7,95.81 R245.1 C166.1
AUD_DMIC_CLK: length 166.3
  TOP w0.127: C161.1 176.45,96.44 L54.2 174.82,96.44 174.12,97.14 174.12,97.95 173.48,98.59 v3(173.48,99.68) ; WEBCM1.4 168.25,224.65 168.25,225.72 167.44,226.53 v3(167.44,228.48)
  L4 w0.127: v3(173.48,99.68) 173.82,100.02 177.33,100.02 178.97,101.66 178.97,109.65 178.07,110.55 178.07,114.01 180.85,116.79 180.85,129.85 188.37,137.37 188.37,150.02 190.51,152.16 190.51,168.99 190.26,169.24 190.26,177.11 184.72,182.65 184.72,184.67 184.67,184.72 184.67,186.96 185.65,187.94 185.65,220.21 177.38,228.48 v3(167.44,228.48)
  BOTTOM w0.127: v2(174.29,100.92) 174.29,100.49 v3(173.48,99.68)
AUD_DMIC_CLK_R: length 2.5
  TOP w0.127: U16.12 176.65,92.04 176.56,92.14 176.56,92.52 v3(176.53,92.54) 175.67,93.41 R246.1
AUD_DMIC_CLK_R_1: length 2.4
  TOP w0.127: L54.1 176.36,95.55 v1(176.63,95.28) 175.86,94.51 R246.2
AUD_DMIC_DATA: length 170
  TOP w0.127: R263.2 174.23,94.98 C167.2 174.24,95.04 172.31,96.98 172.31,99.27 v3(172.72,99.68) ; WEBCM1.5 166.99,224.65 166.99,225.93 166.6,226.32 v3(166.6,228.53)
  L4 w0.127: v3(166.6,228.53) 167.02,228.95 177.27,228.95 185.9,220.32 185.9,187.83 184.92,186.85 184.92,184.82 184.98,184.77 184.98,182.76 190.51,177.22 190.51,169.35 190.77,169.09 190.77,152.06 188.62,149.91 188.62,137.25 181.1,129.73 181.1,116.69 178.32,113.91 178.32,110.65 179.22,109.75 179.22,101.55 177.09,99.42 173.89,99.42 173.68,99.21 173.29,99.21 173.07,99.42 172.97,99.42 v3(172.72,99.68)
  BOTTOM w0.127: v3(172.72,99.68) 172.16,100.24 v2(172.16,100.92)
AUD_DMIC_DATA_R: length 6.7
  TOP w0.127: R263.1 172.38,94.48 v3(174.85,92.01) 174.85,91.88 175.52,91.21 U16.13
  BOTTOM w0.127: v3(174.85,92.01) 174.93,92.08 v2(174.93,92.82)
AUD_DVDD: length 8.2
  TOP w0.203: C168.1 179.37,94.32 179.37,94.32 179.17,94.12 179.17,93.81 179.12,93.76 U16.7
  TOP w0.508: R221.2 180.26,98.17 180.26,97.27 v1(180.34,97.19) ; C168.1 180.02,95.56 180.09,95.63 C164.1 180.09,96.94 v1(180.34,97.19) ; v1(180.34,97.19) 181.16,97.19 R222.2
AUD_GP3: length 4.2
  TOP w0.203: R247.2 182.62,94.53 182.62,94.05 182.5,93.93 ; 182.5,93.93 182.5,93.58 181.99,93.07 181.13,93.07 180.72,92.67 U16.3 ; 182.5,93.93 v1(182.5,93.94)
AUD_LINK_BCLK: length 58.4
  TOP w0.102: R392.1 161.1,71.27 161.47,70.9 167.84,70.9 v3(168.28,70.47) ; U16.5 179.92,92.68 179.86,92.74 179.86,93.24 180.38,93.76 v3(180.67,93.76) 181.05,93.38 181.67,93.38 181.94,93.65 181.94,94.99 182.21,95.26 C162.2
  BOTTOM w0.102: v3(168.28,70.47) 169.24,71.43 169.24,72.88 170.79,74.43 170.79,81.92 170.24,82.46 170.24,83.22 168.02,85.45 168.02,91.94 170.27,94.19 175.5,94.19 175.62,94.07 178.16,94.07 v2(179.18,93.04) 179.63,92.6 180.51,92.6 180.77,92.86 180.77,93.66 v3(180.67,93.76)
AUD_LINK_BCLK_R: length 12
  TOP w0.102: U29.AV23 145.43,76.23 145.75,75.91 146.38,75.91 149.21,73.09 150.2,73.09 151.04,72.25 151.46,72.25 151.86,71.85 153.54,71.85 v1(153.85,71.54) 154.13,71.27 R392.2
AUD_LINK_RST_N: length 78.7
  TOP w0.102: v3(179.68,93.79) 179.52,93.63 U16.6 ; v3(177.19,71.23) v3(168.28,71.23) 167.72,71.23 167.61,71.13 161.56,71.13 160.88,71.82 156.9,71.82 156.4,72.31 R389.1 ; R375.1 192.19,73.86 v3(191.85,73.52)
  L4 w0.127: v3(177.19,71.23) 178.18,71.23 181.1,68.31 186.64,68.31 v3(191.85,73.52)
  BOTTOM w0.102: v3(168.28,71.23) 168.43,71.23 169.01,71.82 169.01,73.5 169.54,74.03 169.54,74.17 v2(169.54,74.17) 170.54,75.17 170.54,81.85 170.01,82.37 170.01,83.13 167.79,85.35 167.79,92.04 170.18,94.42 175.59,94.42 175.72,94.29 179.17,94.29 v3(179.68,93.79)
AUD_LINK_RST_N_2: length 4.6
  TOP w0.254: v1(143.71,53.93) 144.4,53.25 Q62.6 145.15,52.56 145.16,52.56 145.41,52.31 146.19,52.31 146.45,52.56 Q62.4
AUD_LINK_RST_N_R: length 4.3
  TOP w0.102: R375.2 C219.1 193.68,75.75 v1(194.08,76.16) 195.08,75.16 Q49.G
AUD_LINK_RST_R_N: length 12.3
  TOP w0.102: R389.2 154.12,72.31 v1(153.58,72.84) 153.21,73.21 150.71,73.21 150.43,73.49 149.46,73.49 146.41,76.54 145.34,76.54 144.98,76.9 U29.AU24
AUD_LINK_SDIN: length 64.9
  TOP w0.102: v3(167.31,70.37) 167.28,70.34 v1(165.07,70.34) 161.32,70.34 160.7,70.96 157.48,70.96 157.33,70.81 153.67,70.81 152.86,71.62 151.7,71.62 151.37,71.95 151.04,71.95 150.11,72.88 148.99,72.88 146.22,75.66 145.69,75.66 145.51,75.84 144.41,75.84 144.11,75.54 U29.AT22 ; R244.1 178.85,96.85 178.56,97.14 v3(178.56,97.39)
  BOTTOM w0.102: v3(167.31,70.37) 167.31,72.44 168.8,73.94 168.8,74.48 169.93,75.6 169.93,81.81 169.56,82.18 169.56,82.94 167.34,85.16 167.34,92.23 169.99,94.88 174.52,94.88 177.11,97.47 v2(177.55,97.47) 178.49,97.47 v3(178.56,97.39)
AUD_LINK_SDIN_1: length 3.3
  TOP w0.102: R244.2 178.56,94.79 v1(178.56,94.06) 178.56,94.04 178.78,93.82 178.78,93.01 178.72,92.96 U16.8
AUD_LINK_SDO: length 51.4
  TOP w0.102: v3(166.78,69.77) 160.31,69.77 R395.1
  BOTTOM w0.102: v3(166.78,69.77) 167.36,69.77 167.77,70.18 167.77,72.58 169.03,73.84 169.03,74.38 170.25,75.6 170.25,81.81 169.79,82.27 169.79,83.03 167.56,85.26 167.56,92.13 170.08,94.65 175.57,94.65 177.15,96.22 v2(177.27,96.22) 178,96.22 178.31,95.92 R897.2 178.65,96.15 179.79,96.15 Q96.D 181.29,97.2 182.54,95.96 C533.2
AUD_LINK_SDO_1: length 4.4
  BOTTOM w0.102: Q96.G 181.83,94.48 v2(182.32,93.99) 182.91,93.99 183.18,94.27 C533.1 R896.2
AUD_LINK_SDO_N: length 6.2
  TOP w0.102: U16.4 180.32,93.05 v3(180.32,93.05)
  BOTTOM w0.102: v3(180.32,93.05) 180.14,93.23 180.14,95.02 Q96.S 179.15,95.3 178.77,94.92 R897.1 v2(177.29,94.92)
AUD_LINK_SDO_R: length 20.4
  TOP w0.102: U29.AU22 144.81,75.33 145.09,75.33 145.99,74.43 145.99,74.2 146.28,73.91 146.78,73.91 149.3,71.39 v1(151.05,71.39) 152.75,71.39 153.8,70.34 158.52,70.34 R395.2 R407.2 R415.2 158.08,68.22 157.95,68.34 Q52.C
AUD_LINK_SDO_R1: length 41.3
  TOP w0.102: R407.1 159.99,68.94 v3(166.5,68.94)
  BOTTOM w0.102: MEJ1.2 171.01,95.3 170.08,95.3 167.58,92.79 167.58,92.79 166.98,92.19 166.98,86.97 166.98,85.19 169.33,82.84 169.33,82.08 169.57,81.84 169.57,75.98 169.57,75.97 169.57,75.57 168.43,74.43 168.43,74.18 166.89,72.64 166.89,71.12 v2(166.64,70.86) 166.32,70.55 166.32,69.12 v3(166.5,68.94)
AUD_LINK_SYNC: length 49
  TOP w0.102: v3(169.7,72.55) 168.68,72.55 v1(168.28,72.15) 167.49,71.36 161.77,71.36 159.38,73.75 157.18,73.75 156.39,74.53 R379.1 ; U16.9 v3(178.32,93.2)
  BOTTOM w0.102: v3(178.32,93.2) 177.69,93.84 175.53,93.84 175.4,93.96 170.37,93.96 168.25,91.85 168.25,85.54 170.47,83.32 170.47,82.56 170.54,82.49 171.02,82.01 171.02,74.09 169.7,72.77 v3(169.7,72.55)
AUD_LINK_SYNC_R: length 12.1
  TOP w0.102: R383.2 R379.2 154.54,74.07 v1(153.91,74.07) 153.87,74.07 153.81,74.13 149.11,74.13 146.49,76.75 145.56,76.75 U29.AV24
AUD_REGREF: length 3.6
  TOP w0.203: U16.10 177.92,92.88 177.85,92.95 177.85,92.98 177.8,93.03 177.8,93.46 177.29,93.96 v1(177.29,94.09)
  TOP w0.508: v1(177.29,94.09) 177.67,94.47 177.67,95.13 C165.1
BIST_DISABLE: length 192.5
  TOP w0.102: v3(170.81,195.46) 160.1,195.46 159.49,196.07 150.67,196.07 150.16,195.56 134.25,195.56 R93.1 R92.2 131.86,195.77 130.78,195.77 130.54,196.01 R91.1 ; v4(140.1,77.13) 140.1,77.17 139.76,77.51 U29.AH26
  L3 w0.127: v3(170.81,195.46) 174.66,191.61 175.03,191.61 176.45,190.19 176.45,159.34 175.67,158.56 175.67,151.51 176.06,151.12 176.06,145.24 176.16,145.13 176.16,122.85 171.1,117.79 170.26,117.79 170.26,117.79 169.69,117.79 169.69,117.79 166.29,117.79 160.49,111.99 160.49,105.04 159.46,104.01 159.46,99.25 156.21,96 156.18,96 155.64,95.45 155.64,94.04 156.32,93.35 156.32,91.48 156.84,90.96 156.84,88.98 156.48,88.62 156.14,88.62 154.84,87.31 154.84,83.29 153.75,82.2 153.75,81.83 154.24,81.34 154.24,81.11 154.6,80.75 154.6,78.46 v3(152.12,75.98)
  BOTTOM w0.102: v3(152.12,75.98) v2(151.12,76.98) 150.75,77.36 143.33,77.36 143.19,77.49 140.46,77.49 v4(140.1,77.13)
BIST_DISABLE_1: length 3.5
  TOP w0.254: Q19.B 128.97,198.07 128.73,197.82 v1(128.73,197.29) 128.73,196.78 129.16,196.35 R91.2
BIST_EN: length 18.2
  TOP w0.254: R83.2 129.73,200.83 130.59,199.97 Q19.C 131.81,200.8 134.28,200.8 Q20.C 135.19,199.88 137.16,199.88 138.07,200.8 v1(138.07,203.87) 138.07,205.42 136.91,206.59 136.91,207.34 Q14.B
BIST_EN_INV: length 11.1
  TOP w0.102: Q14.C 135.57,206.99 R75.2 134.24,207.57 R70.1 133.99,206.97 133.61,206.6 v3(133.51,206.6) 133.5,206.59 133.5,206.08 134.43,205.15 Q15.C 137.38,205.15 v1(137.44,205.1)
  BOTTOM w0.102: v3(133.51,206.6) 133.5,206.61 U37.2
BIST_ENABLE: length 133.5
  TOP w0.102: U29.AC36 137.68,82.7 v4(137.68,82.2) ; R81.1 131.43,201.71 130.52,201.71 130.19,202.04 128.57,202.04 128.14,201.61 128.14,192.47 126.34,190.66 126.34,125.2 126.61,124.93 126.64,124.93 126.87,124.7 v3(126.87,122.72)
  L4 w0.127: v3(135.96,100.85) 135.87,100.95 135.87,107.06 135.93,107.12 135.96,108.39 135.96,117.35 130.59,122.72 v3(126.87,122.72)
  BOTTOM w0.102: v4(137.68,82.2) 137.61,82.27 137.61,84.95 137.76,85.1 137.76,88.36 139.06,89.66 139.06,92.12 138.61,92.58 138.61,96.47 138.3,96.78 138.3,98.64 v2(137.9,99.04) 137.9,99.34 136.38,100.85 v3(135.96,100.85)
BIST_ENABLE_1: length 7.5
  TOP w0.102: R78.1 133.9,201.33 134.67,201.33 134.77,201.43 R82.2 135.41,201.43 136.04,202.07 136.98,202.07 v1(137.44,201.61) ; R78.1 R81.2 ; R78.1 134.27,202.62 Q15.B
BKLT_ADJ: length 8.9
  TOP w0.165: CONVT1.9 9.5,117.69 9.5,117.69 11.17,119.36 R169.2 14.64,118.5 C123.1
BKLT_EN: length 15.2
  TOP w0.102: R172.2 C124.1 14.03,116.32 Q38.C ; Q38.C 14.03,113.2 13.65,112.82 R174.2 ; Q38.C 11.15,114.54 10.62,115.07 6.84,115.07 CONVT1.10
BKLT_EN1: length 2.8
  TOP w0.102: Q38.B 16.99,114.6 R173.2 v1(17.4,115.53)
BLUE_CRT: length 27.8
  TOP w0.102: v3(35.13,18.6) 35.67,19.15 C351.1 34.81,20.3 L20.2
  L3 w0.127: v3(45.77,20) 45.92,19.85 45.92,18.27 46.23,17.96 47.29,16.9 47.94,16.9 50.6,14.24 50.6,13.59 VGA1.3
  BOTTOM w0.102: v3(45.77,20) 45.77,20.11 44.46,21.42 44.23,21.42 42.95,22.7 v2(42.11,22.7) 40.52,24.29 39.74,24.29 38.58,23.14 38.58,22.1 37.73,21.24 37.53,21.24 U43.1 35.13,18.84 v3(35.13,18.6)
BOARD_A: length 23.5
  TOP w0.102: U29.M37 131.03,83.63 v4(131.03,83.18) ; R235.2 118.78,95.95 118.78,96.22 R236.1 119.63,96.31 119.63,95.41 120.75,94.29 124,94.29 125.86,92.44 125.86,92.13 126.26,91.72 126.26,91.62 127.92,89.97 128.25,89.97 129.09,89.14 129.09,89.05 v4(130.15,87.98)
  BOTTOM w0.102: v4(130.15,87.98) 130.04,87.86 130.04,86.5 130.29,86.24 130.52,86.24 130.84,85.93 130.84,85.23 130.61,85 v2(130.61,84.31) 131.03,83.88 v4(131.03,83.18)
BOARD_B: length 13.2
  TOP w0.102: U29.AA40 136.28,85.35 136.28,86.42 136.34,86.48 136.34,87.16 135.66,87.85 135.66,88.65 134.77,89.53 134.77,91.4 135.05,91.68 v1(135.05,92.16) 135.05,92.55 134.44,93.16 134.44,93.87 134.39,93.91 134.39,95.03 134.82,95.46 R231.1 133.96,96.69 R232.2
BOARD_C: length 15
  TOP w0.102: U29.AT30 144.52,80.04 144.84,80.36 145.1,80.36 145.17,80.29 145.58,80.29 145.79,80.5 147.5,80.5 147.73,80.27 149.45,80.27 149.98,79.74 151.02,79.74 151.08,79.8 152.1,79.8 R343.1 152.86,80.55 153.57,80.55 153.77,80.35 154.14,80.35 154.41,80.61 154.41,81.5 154.85,81.94 155.85,81.94 v1(155.85,81.95) 156.35,81.95 156.49,81.81 R334.2
BOOT1_PHASE1: length 2.2
  TOP w0.254: PR43.2 37.03,134.69 PC19.2 37.03,132.62 v1(37.08,132.57)
BUZZER_SPKR_R: length 85.7
  TOP w0.102: v3(187.63,98.13) 186.23,99.53 186.21,99.53 185.59,100.14 185.12,100.14 184.78,99.81 R227.1 ; v3(158.88,42.53) 158.75,42.53 158.42,42.2 158.42,41.88 C278.1
  BOTTOM w0.102: v3(187.63,98.13) 189.99,95.77 189.99,93.84 191.54,92.29 191.54,90.46 190.96,89.87 190.96,83.4 188.79,81.24 188.7,81.24 188.54,81.09 183.34,81.09 183.18,80.93 181.29,80.93 180.72,80.36 180.72,78.75 179.45,77.47 179.1,77.12 177.15,75.17 177.15,72.99 175.62,71.46 175.62,65.06 166.64,56.09 165.08,56.09 163.73,54.74 163.73,53.55 165.86,51.42 v2(165.86,49.01) 165.86,47.86 160.53,42.53 v3(158.88,42.53)
CAP_1: length 7.6
  TOP w0.203: U24.128 59.94,36.43 60.2,36.18
  TOP w0.508: 60.2,36.18 60.2,36.18 62.34,36.18 62.34,36.18 62.88,36.18 62.89,36.18 63.68,36.18 64.06,35.8 v1(64.06,35.37) 64.06,33.64 C308.1
CASA0#: length 44.7
  TOP w0.127: v4(72.93,90.53) 72.93,90.12 U13.G19 ; v1(59.66,90.31) 60.29,90.31 v4(60.96,90.98) ; MEM1.K3 50.92,98.42 50.8,98.55 50.8,98.74 50.92,98.87 51.63,98.87 51.83,98.68 51.83,98.68 51.95,98.56 v4(51.95,98.38)
  L3 w0.102: v4(72.93,90.53) 72.45,91.02 71.93,91.02 71.46,91.49 71.12,91.49 70.94,91.3 70.82,91.3
  L3 w0.165: 70.82,91.3 70.41,91.3 70.28,91.18 70.28,90.81 70.15,90.69 69.05,90.69 68.91,90.83 68.91,91.17 68.77,91.3 64.57,91.3 64.45,91.18 64.45,91.02 64.32,90.89 63.8,90.89 63.68,91.02 63.68,91.23 63.55,91.35 62.57,91.35 62.46,91.25 62.46,91.07 62.3,90.9 61.04,90.9 v4(60.96,90.98)
  L4 w0.165: v4(51.95,98.38) 52.1,98.53 52.82,98.53 52.89,98.46 53.8,98.46 54.68,97.58 55.8,97.58 56.04,97.83 57.99,97.83 59.77,96.05 59.77,93.74 59.89,93.61 61.09,93.61 61.21,93.48 61.21,93.08 61.09,92.95 59.89,92.95 59.77,92.82 59.77,92.42 59.89,92.29 61.11,92.29 61.24,92.16 61.24,91.76 61.11,91.63 59.89,91.63 59.77,91.5 59.77,89.7 59.89,89.57 60.83,89.57 60.96,89.7 v4(60.96,90.98)
  BOTTOM w0.127: MEM3.K3 52.94,98.42 52.84,98.52 52.09,98.52 v4(51.95,98.38)
CASA1#: length 42.6
  TOP w0.127: MEM2.K3 54.25,80.64 52.56,80.64 v4(52.09,80.17) ; v4(74.52,83.19) 74.52,83.98 74.65,84.11 74.88,84.11 74.98,84.21 74.98,84.46 74.86,84.59 74.65,84.59 74.52,84.72 74.52,85.07 74.14,85.46 74.14,85.59 73.69,86.03 73.69,86.28 73.44,86.53 73.44,86.72 72.83,87.34 U13.G16
  L3 w0.165: v3(57.82,85.78) 59.84,83.76 64.2,83.76 64.37,83.59 66.07,83.59 66.23,83.76 66.23,83.98 66.36,84.11 66.77,84.11 66.89,83.98 66.89,83.76 67.06,83.59 67.51,83.59 67.64,83.72 67.64,83.88 67.77,84.01 68.2,84.01 68.32,83.88 69.11,83.88 69.36,84.13 69.68,84.13 69.88,83.94 69.88,83.5 70,83.37 71.63,83.37 72.19,82.81 72.99,82.81 73.25,83.06 73.25,83.8 73.37,83.93 74.03,83.93 74.52,83.44 v4(74.52,83.19)
  L4 w0.102: 53.05,81.43 53.05,81.69 53.21,81.85 56.91,81.85
  L4 w0.165: 56.91,81.85 57.01,81.95 57.01,82.42 57.53,82.94 57.9,82.94 58.02,83.07 58.02,84.33 57.77,84.58 57.77,85 58.02,85.25 58.02,85.57 v3(57.82,85.78) ; 53.05,81.43 52.45,80.83 52.45,80.53 v4(52.09,80.17)
  BOTTOM w0.127: v3(57.82,85.78) 57.82,85.78 58.23,86.18 v2(58.53,86.18) ; v4(52.09,80.17) 52.09,79.98 51.99,79.88 51.69,79.88 51.48,80.09 51.48,80.29 51.53,80.34 51.53,80.55 51.32,80.76 MEM4.K3
CBN: length 5.5
  TOP w0.203: 174.73,87.87 174.88,88.01 U16.21
  TOP w0.508: 174.73,87.87 174.12,87.25 174.12,86.39 v3(174.09,86.37) 174.09,85.68 173.2,84.79 C196.2
CBP: length 3.7
  TOP w0.203: U16.24 176.3,85.83 176.15,85.68
  TOP w0.508: 176.15,85.68 176.15,84.82 v1(175.77,84.44) 174.88,84.44 C196.1
CK_14M_FLEX: length 14.5
  TOP w0.102: U29.AU8 144.9,67.95 145.26,67.59 145.58,67.59 145.75,67.75 147.66,67.75 150.98,64.44 150.98,64.07 152.94,62.11 152.94,61.54 153.82,60.66 153.95,60.66 v1(154.1,60.51) 154.12,60.51 154.58,60.05 R434.2
CK_14M_PCH: length 10.1
  TOP w0.102: R432.1 149.86,63.36 149.61,63.61 v1(148.67,63.61) 148.54,63.74 148.54,65.31 147.11,66.74 146.33,66.74 146.22,66.85 145.73,66.85 145.51,67.06 144.92,67.06 144.87,67.11 144.55,67.11 144.48,67.09 143.87,67.09 U29.AR7
CK_14M_SIO: length 136.4
  TOP w0.102: R446.1 152.5,58.33 v3(153.14,57.69) ; U24.7 62.4,40.38 63.98,38.79 v3(65.28,38.79)
  L3 w0.127: v3(65.28,38.79) 66.28,37.79 66.28,34.05 66.51,33.82 66.51,24.59 67.94,23.15 68.06,23.15 68.51,22.7 71.27,22.7 73.49,20.48 83.3,20.48 83.69,20.09 88.34,20.09 89.16,20.91 89.59,20.91 91.95,20.91 93.79,22.76 100.61,22.76 101.14,23.29 110.18,23.29 111.49,21.98 116.12,21.98 117.53,23.38 129.49,23.38 131.01,24.9 133.1,24.9 137.29,29.09 137.29,30.18 141.86,34.75 141.86,39.61 143.55,41.29 145.08,41.29 147.23,43.44 147.23,49.01 150.8,52.58 151.98,52.58 v3(152.12,52.43)
  L4 w0.127: v3(152.12,52.43) 152.22,52.54 152.25,52.54 152.93,53.22 152.93,57.49 v3(153.14,57.69)
  BOTTOM w0.102: v2(154.31,58.02) 153.47,58.02 v3(153.14,57.69)
CK_14M_TPM: length 47.7
  TOP w0.102: U23.13 U22.13 148.56,39.07 v3(149.22,39.73) ; R434.1 v1(156.06,58.59) 156.95,58.59 158.39,57.16 162.58,57.16 163.34,57.92 165.61,57.92 v3(166.17,57.36)
  L3 w0.127: v3(149.22,39.73) 149.22,43.38 149.1,43.5 149.01,43.59 149.01,48.2 150.7,49.89 151.7,49.89 153.58,51.77 161.33,51.77 165,55.44 165,56.14 166.17,57.31 v3(166.17,57.36)
CK_33M_PCI0: length 12
  TOP w0.102: R439.2 150.43,58.59 C865.2 149.45,59.57 v1(149.45,59.67) 149.22,59.9 149.22,60.94 149.05,61.12 149.05,61.14 148.73,61.45 148.72,61.45 148.08,62.09 148.08,62.77 148.06,62.8 148.06,65.5 147.07,66.49 146.29,66.49 146.13,66.64 145.44,66.64 U29.AV5
CK_33M_PCI1: length 12.9
  TOP w0.102: U29.AV7 145.05,67.35 145.51,67.35 145.79,67.07 146.28,67.07 146.41,66.94 147.7,66.94 C866.2 149.76,65.11 150.77,64.09 150.77,63.59 152.07,62.29 v1(152.07,61.98) 152.07,61.91 152.46,61.52 152.46,61.34 153.51,60.29 R447.2
CK_33M_PCI2: length 5.8
  TOP w0.102: U29.AU2 144.34,64.6 144.34,63.95 144.55,63.74 144.55,63.68 144.79,63.44 144.79,63.09 v4(144.83,63.05)
  BOTTOM w0.102: R994.2 146.49,61.57 v2(146,61.07) 145.54,61.53 C867.2 144.83,62.7 v4(144.83,63.05)
CK_33M_PCI3: length 6.2
  TOP w0.102: U29.AN9 142.6,68.91 v4(143.13,69.44)
  BOTTOM w0.102: v2(143.9,69.27) 143.89,69.27 143.89,69.28 143.29,69.28 v4(143.13,69.44) 143.13,69.43 142.19,68.49 C868.2 141.55,68.02 141.55,66.58 141.3,66.32 R989.2
CK_33M_PCI4: length 8.5
  TOP w0.102: U29.AU5 144.8,66.8 145.24,66.37 145.68,66.37 145.74,66.43 146.06,66.43 146.21,66.28 146.99,66.28 147.85,65.42 147.85,61.58 TP25.1
CK_96M_DREF_DN: length 10.2
  TOP w0.102: v4(142.5,69.45) 142.49,69.45 142.49,69.83 142.62,69.96 U29.AP11
  BOTTOM w0.102: 145.16,70.85 146.45,72.14 149.46,72.14 149.62,71.98 R986.1 ; 145.16,70.85 v2(145.41,70.6) ; 145.16,70.85 144.4,70.09 142.68,70.09 142.5,69.91 v4(142.5,69.45)
CK_96M_DREF_DP: length 10.2
  TOP w0.102: v4(141.85,69.44) 142.18,69.77 U29.AM11
  BOTTOM w0.102: 147.96,72.39 149.37,72.39 R981.1 ; 147.96,72.39 146.34,72.39 144.29,70.34 142.57,70.34 141.85,69.62 v4(141.85,69.44) ; 147.96,72.39 v2(147.96,72.75)
CK_100M_CPU_XDP_DN: length 244.1
  TOP w0.102: v3(111.23,207.15) 111.2,207.15 110.84,206.79 110.62,206.79 110.06,206.23 110.06,129.47 112.71,126.82 112.71,115.89 113.41,115.2 113.58,115.03 v3(113.58,114.14) ; v4(133.55,67.15) 133.83,66.86 U29.U6
  BOTTOM w0.102: 115.94,68.96 114.55,70.35 114.55,105.4 116.71,107.56 116.71,112.51 115.65,113.57 114.14,113.57 v3(113.58,114.14) ; 115.94,68.96 117.22,67.67 118.79,67.67 123.49,62.98 129.98,62.98 132.51,65.51 132.51,66.86 132.79,67.14 133.54,67.14 v4(133.55,67.15) ; 115.94,68.96 v2(115.72,68.74) ; 85.99,220.23 85.99,215.59 93.82,207.76 108.89,207.76 109.78,206.87 110.95,206.87 v3(111.23,207.15) ; 85.99,220.23 85.99,223.84 62.96,246.87 58.04,246.87 57.6,246.44 57.6,245.99 R637.1 ; 85.99,220.23 v2(86.31,220.23)
CK_100M_CPU_XDP_DP: length 243.6
  TOP w0.102: U29.U7 133.8,67.63 v4(133.57,67.86) ; v3(111.23,206.31) 111,206.54 110.73,206.54 110.31,206.12 110.31,129.58 112.97,126.92 112.97,116 113.83,115.14 113.83,114.74 113.93,114.64 114.34,114.64 114.44,114.54 v3(114.44,114.16)
  BOTTOM w0.102: 85.74,222.72 v2(85.34,222.72) ; 85.74,222.72 85.74,223.73 62.85,246.62 58.14,246.62 57.85,246.33 57.85,245.76 57.95,245.67 R636.1 ; 85.74,222.72 85.74,215.48 93.72,207.5 108.79,207.5 109.68,206.61 110.92,206.61 v3(111.23,206.31) ; v2(125.98,63.51) 125.98,63.23 ; 125.98,63.23 129.87,63.23 132.25,65.61 132.25,66.97 132.68,67.4 133.05,67.4 133.15,67.5 133.15,67.75 133.25,67.86 v4(133.57,67.86) ; 125.98,63.23 123.6,63.23 118.9,67.93 117.33,67.93 114.8,70.45 114.8,105.29 116.97,107.46 116.97,112.62 116.22,113.37 116.03,113.55 115.76,113.83 114.53,113.83 114.44,113.92 v3(114.44,114.16)
CK_CSI_PCH_IN_DN: length 5.8
  TOP w0.102: v4(128.48,71.8) 128.7,72.01 U29.G16
  BOTTOM w0.102: v2(127.41,73.19) 127.41,72.83 ; 127.41,72.83 127.91,72.83 128.39,72.35 128.39,71.88 v4(128.48,71.8) ; 127.41,72.83 126.9,72.83 126.65,73.08 124.98,73.08 R980.1
CK_CSI_PCH_IN_DP: length 5.7
  TOP w0.102: U29.F16 127.98,71.94 v4(127.84,71.8)
  BOTTOM w0.102: R978.1 124.72,72.64 124.91,72.83 125.73,72.83 ; 125.73,72.83 126.55,72.83 126.8,72.58 127.8,72.58 128.01,72.37 128.14,72.24 128.14,72.1 v4(127.84,71.8) ; 125.73,72.83 v2(125.73,72.5)
CK_DP_DN: length 140.2
  TOP w0.102: v3(76.95,151.32) 76.95,151.66 76.81,151.8 76.52,151.8 CPU1.U5 ; v3(133.09,58.66) 133.34,58.41 133.47,58.41 133.58,58.51 133.58,59.39 132.7,60.27 132.7,62.08 133.6,62.98 133.6,63.65 133.63,63.68 133.63,63.75 133.79,63.91 133.79,64.02 133.79,64.02 133.79,64.32 133.83,64.55 133.83,64.86 133.62,65.27 133.58,65.35 U29.T3
  BOTTOM w0.102: v2(94.64,122.13) 94.64,121.85 ; 94.64,121.85 96.24,121.85 109.94,108.16 109.94,79.46 109.18,78.7 109.18,68.18 119.05,58.3 132.73,58.3 v3(133.09,58.66) ; 94.64,121.85 92.74,121.85 84.56,130.04 84.56,134.7 84.66,134.8 84.66,135.1 84.56,135.21 84.56,135.51 84.66,135.61 84.66,135.92 84.56,136.02 84.56,136.18 84.25,136.49 84.25,136.64 84.06,136.83 83.91,136.83 83.7,137.04 83.7,137.21 83.5,137.41 83.33,137.41 83.13,137.61 83.13,137.78 82.93,137.98 82.75,137.98 82.55,138.19 82.55,138.36 82.35,138.56 82.18,138.56 81.98,138.76 81.98,138.93 81.78,139.13 81.6,139.13 81.4,139.34 81.4,139.51 81.2,139.71 81.03,139.71 80.83,139.91 80.83,140.08 80.63,140.28 80.45,140.28 80.25,140.49 80.25,140.66 80.05,140.86 79.88,140.86 79.68,141.06 79.68,141.23 79.48,141.43 79.3,141.43 79.1,141.64 79.1,141.81 78.9,142.01 78.73,142.01 78.53,142.21 78.53,142.38 78.33,142.58 78.15,142.58 77.95,142.79 77.95,142.96 77.75,143.16 77.58,143.16 77.38,143.36 77.38,143.53 77.18,143.74 77,143.74 76.61,144.13 76.61,147.93 76.38,148.16 76.38,149.3 76.74,149.66 76.74,150.75 76.48,151.01 76.48,151.62 76.64,151.77 76.81,151.77 76.95,151.63 v3(76.95,151.32)
CK_DP_DP: length 140.3
  TOP w0.102: v3(133.1,57.77) 133.43,58.1 133.53,58.1 133.83,58.4 133.83,59.5 132.96,60.37 132.96,61.97 133.86,62.87 133.86,63.69 133.99,63.82 133.99,63.93 133.99,63.94 133.99,64.3 134.03,64.53 134.03,64.91 133.95,65.07 133.88,65.2 133.88,65.77 U29.T5 ; v3(76.95,152.23) CPU1.U6
  BOTTOM w0.102: 77.72,142.66 83.73,136.65 84.19,136.19 84.3,136.08 84.3,129.93 92.63,121.6 96.14,121.6 109.68,108.05 109.68,79.57 108.92,78.81 108.92,68.07 118.95,58.05 132.82,58.05 v3(133.1,57.77) ; 77.72,142.66 76.35,144.03 76.35,147.83 76.13,148.06 76.13,149.41 76.48,149.77 76.48,150.65 76.23,150.9 76.23,151.73 76.74,152.23 v3(76.95,152.23) ; 77.72,142.66 v2(77.52,142.45)
CK_DPNS_R_DN: length 131.3
  TOP w0.102: v3(78.78,153.15) CPU1.W6 ; U29.W2 134.75,64.57 134.75,63.92 134.69,63.86 134.69,63.52 134.6,63.43 134.6,62.77 134.65,62.72 134.65,62 134.23,61.58 v4(134.23,61.36)
  BOTTOM w0.102: v4(134.23,61.36) 133.65,61.94 133.5,62.09 132.97,62.09 131.41,60.53 119.13,60.53 110.8,68.85 110.8,75.57 111.56,76.33 111.56,108.93 96.77,123.73 96.77,124.57 95.28,126.07 ; v3(78.78,153.15) 79.26,152.67 79.26,152.11 79.28,152.1 79.28,151.83 79.49,151.61 79.49,151.61 79.73,151.37 79.73,149.78 78.97,149.02 78.97,144.6 87.23,136.34 87.23,134.11 95.28,126.07 ; 95.28,126.07 v2(95.48,126.27)
CK_DPNS_R_DP: length 131.1
  TOP w0.102: v4(133.56,61.27) 134.39,62.1 134.39,62.72 134.4,62.73 134.4,63.51 134.49,63.6 134.49,63.94 134.55,64.01 134.55,64.85 U29.U2 ; v3(78.78,152.23) 78.44,152.23 78.32,152.11 CPU1.W5
  BOTTOM w0.102: v2(88.14,132.42) 88.35,132.63 ; 88.35,132.63 96.52,124.47 96.52,123.62 111.31,108.83 111.31,76.44 110.55,75.68 110.55,68.75 119.02,60.27 131.51,60.27 133.07,61.83 133.4,61.83 133.56,61.67 v4(133.56,61.27) ; 88.35,132.63 86.98,134.01 86.98,136.23 78.72,144.5 78.72,149.13 79.48,149.89 79.48,151.26 79.24,151.5 79.24,151.51 79.02,151.72 79.02,151.99 v3(78.78,152.23)
CK_GLAN_DN: length 130.4
  TOP w0.102: U29.W11 135.28,69.76 v4(135.62,70.1) ; v1(32.36,38.03) 32.36,37.68 ; 32.36,37.68 32.71,37.68 33.95,38.92 34.91,38.92 35.52,39.53 38.25,39.53 38.66,39.13 38.66,38.74 v3(38.86,38.54) ; 32.36,37.68 U26.16
  L4 w0.102: v3(38.86,38.54) 38.86,39 39.04,39.18 40.33,39.18 41.15,40 41.15,41.22 40.31,42.06 40.31,42.93 39.5,43.74 39.5,47.16 40.1,47.76 40.84,47.76 41.73,48.66 41.73,49.69 45.47,53.43 48.88,53.43 49.26,53.81 51.38,53.81 51.94,53.25 52.68,53.25 53.39,53.96 62.6,53.96 63.28,54.64 73,54.64 74.48,56.11 81.64,56.11 84.76,59.23 96.4,59.23 97.11,59.94 109.54,59.94 113.27,63.67 126.48,63.67 127.38,64.57 132.39,64.57 136.27,68.45 136.27,68.89 136.55,69.17 136.55,69.58 136.21,69.92 135.8,69.92 v4(135.62,70.1)
CK_GLAN_DP: length 130.4
  TOP w0.102: v3(38.1,38.54) 38.4,38.85 38.4,39.02 38.15,39.28 35.62,39.28 35.01,38.67 34.06,38.67 33.73,38.34 ; 33.73,38.34 v1(33.99,38.08) ; 33.73,38.34 32.82,37.43 31.62,37.43 31.47,37.28 U26.15 ; v4(135.61,69.4) 135.31,69.4 135.16,69.25 U29.W10
  L4 w0.102: v4(135.61,69.4) 135.61,69.55 135.75,69.69 136.11,69.69 136.32,69.49 136.32,69.27 136.04,68.99 136.04,68.55 132.3,64.8 127.29,64.8 126.38,63.9 113.18,63.9 109.45,60.17 97.02,60.17 96.3,59.46 84.66,59.46 81.55,56.34 74.38,56.34 72.91,54.87 63.18,54.87 62.5,54.19 53.3,54.19 52.59,53.48 52.04,53.48 51.48,54.04 49.17,54.04 48.79,53.65 45.37,53.65 41.5,49.79 41.5,48.75 40.74,47.99 40.01,47.99 39.27,47.25 39.27,43.65 40.08,42.83 40.08,41.97 40.92,41.13 40.92,40.09 40.23,39.4 38.95,39.4 38.59,39.05 38.2,39.05 38.1,38.95 v3(38.1,38.54)
CK_M_DDR0_A_DN: length 88
  TOP w0.165: v4(167.21,156.32) 167.07,156.18 167.07,155.8 166.07,154.8 165.28,154.8 165.18,154.7 DIMM1.103 ; v3(99.3,164.46) 99.12,164.46 98.7,164.03 CPU1.AY16
  L3 w0.191: v3(99.3,164.46) 99.46,164.29 101.8,164.29 102.26,163.83 102.26,162.87 102.61,162.51 103.23,162.51 103.42,162.7 103.42,163.15 103.82,163.55 104.37,163.55 104.77,163.15 104.77,162.7 104.96,162.51 105.34,162.51 105.53,162.7 105.53,163.15 105.92,163.55 106.48,163.55 106.88,163.15 106.88,162.7 107.07,162.51 136.76,162.51 143.46,155.81 144.98,155.81 145.32,155.47 145.32,154.49 145.51,154.3 145.89,154.3 146.08,154.49 146.08,155.25 146.48,155.65 147.04,155.65 147.43,155.25 147.43,154.49 147.62,154.3 148,154.3 148.19,154.49 148.19,155.25 148.61,155.67 149.7,155.67 150.04,155.33 156.66,155.33 157.02,154.97 157.02,154.49 157.21,154.3 157.59,154.3 157.78,154.49 157.78,154.97 158.14,155.33 160.7,155.33 162.08,156.71 164.01,156.71 164.53,157.23 166.81,157.23 167.11,156.92 167.11,156.6 167.21,156.51 v4(167.21,156.32)
  BOTTOM w0.165: v2(167,157.21) 167.21,157.01 v4(167.21,156.32)
CK_M_DDR0_A_DP: length 87.9
  TOP w0.165: v4(166.5,156.27) 166.61,156.27 166.8,156.08 166.8,155.91 165.95,155.06 165.46,155.06 165.23,155.3 DIMM1.101 ; CPU1.AY15 98.44,163.58 98.53,163.67 98.71,163.67 99.03,164 99.26,164 v3(99.5,163.76)
  L3 w0.191: v4(166.5,156.27) 166.73,156.51 166.73,156.52 166.82,156.61 166.82,156.8 166.69,156.94 164.65,156.94 164.13,156.42 162.21,156.42 160.82,155.04 158.26,155.04 158.07,154.85 158.07,154.37 157.71,154.01 157.09,154.01 156.73,154.37 156.73,154.85 156.54,155.04 149.92,155.04 149.58,155.38 148.74,155.38 148.48,155.13 148.48,154.37 148.12,154.01 147.5,154.01 147.14,154.37 147.14,155.13 146.91,155.36 146.6,155.36 146.38,155.13 146.38,154.37 146.01,154.01 145.39,154.01 145.03,154.37 145.03,155.35 144.86,155.51 143.34,155.51 136.64,162.22 106.95,162.22 106.58,162.58 106.58,163.03 106.36,163.26 106.05,163.26 105.82,163.03 105.82,162.58 105.46,162.22 104.84,162.22 104.48,162.58 104.48,163.03 104.25,163.26 103.94,163.26 103.71,163.03 103.71,162.58 103.35,162.22 102.49,162.22 101.97,162.74 101.97,163.71 101.68,164 99.74,164 v3(99.5,163.76)
  BOTTOM w0.165: v4(166.5,156.27) v2(166.5,155.3)
CK_M_DDR0_B_DN: length 79.8
  TOP w0.165: CPU1.AM21 91.05,168.61 v4(90.6,168.16) ; v4(152.38,155.85) 152.15,155.62 152.15,155.13 151.72,154.7 DIMM2.103
  L4 w0.102: v4(90.6,168.16) 90.68,168.09 90.68,168.09 90.83,167.93 90.83,167.56 91.08,167.31 92.56,167.31 93.08,167.83 93.68,167.83 93.99,167.52 95.78,167.52 96.37,168.12 97.52,168.12 97.9,167.74 97.9,167.74 98.16,167.47 100.02,167.47 100.07,167.43
  L4 w0.191: 100.07,167.43 100.76,166.73 107.64,166.73 118.73,155.65 121.34,155.65 121.53,155.46 121.53,155.09 121.89,154.73 122.52,154.73 122.88,155.09 122.88,155.46 123.07,155.65 123.45,155.65 123.64,155.46 123.64,155.09 124,154.73 124.63,154.73 124.99,155.09 124.99,155.46 125.18,155.65 125.56,155.65 125.75,155.46 125.75,155.09 126.11,154.73 126.73,154.73 127.09,155.09 127.09,155.46 127.29,155.65 127.67,155.65 127.86,155.46 127.86,155.09 128.22,154.73 129.1,154.73 129.45,155.08 129.45,155.41 129.69,155.65 142.6,155.65 143.52,154.73 148.22,154.73 148.62,155.13 151.52,155.13 151.98,155.58 152.1,155.58 v4(152.38,155.85)
  BOTTOM w0.165: v4(152.38,155.85) 151.45,154.92 v2(151.26,154.92)
CK_M_DDR0_B_DP: length 79.3
  TOP w0.165: v4(91.57,168.12) 91.25,168.12 91.06,167.93 91.06,167.76 CPU1.AM20 ; v4(151.59,155.86) 151.88,155.57 151.88,155.24 151.61,154.97 150.54,154.97 150.21,155.3 DIMM2.101
  L4 w0.102: v4(91.57,168.12) 91.57,168.52 91.5,168.59 91.19,168.59 91.04,168.44 91.04,167.64 91.16,167.51 92.47,167.51 92.99,168.03 93.77,168.03 94.07,167.73 95.69,167.73 96.29,168.33 97.6,168.33 98.1,167.83 98.1,167.82 98.25,167.68 100.23,167.68
  L4 w0.191: v4(151.59,155.86) 151.59,155.6 151.4,155.42 148.5,155.42 148.1,155.03 143.64,155.03 142.72,155.94 129.57,155.94 129.16,155.53 129.16,155.2 128.98,155.03 128.34,155.03 128.15,155.22 128.15,155.58 127.79,155.94 127.16,155.94 126.8,155.58 126.8,155.22 126.61,155.03 126.23,155.03 126.04,155.22 126.04,155.58 125.68,155.94 125.06,155.94 124.69,155.58 124.69,155.22 124.5,155.03 124.12,155.03 123.93,155.22 123.93,155.58 123.57,155.94 122.95,155.94 122.59,155.58 122.59,155.22 122.4,155.03 122.01,155.03 121.82,155.22 121.82,155.58 121.46,155.94 118.85,155.94 107.76,167.02 100.89,167.02 100.23,167.68
  BOTTOM w0.165: v2(151.38,156.83) 151.38,156.58 151.59,156.38 v4(151.59,155.86)
CK_M_DDR1_A_DN: length 89.1
  TOP w0.165: DIMM1.104 171.19,154.4 171.03,154.57 170.09,154.57 169.72,154.94 169.72,155.19 v4(169.48,155.43) ; v4(97.12,162.67) 96.66,163.12 CPU1.AV15
  L3 w0.191: v4(169.48,155.43) 169.48,154.96 169.28,154.76 168.57,154.76 167.61,155.72 163.56,155.72 162.77,154.92 161.68,154.92 160.11,153.36 154.68,153.36 153.78,154.26 150.31,154.26 149.41,153.36 144.57,153.36 140.01,157.92 139.34,157.92 138.87,157.45 138.5,157.45 138.09,157.87 138.09,158.13 138.63,158.67 138.63,159.23 138.23,159.63 137.67,159.63 137.13,159.09 136.87,159.09 136.59,159.36 136.59,159.63 137.03,160.06 137.03,160.62 136.64,161.02 136.08,161.02 135.64,160.58 135.37,160.58 134.38,161.57 102.16,161.57 101.04,162.69 99.67,162.69 98.9,163.46 97.76,163.46 97.46,163.15 97.46,163.01 v4(97.12,162.67)
  BOTTOM w0.165: v4(169.48,155.43) 169.54,155.49 v2(169.54,156.57)
CK_M_DDR1_A_DP: length 89.6
  TOP w0.165: CPU1.AW15 98,162.64 v4(98.03,162.64) ; v4(170.21,155.43) 169.99,155.21 169.99,155.05 170.21,154.83 171.26,154.83 171.43,155 DIMM1.102
  L3 w0.191: v4(170.21,155.43) 170.21,154.97 170.02,154.79 169.73,154.79 169.4,154.47 168.45,154.47 167.49,155.42 163.68,155.42 162.89,154.63 161.8,154.63 160.24,153.07 154.56,153.07 153.66,153.97 150.43,153.97 149.53,153.07 144.45,153.07 139.89,157.63 139.47,157.63 139,157.16 138.38,157.16 137.79,157.74 137.79,158.26 138.33,158.79 138.33,159.11 138.11,159.33 137.79,159.33 137.26,158.79 136.74,158.79 136.3,159.24 136.3,159.75 136.74,160.18 136.74,160.5 136.52,160.72 136.2,160.72 135.76,160.29 135.25,160.29 134.26,161.28 102.04,161.28 100.92,162.4 99.55,162.4 98.78,163.17 97.89,163.17 97.75,163.03 97.75,162.76 97.87,162.64 v4(98.03,162.64)
  BOTTOM w0.165: v2(171.45,156.45) 171.22,156.45 v4(170.21,155.43)
CK_M_DDR1_B_DN: length 74.7
  TOP w0.165: DIMM2.104 156.46,154.4 156.12,154.73 155.07,154.73 153.96,155.84 v4(153.9,155.84) ; v4(92.46,168.11) 92.95,168.6 CPU1.AP21
  L4 w0.102: v4(92.46,168.11) 92.62,168.27 93.8,168.27 94.14,168.61 94.22,168.61 95.1,169.49 96.48,169.49 97.14,168.83 98.5,168.83 99.18,168.16 100.44,168.16 100.48,168.11
  L4 w0.191: 100.48,168.11 100.92,167.67 108.2,167.67 108.49,167.39 119.29,156.59 143.06,156.59 143.97,155.67 147.83,155.67 148.63,156.47 153.98,156.47 154.13,156.33 154.13,156.07 v4(153.9,155.84)
  BOTTOM w0.165: v4(153.9,155.84) v2(153.9,154.92)
CK_M_DDR1_B_DP: length 74.8
  TOP w0.165: v4(154.67,155.81) 154.65,155.79 154.65,155.53 155.18,155 DIMM2.102 ; CPU1.AP22 92.97,169.52 v4(93.43,169.07)
  L4 w0.102: v4(93.43,169.07) 93.41,169.08 93.12,169.08 92.94,168.9 92.94,168.58 93.04,168.48 93.72,168.48 94.06,168.82 94.14,168.82 95.02,169.7 96.56,169.7 97.22,169.04 98.59,169.04 99.26,168.36 100.63,168.36 100.64,168.37
  L4 w0.191: 100.64,168.37 101.04,167.97 108.33,167.97 109.12,167.17 119.41,156.88 143.18,156.88 144.09,155.97 147.71,155.97 148.51,156.77 154.11,156.77 154.42,156.45 154.42,156.06 154.67,155.81 v4(154.67,155.81)
  BOTTOM w0.165: v2(155.2,156.62) 155.16,156.62 154.67,156.13 v4(154.67,155.81)
CK_P_33M_LPCP80: length 43.3
  TOP w0.102: R439.1 151.38,59.91 151.35,59.94 151.35,60.43 v3(150.54,61.23) ; v3(143.81,55.56) 143.67,55.56 141.86,53.75 141.86,50.1 v3(141.07,49.31)
  L3 w0.127: LPC1.1 123.15,39.25 130.35,39.25 131.15,40.04 131.15,40.45 132.97,42.27 132.97,42.77 134.36,44.15 135.92,44.15 v3(141.07,49.31)
  BOTTOM w0.102: v3(150.54,61.23) 150.75,61.03 150.75,60.31 146,55.56 v3(143.81,55.56)
CK_P_33M_SIO: length 142.9
  TOP w0.102: U24.16 61.93,43.98 62.15,43.76 62.15,43.75 62.36,43.54 63.19,43.54 v3(63.28,43.45)
  L3 w0.127: v3(63.28,43.45) 63.28,39.47 65.77,36.98 65.77,33.84 66,33.61 66,24.37 67.73,22.64 67.85,22.64 68.92,21.57 71.08,21.57 72.68,19.97 83.09,19.97 83.48,19.58 88.55,19.58 89.38,20.41 92.16,20.41 94,22.25 100.82,22.25 101.35,22.78 109.97,22.78 111.28,21.47 116.33,21.47 117.74,22.87 129.7,22.87 131.04,24.22 133.13,24.22 134.59,25.68 135.7,25.68 137.79,27.77 137.79,29.96 143.13,35.3 143.13,37.7 142.39,38.44 v3(142.39,39.23)
  L4 w0.127: v3(143.43,56.42) 143.13,56.12 143.13,49.75 143.01,49.63 143.01,46.14 142.68,45.81 142.6,45.73 142.6,42.79 142.43,42.63 142.43,39.27 v3(142.39,39.23)
  BOTTOM w0.102: R989.1 141.15,64.65 141.15,62.83 141.58,62.39 141.58,60.71 142.11,60.18 142.11,58.63 142.74,58.01 143.78,58.01 v2(144.15,57.64) 144.15,57.24 143.51,56.61 143.51,56.5 v3(143.43,56.42)
CK_P_33M_TPM: length 46.6
  TOP w0.102: v3(145.52,39.86) 145.31,40.07 U22.21 U23.21 ; v3(165.35,57.24) v1(163.45,57.24) 162.89,56.68 155.14,56.68 153.51,58.31 R447.1
  L3 w0.127: v3(145.52,39.86) 145.69,39.86 146.43,40.6 146.91,40.6 148.5,42.19 148.5,48.41 150.75,50.66 151.22,50.66 152.85,52.28 161.12,52.28 164.49,55.65 164.49,56.37 v3(165.35,57.24)
CK_PCH_33M_FB: length 37.2
  TOP w0.102: v4(141.48,75.98) 141.83,75.62 U29.AM22
  L4 w0.127: v4(141.48,75.98) 141.48,75.98 141.48,75.52 141.35,75.4 140.51,75.4 140.39,75.27 140.39,74.96 140.51,74.84 142.08,74.84 142.8,75.56 142.8,76.41 142.9,76.51 143.28,76.51 143.39,76.41 143.39,74.51 143.51,74.38 143.77,74.38 143.89,74.51 143.89,75.7 144,75.8 144.4,75.8 144.53,75.68 144.53,74.41 144.65,74.28 144.98,74.28 145.11,74.41 145.11,75.68 145.24,75.8 145.72,75.8 145.85,75.68 145.85,73.75 145.72,73.62 145.03,73.62 144.91,73.49 144.91,73.11 145.03,72.98 145.72,72.98 146.02,72.68 148.41,72.68 150.88,70.21 150.88,67.93 150.08,67.13 150.08,64.46 149.35,63.74 149.35,62.96 149.11,62.72 v3(149.1,62.72)
  BOTTOM w0.102: v3(149.1,62.72) 148.21,62.72 147.5,62.01 R994.1 ; v2(141.86,75.04) 141.86,75.42 141.48,75.8 v4(141.48,75.98)
CK_PE_100M_16PORT_DN: length 100
  TOP w0.102: v3(131.42,55.74) 132.13,56.45 133.35,56.45 134.44,57.54 134.44,59.58 135.51,60.65 135.51,62.45 135.99,62.93 135.99,64.38 135.75,64.62 135.75,64.87 136.11,65.23 U29.AA3 ; U13.AK32 90.15,98.82 92.66,101.33 92.66,103.67 93.29,104.31 93.29,104.97 94.15,105.83 98.75,105.83 102.62,101.96 102.62,94.85 v3(102.91,94.55)
  BOTTOM w0.102: v2(109.27,63.86) 109.02,63.62 ; 109.02,63.62 113.92,58.72 114.61,58.72 118.71,54.62 128.64,54.62 129.12,55.1 131.28,55.1 131.49,55.31 131.49,55.66 v3(131.42,55.74) ; 109.02,63.62 106.33,66.31 106.33,69.45 105.69,70.09 105.69,75.99 105.21,76.47 105.21,87.92 102.62,90.51 102.62,94.25 v3(102.91,94.55)
CK_PE_100M_16PORT_DP: length 100
  TOP w0.102: U29.AA2 136.24,64.55 136.24,62.82 135.77,62.34 135.77,60.54 134.7,59.47 134.7,57.43 133.46,56.19 132.23,56.19 132.12,56.08 132.12,55.9 132.21,55.81 132.21,55.81 v3(132.28,55.74) ; v3(102.06,94.55) 102.36,94.85 102.36,101.86 98.65,105.57 94.26,105.57 93.55,104.86 93.55,104.2 92.91,103.57 92.91,101.23 90.59,98.91 90.59,98.68 90.15,98.24 U13.AK30
  BOTTOM w0.102: v3(102.06,94.55) 102.36,94.25 102.36,90.41 104.96,87.81 104.96,76.36 105.44,75.89 105.44,69.99 106.08,69.35 106.08,66.21 113.61,58.68 113.82,58.47 114.5,58.47 118.6,54.37 121.36,54.37 ; 121.36,54.37 128.74,54.37 129.23,54.85 131.39,54.85 v3(132.28,55.74) ; 121.36,54.37 v2(121.36,53.98)
CK_PE_100M_MCP_DN: length 131.1
  TOP w0.102: v3(77.86,150.41) 77.86,150.69 77.7,150.86 CPU1.V4 ; v3(131.57,59.67) 131.8,59.44 131.95,59.44 132.1,59.59 132.1,62.12 133.1,63.11 133.1,63.79 133.38,64.08 133.38,64.4 133.21,64.57 133.21,65.05 133.08,65.18 U29.R2
  BOTTOM w0.102: v3(131.57,59.67) 131.57,59.55 131.29,59.27 119.24,59.27 109.99,68.52 109.99,76.01 110.75,76.77 110.75,108.52 92.16,127.12 ; 92.16,127.12 v2(92.35,127.31) ; 92.16,127.12 86.42,132.85 86.42,135.74 77.66,144.5 77.66,149.03 77.32,149.37 77.32,150.67 77.54,150.89 77.76,150.89 77.86,150.78 v3(77.86,150.41)
CK_PE_100M_MCP_DP: length 131.2
  TOP w0.102: v3(131.57,58.81) 131.95,59.19 132.06,59.19 132.36,59.48 132.36,62.01 133.35,63.01 133.35,63.76 133.58,63.99 133.58,64.68 U29.T2 ; v3(77.86,151.32) CPU1.V5
  BOTTOM w0.102: v3(131.57,58.81) 131.37,59.01 119.13,59.01 109.73,68.41 109.73,76.11 110.5,76.87 110.5,108.42 89.5,129.41 ; v3(77.86,151.32) 77.68,151.14 77.43,151.14 77.07,150.77 77.07,149.26 77.41,148.92 77.41,144.39 86.17,135.63 86.17,132.74 89.5,129.41 ; v2(89.28,129.19) 89.5,129.41
CK_SATA_PCH_DN: length 6
  TOP w0.102: U29.H35 129.03,82.53 v4(128.89,82.67)
  BOTTOM w0.102: v2(126.7,85.86) 127.03,85.86 127.48,86.32 R939.1 127.76,85.02 127.91,84.87 127.91,83.78 128.89,82.8 v4(128.89,82.67)
CK_SATA_PCH_DP: length 5
  TOP w0.102: v4(128.91,83.39) 128.91,83.24 129.06,83.09 129.35,83.09 U29.H36
  BOTTOM w0.102: 128.17,84.44 128.17,84.98 128.01,85.13 128.01,85.76 128.11,85.86 128.32,85.86 R938.1 ; 128.17,84.44 v2(128.52,84.44) ; 128.17,84.44 128.17,83.88 128.65,83.39 v4(128.91,83.39)
CK_XDP_S_DN: length 8.6
  BOTTOM w0.102: 54.54,243.08 55.11,243.65 57.4,243.65 57.63,243.88 57.63,244.43 R637.2 ; 54.54,243.08 53.48,242.01 53.48,241.38 53.36,241.26 XDPC1.42 ; 54.54,243.08 v2(54.33,243.29)
CK_XDP_S_DP: length 9
  BOTTOM w0.102: XDPC1.40 53.86,241.26 53.74,241.38 53.74,241.91 55.22,243.39 56.87,243.39 ; v2(56.87,243.04) 56.87,243.39 ; 56.87,243.39 57.5,243.39 57.88,243.77 57.88,244.67 57.98,244.78 R636.2
CKEA0: length 54.9
  TOP w0.127: v4(58.12,98.9) 58.1,98.88 56.92,98.88 56.78,99.03 56.37,99.03 55.96,98.62 MEM1.K9 ; U13.K20 74.63,91.26 v4(74.63,91.47) ; v1(45.26,97.87) 45.81,98.41 48.31,98.41 48.71,98.81 v4(48.98,98.81)
  L3 w0.165: v4(48.98,98.81) 48.28,98.81 48.16,98.94 48.16,99.65 48.28,99.78 49.37,99.78 49.48,99.67 49.48,99.29 49.68,99.08 50.93,99.08 51.33,99.49 51.33,99.57 51.79,100.03 51.85,100.03 52.1,100.28 v4(52.22,100.28) 52.33,100.39 52.96,100.39 53.21,100.14 53.21,99.95 54.04,99.12 54.04,98.54 54.47,98.11 55.06,98.11 55.4,98.46 55.82,98.46 56.37,97.9 58.87,97.9 59.54,97.24 66.07,97.24 66.51,96.8 70.65,96.8 70.91,96.53 70.91,96.53 71.17,96.27 71.18,96.27 71.95,95.49 73.13,95.49 73.93,96.29 73.93,96.29 74.3,96.66 74.8,96.66 75.16,96.3 75.6,96.3 75.9,96 75.9,92.75 75.08,91.92 75.05,91.92 74.8,91.67 74.8,91.65 v4(74.63,91.47)
  L4 w0.165: v4(52.22,100.28) 52.33,100.39 52.96,100.39 52.96,100.39 53.22,100.39 54.07,99.53 55.03,99.53 55.4,99.17 56.87,99.17 57.15,98.88 57.86,98.88 57.88,98.9 v4(58.12,98.9)
  BOTTOM w0.127: MEM3.K9 49.92,98.42 50.02,98.51 50.02,98.74 49.89,98.87 49.04,98.87 v4(48.98,98.81)
CKEA1: length 47.7
  TOP w0.127: MEM2.K9 48.82,80.76 v3(48.81,80.78) 48.33,81.26 v1(47,81.26) ; U13.J17 74.15,88.2 v4(74.41,87.94)
  L3 w0.165: v3(48.81,80.78) 48.83,80.8 50.94,80.8 51.2,80.54 51.2,80.35 51.81,79.73 52.28,79.73 52.56,80.01 52.62,80.01 53.04,80.43 53.15,80.43 53.34,80.62 53.48,80.62 53.93,81.08 v4(53.93,81.12) 53.93,81.4 54.13,81.6 55.8,81.6 56.41,80.99 56.77,80.99 57.03,81.24 57.03,81.68 57.58,82.23 58.67,82.23 58.75,82.15 63.54,82.15 63.7,81.98 66.85,81.98 67.08,82.21 68.99,82.21 69.91,81.29 71.53,81.29 71.74,81.08 73.92,81.08 74.49,81.65 74.8,81.65 75.22,82.07 75.22,82.23 75.86,82.87 75.86,83.27 75.6,83.53 75.36,83.53 74.96,83.92 74.96,84.28 76.18,85.5 76.18,86.63 75.29,87.53 74.96,87.53 74.55,87.94 v4(74.41,87.94)
  L4 w0.165: v4(55.57,81.16) 55.74,81.33 56.07,81.33 56.23,81.17 56.23,80.88 55.92,80.57 54.11,80.57 54.01,80.47 54.01,80.31 53.88,80.18 53.7,80.18 53.44,80.43 53.44,80.59 53.74,80.88 53.74,80.93 v4(53.93,81.12)
  BOTTOM w0.127: v4(55.57,81.16) 55.86,81.16 55.96,81.06 MEM4.K9
CLINK_CLK_LAN: length 177.7
  TOP w0.102: v4(133.57,82.71) 133.57,82.72 U29.U36 ; R7.1 103.91,235.23 103.91,235.45 103.41,235.95 102.62,235.95 v3(102.57,235.9) ; v3(114.43,218.55) 114.43,217.28 v1(115.93,215.78) 117.17,214.54 117.17,213.23 117.17,208.84 117.38,208.63 118.71,207.3 120.62,207.3 122.25,205.67 123.79,205.67 125.55,203.91 125.55,202.95 126.34,202.16 126.34,193.26 124.56,191.48 124.56,190.52 124.56,124.38 124.69,124.25 124.69,122.98 125.96,121.71 v3(125.96,121.6)
  L4 w0.127: v3(114.43,218.55) 114.43,219.34 109.63,224.14 109.63,227.24 108.86,228 108.86,233.4 107.17,235.09 103.89,235.09 103.07,235.9 v3(102.57,235.9) ; v3(133.56,88.96) 131.74,90.78 131.74,92.87 131.66,92.95 131.66,93.97 131.74,94.04 131.74,95.33 132.74,96.33 132.74,99.18 133.85,100.28 133.85,100.95 134.34,101.44 134.53,101.63 134.53,107.34 134.79,107.59 134.82,108.87 134.82,112.59 125.96,121.44 v3(125.96,121.6)
  BOTTOM w0.102: v4(133.57,82.71) 133.8,82.94 133.8,83.04 133.95,83.19 133.95,83.54 133.5,83.99 133.5,88.91 v3(133.56,88.96)
CLINK_CLK_LAN_1: length 5.8
  TOP w0.102: R7.2 105.85,234.93 v1(106.43,235.52) 106.66,235.75 107.8,235.75 108.6,236.55 NGFF1.42
CLINK_DATA_LAN: length 181
  TOP w0.102: v4(133.56,82) 133.62,82 U29.U35 ; v3(115.44,218.55) 115.44,217.15 117.53,215.07 117.53,213.38 117.53,208.99 118.86,207.65 120.78,207.65 122.4,206.03 123.94,206.03 125.91,204.06 125.91,203.09 126.7,202.31 126.7,193.12 124.92,191.34 124.92,190.66 124.92,190.66 124.92,124.53 125.04,124.4 125.04,123.28 v3(125.96,122.36) ; R5.1 103.91,235.95 103.28,236.58 v1(103.1,236.58) 102.59,237.09 v3(102.59,237.47)
  L4 w0.127: v3(115.44,218.55) 114.81,219.19 114.81,219.5 113.44,220.87 113.44,221.95 110.01,225.38 110.01,227.4 109.25,228.16 109.25,233.55 106.21,236.58 103.15,236.58 102.59,237.14 v3(102.59,237.47) ; v3(125.96,122.36) 125.49,121.89 125.49,121.26 134.4,112.34 134.4,107.75 134.15,107.5 134.15,101.79 133.46,101.1 133.46,100.44 132.36,99.34 132.36,96.49 131.36,95.49 131.36,94.2 131.28,94.12 131.28,92.79 131.36,92.71 131.36,90.54 133.52,88.38 v3(134.14,88.38)
  BOTTOM w0.102: v3(134.14,88.38) 133.86,88.1 133.7,87.94 133.7,84.08 134.15,83.63 134.15,83.11 134,82.96 134,82.47 133.56,82.03 v4(133.56,82)
CLINK_DATA_LAN_1: length 5.6
  TOP w0.102: NGFF1.40 108.59,237.05 107.92,236.38 v1(107.37,236.38) 106.22,236.38 105.79,235.95 R5.2
CLINK_RST_LAN_N: length 189.1
  TOP w0.102: v3(125.96,123.12) 125.96,123.24 125.5,123.7 125.5,124.53 125.27,124.76 125.27,191.19 127.05,192.97 127.05,202.45 126.26,203.24 126.26,204.21 124.08,206.38 122.89,206.38 121.21,208.06 118.95,208.06 117.88,209.13 117.88,214 118.57,214.69 119.67,214.69 119.95,214.41 120.33,214.41 120.85,214.93 120.85,219.26 v3(121.03,219.44) ; U29.U34 133.67,81.34 v4(133.58,81.34) ; v3(103.4,237.45) 103.89,236.97 R3.1
  L4 w0.127: v3(103.4,237.45) 103.78,237.07 106.76,237.07 107.96,235.86 107.96,235.45 108.24,235.18 108.65,235.18 109.88,233.94 110.39,233.44 110.39,226.02 114.27,222.13 114.27,220.94 115.93,219.29 116.97,219.29 117.12,219.44 v3(121.03,219.44) ; v3(125.96,123.12) 125.11,122.27 125.11,121.1 134.02,112.18 134.02,107.91 133.77,107.65 133.77,101.95 133.08,101.26 133.08,100.6 130.97,98.49 130.97,94.36 130.34,93.72 130.34,90.88 130.76,90.46 130.81,90.46 v4(130.98,90.29)
  BOTTOM w0.102: v4(130.98,90.29) 132.57,90.29 133.44,89.42 133.72,89.42 134.57,88.56 134.57,87.82 v2(134.24,87.49) 133.99,87.23 133.99,84.62 133.91,84.54 133.91,84.21 134.36,83.76 134.36,83.03 134.2,82.87 134.2,81.97 v4(133.58,81.34)
CLINK_RST_LAN_N_1: length 5.3
  TOP w0.102: R3.2 105.33,237.21 v1(106.4,237.21) 108.07,237.21 108.41,237.55 NGFF1.38
CLKA0: length 50
  TOP w0.127: U13.H26 73.75,95.14 v4(73.75,95.14) ; v4(47.72,99.97) 47.45,99.7 46.9,99.7 R209.1 ; MEM1.J7 53.81,99.46 53.55,99.57 53.03,99.57 52.83,99.54 52.73,99.53 v4(52.1,99.33)
  L4 w0.152: v4(73.75,95.14) 73.57,95.14 73.47,95.23 73.03,95.23 72.94,95.32 72.13,95.32 70.4,97.05 70.4,97.12 59.54,107.98 53.43,107.98 52.28,106.83 52.28,106.51 51.93,106.16 51.58,106.16 49.79,104.37 49.79,100.86 50.39,100.26 51.1,100.26 51.9,99.46 51.97,99.46 v4(52.1,99.33) 51.93,99.17 49.75,99.17 49.32,99.59 48.09,99.59 v4(47.72,99.97)
  BOTTOM w0.127: MEM3.J7 51.36,99.41 51.36,99.7 51.53,99.87 52.01,99.87 52.04,99.84 52.16,99.84 52.31,99.69 52.31,99.54 v4(52.1,99.33) ; v2(46.94,99.68) 47.43,99.68 v4(47.72,99.97)
