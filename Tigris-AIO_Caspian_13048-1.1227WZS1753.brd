# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WEA1#: length 41.2
  TOP w0.127: v4(73.75,82.39) 73.48,82.39 73.35,82.51 U13.H10 ; MEM2.L3 53.14,81.56 52.74,81.16 52.2,81.16 v4(51.73,81.63)
  L3 w0.165: v4(73.75,82.39) 73.59,82.22 71.62,82.22 71.3,81.9 70.82,81.9 70.69,82.03 70.69,82.61 70.56,82.74 70.13,82.74 70,82.61 70,82.48 69.85,82.33 69.57,82.33 69.1,82.81 69.1,83.06 68.81,83.35 68.36,83.35 67.84,82.83 64.06,82.83 63.89,83 58.32,83 58.02,83.3 58.02,84.12 57.76,84.39 56.96,84.39 56.95,84.4 56.13,84.4 56.01,84.52 56.01,84.94 56.13,85.06 v4(57.02,85.06)
  L4 w0.102: v4(51.73,81.63) 51.78,81.63 52.42,82.26 54.59,82.26 54.72,82.4 54.72,82.62 54.82,82.73 55.23,82.73 55.33,82.62 55.33,82.42 55.43,82.32 55.73,82.32
  L4 w0.165: 55.73,82.32 55.85,82.45 55.85,83.01 55.74,83.12 54.89,83.12 54.79,83.22 54.79,83.73 54.89,83.83 55.74,83.83 56.37,84.46 56.37,85.51 56.5,85.64 56.9,85.64 57.02,85.51 v4(57.02,85.06)
  BOTTOM w0.127: MEM4.L3 50.96,81.76 50.81,81.76 50.71,81.66 50.71,81.42 50.71,81.41 50.71,81.21 50.81,81.11 51.63,81.11 51.73,81.21 v4(51.73,81.63) ; v4(57.02,85.06) 57.15,84.94 v2(58.18,84.94)
WEBCAM_DET: length 179.8
  TOP w0.102: WEBCM1.7 164.49,224.65 164.49,223.35 163.98,222.84 162.31,222.84 162.22,222.93 PC2.2 R30.2 160.29,222.93 159.97,222.61 158.12,222.61 v3(156.41,220.91) ; v4(149.61,83.74) 149.33,83.46 148.74,83.46 148.58,83.3 148.07,83.3 147.07,82.3 146.18,82.3 146.11,82.36 145.78,82.36 145.55,82.59 U29.AV35
  L3 w0.127: v4(149.61,83.74) 150.45,83.74 151.38,84.67 151.38,85.46 155.79,89.87 155.79,93.53 155.38,93.93 155.38,95.56 157.76,97.94 157.76,107.3 160.15,109.68 160.15,112 166.19,118.04 169.59,118.04 170.36,118.04 170.37,118.04 171,118.04 175.91,122.95 175.91,145.03 175.81,145.13 175.81,151.01 175.41,151.41 175.41,158.71 176.2,159.5 176.2,190.09 174.93,191.36 174.12,191.36 171.51,193.96 168.73,193.96 155.63,207.07 155.63,216.38 156.41,217.17 v3(156.41,220.91)
  BOTTOM w0.102: v3(156.41,220.91) v2(157.23,220.91)
XCLK_RCOMP: length 2.9
  TOP w0.203: v4(133.48,69.4) 133.39,69.4 U29.R11
  BOTTOM w0.203: R982.2 132.94,68.44 133.68,68.44 133.83,68.59 v2(133.83,68.64) 133.83,69.04 v4(133.48,69.4)
XDP_DBRESET_N: length 76.7
  TOP w0.102: CPU1.G40 68.26,187.78 70.37,189.89 70.37,197.47 67.26,200.58 67.26,201.32 66.57,202 66.57,202.64 66.34,202.87 66.34,204.16 65.41,205.1 v3(65.41,205.85)
  BOTTOM w0.102: R744.2 65.57,204.9 v2(65.51,204.96) 65.41,205.06 v3(65.41,205.85) 65.41,208.21 47.18,226.43 47.18,235.83 48.45,237.09 51.05,237.09 51.86,237.9 XDPC1.48 51.86,243.05 53.14,244.33 54.08,244.33 54.52,244.78 C367.1
XDP_PLTRST_N: length 5.7
  BOTTOM w0.102: XDPC1.41 53.36,230.3 v2(52.68,229.63) 52.25,229.19 R697.2
XDP_PWR_DEBUG: length 39
  TOP w0.102: v3(70.48,209.28) 70.48,207.78 R74.1 ; R38.1 R35.2 60.92,221.01 v3(60.88,221.04)
  BOTTOM w0.102: XDPC1.45 52.36,230.55 51.79,229.98 51.79,226.29 52.21,225.87 56.06,225.87 v3(60.88,221.04) 70.48,211.44 v2(70.48,210.5) v3(70.48,209.28)
XDP_PWRGD: length 6.5
  BOTTOM w0.102: R696.2 R695.1 54.38,228.75 v2(54.38,229.68) 53.86,230.2 XDPC1.39
XDP_VR_READY: length 6.6
  BOTTOM w0.102: XDPC1.47 51.86,230.76 51.1,230.01 v2(51.1,229.65) R698.2 C394.1
XTAL_25M_PCH_IN: length 28.2
  TOP w0.102: v4(131.06,67.78) 131.67,67.78 U29.N7 ; X3.3 118.12,50.7 118.12,51.94 117.79,52.28 C259.1 117.79,54.03 R467.1 119.11,55.64 122.24,55.64 v3(123.34,56.74)
  L3 w0.127: v4(131.06,67.78) 130.43,67.14 130.43,61.32 126.54,57.44 123.96,57.44 123.37,56.84 123.37,56.77 v3(123.34,56.74)
XTAL_25M_PCH_OUT: length 24.7
  TOP w0.102: X3.1 118.93,51.99 C260.1 118.93,53.93 R467.2 121.68,54.17 124.1,56.6 v3(124.61,56.6) ; v4(131.12,67.07) 131.67,67.07 U29.N6
  L3 w0.127: v4(131.12,67.07) 131.12,61.12 126.81,56.8 124.82,56.8 v3(124.61,56.6)
XTALIN: length 9.5
  TOP w0.102: U13.AM28 92.23,97.14 v3(92.58,96.78) 92.94,97.14 94.43,97.14 C756.1 95.31,97.2 R1188.1 96.52,97.77 98.15,97.77 99.15,96.77 X5.1
XTALOUT: length 8
  TOP w0.102: X5.3 97.04,98.41 R1188.2 94.55,98.41 C757.1 92.82,98.35 v3(92.71,98.23) 92,97.52 90.53,97.52 U13.AK28

## Copper pours and planes (outline as drawn)
5V_PWR on TOP: 87.76,22.34 86.54,23.56 86.54,30.9 87.25,31.61 91.24,31.61 91.97,30.87 91.97,28.15 93.09,27.03 96.14,27.03 96.77,27.67 96.77,30.59 97.03,30.84 99.01,30.84 99.07,30.79 99.07,27.86 99.68,27.25 99.68,27.01 101.06,27.01 101.22,26.85 101.22,24.37 100.84,23.99 99.9,23.99 98.25,22.34 ; 2 cut-outs
5V_PWR on BOTTOM: 87.76,22.34 86.54,23.56 86.54,30.9 87.25,31.61 91.24,31.61 91.97,30.87 91.97,28.15 93.09,27.03 96.14,27.03 96.77,27.67 96.77,30.59 97.03,30.84 99.69,30.84 99.82,30.72 99.82,23.1 99.06,22.34
12V_DUAL on TOP: 13.89,127.34 13.41,127.82 13.41,129.75 14.5,130.84 14.5,131.4 14.61,131.51 14.61,133.21 15.11,133.71 18.41,133.71 22.07,137.37 28.75,137.37 29.24,136.89 29.24,133.69 28.91,133.36 28.63,133.36 28.6,133.38 26.7,133.38 24.54,131.23 21.11,131.23 19.91,130.03 19.91,129.98 17.27,127.34 ; 4 cut-outs
12V_DUAL on TOP: 18.34,70.42 17.65,71.1 17.65,72.37 17.88,72.6 19.81,72.6 20.21,72.21 26.02,72.21 26.19,72.04 26.19,70.57 26.04,70.42 ; 2 cut-outs
12V_DUAL on TOP: 150.75,33.38 149.61,34.53 149.61,35.92 149.86,36.18 150.24,36.18 151.89,34.53 151.89,33.51 151.76,33.38 ; 1 cut-out
12V_DUAL on TOP: 178.22,108.28 177.93,108.57 177.93,113.14 178.18,113.39 178.69,113.39 178.74,113.45 180.04,113.45 180.24,113.24 180.24,111.95 181.94,110.25 181.94,108.49 181.72,108.28
12V_DUAL on TOP: 19.66,154.09 18.92,154.82 15.27,154.82 13.13,156.96 13.13,157.72 13.44,158.02 28.4,158.02 28.8,157.62 28.8,155.76 28.68,155.64 25.17,155.64 24.74,156.07 23.19,156.07 23.01,155.89 23.01,154.26 22.83,154.09
12V_DUAL on TOP: 37.95,79.36 37.77,79.54 37.77,82.94 38.02,83.19 39.93,83.19 40.31,82.81 40.31,79.56 40.11,79.36
12V_DUAL on BOTTOM: 15.62,122.79 15.37,123.05 15.37,127.31 15.01,127.67 13.87,127.67 13.64,127.9 13.64,129.35 13.82,129.52 17.73,129.52 17.74,129.54 18.63,129.54 19.15,130.06 19.96,130.06 21.95,132.04 23.77,132.04 24.79,133.05 24.79,153.3 23.95,154.14 13.69,154.14 13.08,154.75 13.08,157.87 13.26,158.05 19.18,158.05 19.66,158.53 19.66,160.05 20.04,160.44 31.06,160.44 32.64,158.86 32.64,144.05 30.84,142.25 30.84,133.87 27.71,130.74 24.79,130.74 24.78,130.76 23.48,130.76 21.08,128.36 21.08,126.93 18.57,124.42 18.57,123.05 18.54,123.05 18.29,122.79 ; 1 cut-out
12V_DUAL on BOTTOM: 176.1,110.22 175.79,110.52 175.79,115.4 175.51,115.68 165.6,115.68 164.97,115.06 151.83,115.06 150.67,113.9 147.45,113.9 146.69,114.66 146.69,116.44 150.24,120 178.82,120 180.02,118.79 180.02,110.66 179.58,110.22
12V_DUAL on BOTTOM: 140.72,203.44 140.21,203.95 140.21,205.57 140.26,205.62 140.26,209.46 141.27,210.47 145.82,210.47 148.08,212.73 149.56,212.73 154.61,217.79 154.61,219.16 154.97,219.52 157.23,219.52 157.51,219.24 157.51,213.5 149.35,205.34 149.22,205.34 147.32,203.44
12V_DUAL on BOTTOM: 66.8,34.78 65.41,36.18 65.41,39.48 64.71,40.18 64.71,43.61 64.39,43.93 63.5,43.93 63.25,44.18 63.25,53.32 61.59,54.97 49.34,54.97 48.77,55.55 46.61,55.55 45.78,54.72 19.36,54.72 18.91,55.17 18.91,60.34 18.92,60.35 18.92,61.08 19.29,61.45 34.92,61.45 34.99,61.52 43.24,61.52 44.64,62.91 44.64,63.29 45.34,63.99 57.28,63.99 58.8,62.47 63.25,62.47 70.21,55.51 70.21,51.8 70.87,51.14 70.87,47.86 72.39,46.34 72.39,35.29 71.88,34.78 ; 1 cut-out
12V_DUAL on L3: 40.34,82.94 39.47,82.94 39.22,82.69 39.22,79.84 39.45,79.61 40.46,79.61 40.69,79.84 40.69,82.58
12V_DUAL on L3: outline of 158 points within 6.48,54.97 148.87,246.36 ; 1 cut-out
12V_DUAL_1D05V_S0 on TOP: 182.45,100.69 182.3,100.85 177.01,100.85 175.69,102.17 175.69,107.17 176.12,107.6 181.69,107.6 181.89,107.4 181.89,103.34 181.94,103.34 182.04,103.23 182.04,101.91 182.4,101.56 183.29,101.56 183.44,101.41 183.44,100.8 183.34,100.69
12V_DUAL_DDR_VIN on TOP: 159.77,212.99 159.36,213.39 159.36,216.8 159.92,217.36 163.6,217.36 165.89,219.64 165.89,220.56 166.24,220.91 172.85,220.91 174.8,222.87 176.15,222.87 176.5,222.51 176.5,215.88 176.05,215.43 168,215.43 165.56,212.99 ; 2 cut-outs
12V_DUAL_DDR_VIN on BOTTOM: 159.03,212.99 158.45,213.57 158.45,218.32 158.72,218.6 164.85,218.6 166.85,220.61 176.1,220.61 176.5,220.2 176.5,215.88 176.05,215.43 168,215.43 165.56,212.99
12V_DUAL_VGACORE on TOP: 20.09,106.28 19.79,106.59 19.79,108.04 19.18,108.65 19.18,122.59 18.67,123.1 18.67,128.63 20.95,130.92 24.26,130.92 24.38,130.79 24.38,129.27 23.24,128.13 23.24,122.34 24.41,121.17 24.41,109.66 24.21,109.46 23.34,109.46 22.99,109.1 22.99,106.59 22.68,106.28
12V_DUAL_VGACORE on BOTTOM: 21.11,106.28 20.78,106.61 20.78,115.2 19.66,116.32 19.66,124.34 21.69,126.37 21.69,128.3 22.05,128.66 23.06,128.66 23.37,128.36 23.37,106.74 22.91,106.28 ; 2 cut-outs
12V_FAN_MIX on BOTTOM: 16.13,185.78 16,185.91 14.86,185.91 14.48,186.29 14.48,189.59 14.71,189.82 14.71,191.47 15.24,192.01 18.67,192.01 19.43,191.25 19.43,185.91 19.3,185.78 ; 3 cut-outs
12V_MONITOR on BOTTOM: 19.46,130.74 19.3,130.9 19.3,145.81 19.51,146.01 19.51,147 19.3,147.2 19.3,151.95 19.71,152.36 21.49,152.36 22.23,153.1 23.85,153.1 24.1,152.84 24.1,133 23.55,132.44 21.95,132.44 20.24,130.74 ; 18 cut-outs
12V_PWR on TOP: 21.97,77.2 21.49,77.68 21.49,95.06 22.31,95.88 27.64,95.88 28.6,94.92 28.6,78.11 28.09,77.61 25.53,77.61 25.12,77.2
12V_S0 on TOP: 19.71,159.04 19.58,159.17 19.58,159.57 19.56,159.6 19.56,161.81 20.07,162.32 23.77,162.32 24.18,161.91 24.18,159.17 24.05,159.04
12V_S0 on BOTTOM: 4.6,111.97 2.59,113.98 2.59,147.94 3.89,149.23 9.75,149.23 12.4,151.88 12.4,153.17 12.93,153.7 20.5,153.7 20.68,153.53 20.68,152.97 20.32,152.61 13.59,152.61 13.49,152.51 13.49,150.76 10.95,148.22 4.72,148.22 3.63,147.13 3.63,115.17 5.71,113.09 9.27,113.09 10.21,114.03 10.29,114.03 10.29,118.98 11.3,120 14.61,120 15.62,118.98 15.62,117.59 15.49,117.46 14.86,117.46 14.61,117.71 14.61,118.6 14.22,118.98 11.94,118.98 11.26,118.31 11.26,112.93 10.31,111.97
12V_S0 on BOTTOM: 17.02,182.23 16.76,182.48 16.76,185.15 17.02,185.4 17.91,185.4 18.16,185.15 18.16,182.48 17.91,182.23 ; 1 cut-out
12V_S0 on L4: 16.89,183.88 16.89,182.86 17.91,181.85 17.91,163.43 19.81,161.53 19.81,159.88 19.53,159.6 19.53,152.16 19.91,151.77 20.4,151.77 20.78,152.16 20.78,157.69 23.44,160.36 23.44,162.09 23.14,162.39 21.01,162.39 20.65,162.75 20.65,163.08 18.87,164.86 18.87,182.46 18.16,183.17 18.16,184.13 17.91,184.39 17.4,184.39
+1.5V_PWR on TOP: 153.44,197.09 152.93,197.6 152.93,212.07 153.42,212.56 165.53,212.56 166.34,211.74 166.34,201.69 165.81,201.15 162.79,201.15 161.72,200.09 161.72,197.55 161.26,197.09 ; 2 cut-outs
+1.5V_PWR on BOTTOM: 146.94,195.79 146.38,196.35 146.38,201.66 157.05,212.33 165.76,212.33 166.34,211.74 166.34,204.3 161.72,199.68 161.72,196.94 160.58,195.79
+3V_VA on BOTTOM: 175.01,82.91 174.75,83.17 174.75,84.18 175.13,84.57 175.13,85.84 174.75,86.22 174.75,86.6 174.88,86.72 175.13,86.72 175.51,87.11 177.16,87.11 177.55,86.72 177.55,84.82 176.91,84.18 176.66,84.18 175.51,83.04 175.51,82.91 ; 6 cut-outs
+5V_VGA on BOTTOM: 56.16,18.14 55.88,18.42 55.88,22.34 56.9,23.35 63.63,23.35 63.88,23.1 63.88,20.18 63.63,19.92 62.74,19.92 61.85,20.81 58.42,20.81 57.66,20.05 57.66,18.35 57.45,18.14 ; 3 cut-outs
+19V_AMP_PVCC on TOP: 152.4,33 152.15,33.26 152.15,34.27 152.65,34.78 155.32,34.78 155.45,34.65 157.35,34.65 157.48,34.53 157.48,33.89 157.35,33.77 155.96,33.77 155.19,33 ; 3 cut-outs
+19V_AMP_PVCC on TOP: 163.32,33.26 162.81,33.77 161.67,33.77 161.54,33.89 161.54,34.53 161.67,34.65 163.45,34.65 163.83,34.27 163.83,33.38 163.7,33.26
+19V_AMP_PVCC on BOTTOM: 155.8,31.51 154.64,32.67 154.64,33.89 156.01,35.26 156.01,35.98 156.39,36.36 157.12,36.36 157.38,36.1 157.38,32.75 157.33,32.7 157.89,32.14 157.89,32.11 161.67,32.11 161.9,32.34 161.9,36.79 162.08,36.97 163.86,36.97 164.34,36.48 164.34,32.24 163.6,31.51 ; 3 cut-outs
AGND on TOP: 75.95,3.92 72.14,7.73 72.14,11.41 72.26,11.54 72.77,11.54 73.41,12.18 73.41,13.06 74.93,14.59 77.09,14.59 77.6,14.08 77.6,11.54 75.18,9.13 75.18,7.35 75.95,6.59 77.98,6.59 78.36,6.97 78.36,10.91 79.76,12.3 79.76,16.75 81.41,18.4 82.3,18.4 83.82,16.87 83.82,11.03 84.71,10.14 85.09,10.14 85.34,9.89 85.34,8.87 85.09,8.62 83.82,8.62 82.17,10.27 80.64,10.27 79.88,9.51 79.88,5.57 78.23,3.92 ; 1 cut-out
AGND on TOP: 68.96,8.62 68.71,8.87 68.71,11.41 68.83,11.54 69.6,11.54 69.72,11.41 69.72,8.75 69.6,8.62 ; 1 cut-out
AGND on TOP: 187.83,79.87 187.45,80.25 187.45,82.15 187.71,82.41 189.23,82.41 189.99,83.17 189.99,84.82 189.74,85.07 187.96,85.07 187.83,85.2 187.83,86.22 187.07,86.98 187.07,89.52 186.94,89.65 186.69,89.65 186.44,89.9 186.44,90.53 186.69,90.79 188.34,90.79 189.36,89.77 191.01,89.77 191.39,90.15 191.39,92.95 190.25,94.09 188.72,94.09 188.59,94.22 188.59,94.85 191.01,94.85 192.15,93.71 193.42,93.71 195.07,92.06 195.07,83.17 192.02,80.12 191.39,80.12 191.13,79.87 ; 1 cut-out
AGND on BOTTOM: 177.8,83.8 177.55,84.06 177.55,86.98 177.29,87.23 175.39,87.23 174.88,86.72 174.75,86.72 174.62,86.6 174.62,85.96 175.01,85.58 175.01,84.62 174.4,84.01 172.14,84.01 170.26,85.89 170.26,91.86 170.66,92.26 172.9,92.26 176.02,89.14 177.04,89.14 177.8,88.38 179.07,88.38 179.71,87.74 179.71,85.07 178.44,83.8 ; 6 cut-outs
AGND on BOTTOM: 83.95,9 82.17,10.78 76.45,10.78 74.42,12.81 74.42,16.24 75.31,17.13 77.98,17.13 78.87,18.02 85.98,18.02 87.12,16.87 87.12,9.25 86.87,9
AGND on BOTTOM: 189.61,77.45 188.21,78.85 181.23,78.85 180.85,79.23 180.85,79.99 181.48,80.63 183.13,80.63 183.39,80.88 188.85,80.88 190.5,82.53 190.88,82.53 191.77,83.42 191.77,92.06 190.63,93.2 190.63,94.34 191.39,94.34 192.15,93.58 193.93,93.58 195.07,92.44 195.07,80.88 191.64,77.45
AGND on L2GND: outline of 119 points within 68.26,0.76 203.99,94.92
AGND on L5GND: 189.69,77.52 188.42,78.79 175.08,78.79 174.56,79.31 174.56,82.46 174.82,82.71 174.82,83.88 174.7,83.99 172.29,83.99 170.52,85.76 170.52,91.85 170.79,92.12 172.51,92.12 175.44,89.2 177.09,89.2 177.98,88.31 178.74,88.31 181.02,86.03 182.58,86.03 183.71,87.15 183.71,88.2 182.94,88.96 182.94,90.6 185.37,90.6 185.99,91.22 185.99,93.89 187.02,94.92 191.06,94.92 192.07,93.9 194.1,93.9 195.14,92.87 195.14,90.2 196.9,88.44 200.1,88.44 202.14,90.47 203.99,90.47 203.99,80.18 200.99,80.18 198.71,82.47 196.77,82.47 191.82,77.52
AVCC33_2136 on TOP: 130.94,202.42 130.81,202.55 130.81,204.71 131.55,205.44 132.97,205.44 132.97,202.93 132.46,202.42 ; 2 cut-outs
DVCC33_2136 on TOP: 125.86,210.17 124.49,211.54 124.49,214.13 124.61,214.26 125.81,214.26 125.93,214.39 129.49,214.39 129.54,214.33 129.54,211.69 129.16,211.31 128.78,211.31 128.65,211.18 128.65,210.55 128.52,210.42 127.89,210.42 127.64,210.17 ; 4 cut-outs
GND on TOP (solid shape): outline of 273 points within 0.62,3.05 10.62,13.05
GND on TOP (solid shape): outline of 273 points within 1.62,151.05 11.62,161.05
GND on TOP (solid shape): outline of 273 points within 146.62,6.05 156.62,16.05
GND on TOP (solid shape): outline of 273 points within 178.6,173.03 188.64,183.07
GND on TOP (solid shape): outline of 273 points within 178.6,69.03 188.64,79.07
GND on BOTTOM (solid shape): outline of 273 points within 0.62,3.05 10.62,13.05
GND on BOTTOM (solid shape): outline of 273 points within 1.62,151.05 11.62,161.05
GND on BOTTOM (solid shape): outline of 273 points within 146.62,6.05 156.62,16.05
GND on BOTTOM (solid shape): outline of 273 points within 178.6,173.03 188.64,183.07
GND on BOTTOM (solid shape): outline of 273 points within 178.6,69.03 188.64,79.07
GND on TOP: 76.6,160.39 76.35,160.63 76.35,161.57 76.59,161.81 78.15,161.81 78.15,160.39 78.15,160.39
GND on TOP: 176.91,97.9 176.78,98.03 175.13,98.03 174.62,98.54 174.52,98.54 174.52,99.2 175.87,100.54 181.97,100.54 182.37,100.14 183.36,100.14 183.46,100.03 183.46,99.25 183.24,99.02 178.82,99.02 178.36,98.56 178.36,98.18 178.08,97.9
GND on TOP: 11.05,211.31 10.92,211.44 10.92,214.36 11.05,214.49 14.86,214.49 14.99,214.36 14.99,211.44 14.86,211.31
GND on TOP: 76.6,166.49 76.35,166.73 76.35,167.66 76.59,167.9 78.15,167.9 78.15,166.49 78.15,166.49
GND on TOP: 179.58,66.91 179.45,67.04 179.45,71.23 180.34,70.34 180.72,70.34 181.48,69.58 182.12,69.58 182.5,69.2 184.53,69.2 184.78,69.45 185.42,69.45 185.93,69.96 186.44,69.96 187.45,70.98 187.45,71.61 188.34,72.5 188.34,75.68 186.56,77.45 186.56,77.83 187.07,78.34 188.34,78.34 189.48,77.2 192.15,77.2 196.47,81.52 198.88,81.52 199.64,80.76 199.64,79.1 198.63,78.09 198.63,75.17 198.12,74.66 196.47,74.66 195.83,75.29 192.35,75.29 192.07,75.02 192.07,74.38 191.8,74.1 189.89,74.1 189.08,73.29 190.25,72.12 193.29,72.12 194.44,73.26 199.39,73.26 200.98,74.85 201.36,74.85 201.42,74.79 201.8,74.79 203.76,76.74 203.91,76.74 203.99,76.67 203.99,67.17 203.73,66.91
GND on TOP: 88.91,95.59 88.66,95.84 88.53,95.84 88.28,96.09 88.28,96.98 88.86,97.57 89.47,97.57 89.55,97.49 89.55,96.35 89.42,96.22 89.42,95.84 89.16,95.59
GND on TOP: 14.8,194.62 14.54,194.87 14.54,198.55 14.8,198.81 17.08,198.81 17.21,198.68 17.21,194.87 16.96,194.62
GND on TOP: 113.67,34.02 112.9,34.78 111.89,34.78 111.63,35.04 111.63,36.18 111.89,36.43 113.54,36.43 114.17,37.07 114.17,37.32 114.3,37.45 114.94,37.45 115.57,36.81 115.57,36.18 116.46,35.29 116.46,34.15 116.33,34.02 ; 5 cut-outs
GND on TOP: 10.92,189.47 10.79,189.59 10.79,193.15 11.05,193.4 14.48,193.4 14.86,193.02 14.86,189.59 14.73,189.47
GND on TOP: 28.35,204.2 28.22,204.33 28.22,207.88 28.6,208.26 40.16,208.26 40.54,207.88 40.54,204.58 40.16,204.2 36.73,204.2 36.6,204.33 36.6,205.98 36.35,206.23 34.57,206.23 34.44,206.1 34.44,205.47 34.19,205.22 32.28,205.22 32.03,204.96 32.03,204.45 31.78,204.2 ; 2 cut-outs
GND on TOP: 181.36,131.94 180.85,132.44 180.85,136.25 181.48,136.89 188.59,136.89 189.61,135.87 189.61,131.94 ; 1 cut-out
GND on TOP: 57.4,115.93 50.42,122.92 50.42,131.43 51.18,132.19 65.91,132.19 73.15,124.95 73.15,117.97 71.12,115.93
GND on TOP: 5.59,136.89 4.57,137.91 4.57,142.1 5.59,143.11 8.18,143.11 8.66,143.6 13.84,143.6 14.31,143.13 18.66,143.13 19.28,142.5 19.28,140.24 18.72,139.68 15.39,139.68 14.55,140.52 8.46,140.52 7.62,139.68 7.62,137.65 6.86,136.89
GND on TOP: 15.15,174.52 14.93,174.74 14.93,180.26 15.24,180.58 17.14,180.58 17.14,174.61 17.05,174.52
GND on TOP: 97.03,182.05 96.29,182.79 96.29,184.77 95.2,185.86 95.2,186.8 95.43,187.03 98.48,187.03 99.47,186.04 99.47,183.27 98.25,182.05
GND on TOP: 44.32,72.54 42.16,74.7 42.16,90.92 40.51,92.57 40.51,106.03 41.21,106.73 44.98,106.73 45.44,106.27 45.44,102.21 45.36,102.13 43.66,102.13 43.41,101.88 43.41,96.34 43.66,96.09 45.57,96.09 45.64,96.01 45.64,95.07 45.46,94.89 45.46,85.37 45.26,85.17 45.26,84.45 45.13,84.33 43.43,84.33 43.28,84.17 43.28,83.16 43.46,82.98 45.26,82.98 45.44,82.8 45.44,81.66 45.21,81.43 43.56,81.43 43.41,81.28 43.41,79.83 44.22,79.02 45.34,79.02 45.44,78.92 45.44,75.95 45.24,75.74 45.24,74.12 45.49,73.86 46.63,73.86 46.84,73.66 46.84,72.69 46.68,72.54 ; 34 cut-outs
GND on TOP: 140.21,29.45 139.45,30.21 139.45,31.23 138.81,31.86 138.81,32.11 139.19,32.5 143,32.5 144.02,31.48 146.43,31.48 146.94,30.97 146.94,30.21 146.69,29.96 143.13,29.96 142.62,29.45 ; 8 cut-outs
GND on TOP: 129.03,208.14 128.91,208.26 128.91,210.8 129.16,211.06 129.67,211.06 130.05,211.44 130.05,214.11 130.18,214.23 135,214.23 135.89,213.34 135.89,211.69 134.37,210.17 134.37,208.26 134.24,208.14 ; 7 cut-outs
GND on TOP: 115.57,101.33 115.19,101.71 115.19,103.11 115.32,103.23 117.73,103.23 118.26,102.7 118.67,102.7 118.85,102.52 118.85,101.48 118.69,101.33 ; 1 cut-out
GND on TOP: 177.52,215.45 177.11,215.86 177.11,222.54 177.44,222.87 180.47,222.87 180.82,222.51 180.82,215.83 180.44,215.45
GND on TOP: 150.9,111.62 150.7,111.82 150.7,117.13 152.37,118.81 152.37,119.97 153.62,121.22 158.52,121.22 159.23,120.51 159.23,112.61 158.72,112.61 158.12,112 152.02,112 151.64,111.62
GND on TOP: 21.97,165.59 21.84,165.72 21.84,169.27 21.97,169.4 23.11,169.4 23.24,169.27 23.24,168.77 22.61,168.13 22.61,167.88 22.73,167.75 22.73,165.72 22.61,165.59
GND on TOP: outline of 114 points within 62.81,156.69 89.62,183.91
GND on TOP: 175.9,108.19 175.51,108.57 175.51,109.46 175.26,109.71 174.12,109.71 173.48,110.35 173.48,113.27 174.12,113.9 177.29,113.9 177.55,113.65 177.55,108.31 177.42,108.19 ; 1 cut-out
GND on TOP: 31.24,43.04 31.11,43.16 31.11,44.69 31.5,45.07 31.5,47.35 31.62,47.48 33.66,47.48 33.78,47.35 33.78,43.29 33.53,43.04 ; 6 cut-outs
GND on TOP: 24.38,121.9 23.75,122.54 23.75,127.75 24.51,128.51 27.94,128.51 28.57,127.87 28.57,122.41 28.07,121.9
GND on TOP: 76.6,162.42 76.35,162.67 76.35,163.6 76.59,163.84 78.15,163.84 78.15,162.43 78.15,162.42
GND on TOP: 97.13,51.67 94.74,54.06 94.74,54.95 95.28,55.48 101.68,55.48 102.59,54.57 102.59,52 102.26,51.67
GND on TOP: outline of 104 points within 60.84,157.94 72.2,169.91
GND on TOP: 76.6,172.58 76.35,172.83 76.35,173.76 76.59,174 78.15,174 78.15,172.59 78.15,172.58
GND on TOP: 76.6,170.55 76.35,170.79 76.35,171.73 76.59,171.97 78.15,171.97 78.15,170.55 78.15,170.55
GND on TOP: 18.92,204.96 18.67,205.22 18.67,207.5 19.05,207.88 21.21,207.88 21.34,207.76 21.34,206.23 20.07,204.96
GND on TOP: 144.65,24.24 143.64,25.26 143.64,25.76 144.53,26.65 146.81,26.65 146.94,26.53 146.94,24.49 146.69,24.24 ; 6 cut-outs
GND on TOP: 97.18,56.63 96.77,57.03 96.77,60.41 97.23,60.87 103.63,60.87 104.04,60.46 104.04,59.09 104.6,58.53 106.3,58.53 106.68,58.15 106.68,57.13 106.17,56.63
GND on TOP: 30.48,161.65 29.97,162.16 27.05,162.16 26.29,162.92 26.29,165.46 26.6,165.78 30.16,165.78 30.29,165.65 30.29,164 30.54,163.75 32.32,163.75 32.45,163.87 32.45,164.33 33.05,164.93 34.21,164.93 35.06,165.78 38.54,165.78 38.67,165.65 38.67,162.22 38.4,161.96 37.59,161.96 37.35,161.71 31.24,161.71 31.21,161.68 30.51,161.68 ; 2 cut-outs
GND on TOP: outline of 163 points within 0.51,0.51 119.49,252.99
GND on TOP: 138.33,65.08 138.18,65.24 135.33,65.24 135.32,65.25 135.31,65.24 134.44,65.24 133.86,65.82 133.86,66.33 134.39,66.86 137.54,66.86 138.2,66.2 138.91,66.2 139.12,66.4 139.57,66.4 139.73,66.25 139.73,65.41 139.4,65.08
GND on TOP: 156.46,35.67 156.08,36.05 156.08,37.45 156.34,37.7 157.73,37.7 157.86,37.58 157.86,36.94 157.73,36.81 157.61,36.81 157.35,36.56 157.35,35.67
GND on TOP: 77.72,83.3 77.6,83.42 77.6,83.55 78.11,84.06 78.11,84.82 77.6,85.33 77.6,85.58 78.11,86.09 78.11,86.85 77.6,87.36 77.6,87.61 78.11,88.12 78.11,88.76 77.6,89.26 77.6,89.52 78.11,90.03 78.11,90.53 77.47,91.17 77.47,91.42 77.6,91.55 77.85,91.55 78.87,90.53 78.87,90.15 78.36,89.65 78.36,89.01 78.87,88.5 78.87,88.25 78.36,87.74 78.36,87.23 78.99,86.6 78.99,86.47 78.49,85.96 78.49,85.2 80.01,83.68 80.01,83.42 79.88,83.3
GND on TOP: 38,83.58 37.77,83.8 37.77,87.49 37.31,87.94 37.31,88.83 37.44,88.96 39.88,88.96 40.31,88.53 40.31,83.96 39.93,83.58 ; 1 cut-out
GND on TOP: 76.6,164.45 76.35,164.7 76.35,165.63 76.59,165.87 78.15,165.87 78.15,164.46 78.15,164.45
GND on TOP: 94.36,98.92 94.23,99.04 94.23,99.55 94.36,99.68 95.12,99.68 95.38,99.93 95.38,103.49 95.63,103.74 96.9,103.74 97.16,103.49 97.16,100.69 95.38,98.92 ; 6 cut-outs
GND on TOP: 71.91,151.54 71.38,152.06 71.38,152.15 71.13,152.41 70.76,152.41 70.19,152.98 70.19,153.32 69.96,153.55 69.96,153.94 70.52,154.5 70.52,155.41 70.85,155.74 72.06,155.74 72.17,155.63 72.17,155.37 71.51,154.71 71.51,154.13 71.78,153.86 72.34,153.86 72.5,154.02 72.5,154.59 72.63,154.72 73.07,154.72 73.64,154.16 74.06,154.16 74.29,154.39 74.29,154.77 74.54,155.01 74.78,155.01 74.92,154.87 74.92,152.83 73.63,151.54
GND on TOP: 161.15,31.65 161.11,31.68 161.11,32.79 160.98,32.93 160.04,32.93 159.91,32.79 159.91,31.68 159.89,31.65 159.63,31.65 159.61,31.68 159.61,32.87 159.56,32.93 159.45,32.93 159.41,32.88 159.41,31.69 159.37,31.65 159.12,31.65 159.1,31.68 159.1,32.87 159.04,32.93 158.17,32.93 157.91,32.67 157.91,31.69 157.87,31.65 157.64,31.65 157.59,31.71 157.59,32.37 157.66,32.44 157.66,32.79 157.8,32.93 157.79,32.93 157.79,36.39 161.21,36.39 161.21,33.29 161.41,33.09 161.41,31.68 161.38,31.65
GND on TOP: outline of 168 points within 126.15,69.58 128.55,81.67
GND on TOP: 80.39,86.22 80.14,86.47 80.14,86.72 79.63,87.23 79.63,87.61 80.14,88.12 80.14,88.5 79.5,89.14 79.5,89.39 80.14,90.03 80.14,90.53 79.5,91.17 79.5,91.3 79.63,91.42 79.88,91.42 80.77,90.53 80.77,90.03 80.26,89.52 80.26,89.01 80.77,88.5 80.77,88.25 80.26,87.74 80.26,87.36 80.77,86.85 80.77,86.47 80.52,86.22
GND on TOP: 88.84,3.6 86.36,6.08 84.84,6.08 84.45,6.46 84.45,7.98 84.58,8.11 85.6,8.11 85.85,8.37 95,8.37 96.01,7.35 106.55,7.35 109.22,10.02 119.13,10.02 121.16,7.98 131.83,7.98 132.33,8.49 143,8.49 143.76,9.25 143.76,12.94 143.38,13.32 143.38,16.75 144.17,17.54 149.58,17.54 150.44,18.4 163.96,18.4 168.47,13.89 168.47,4.11 167.96,3.6 ; 7 cut-outs
GND on TOP: outline of 89 points within 126.47,64.68 130.73,69.73
GND on TOP: 76.6,174.61 76.35,174.86 76.35,175.83 76.55,176.03 78.15,176.03 78.15,174.62 78.15,174.61
GND on TOP: 159.51,217.79 159.11,218.2 159.11,221.83 159.41,222.13 164.16,222.13 164.39,222.36 167.51,222.36 167.74,222.13 167.74,221.55 167.56,221.37 165.86,221.37 165.28,220.79 165.28,219.74 163.32,217.79
GND on TOP: 184.4,106.97 184.37,107.01 183.02,107.01 182.35,107.68 182.35,110.09 182.73,110.47 188.8,110.47 188.95,110.32 188.95,107.22 188.7,106.97 ; 1 cut-out
GND on TOP: 126.19,214.74 125.44,215.49 122.47,215.49 122.28,215.68 122.28,216.93 122.35,217 123.19,217 123.44,217.26 126.19,217.26 126.36,217.08 128.78,217.08 128.85,217 128.85,216.62 128.75,216.52 128.75,215.63 128.85,215.53 129.51,215.53 129.62,215.43 129.62,214.87 129.49,214.74 ; 6 cut-outs
GND on TOP: 70.84,47.43 70.59,47.69 70.59,51.04 70.61,51.04 71.25,51.67 72.75,51.67 74.02,52.94 77.6,52.94 77.98,52.56 77.98,49.01 77.6,48.62 76.33,48.62 75.56,49.39 73.89,49.39 73.66,49.16 73.66,47.58 73.51,47.43 ; 1 cut-out
GND on TOP: 176.66,168.39 176.28,168.77 176.28,171.94 176.53,172.2 179.2,172.2 179.71,171.69 181.36,171.69 181.42,171.75 184.21,171.75 184.78,171.18 184.78,170.04 184.4,169.66 181.48,169.66 180.21,168.39
GND on TOP: 76.6,168.52 76.35,168.76 76.35,169.69 76.59,169.94 78.15,169.94 78.15,168.52 78.15,168.52
GND on TOP: 21.89,99.17 20.35,100.72 20.35,105.11 20.6,105.37 23.04,105.37 25.43,102.98 29.21,102.98 29.34,102.85 29.34,101.2 29.59,100.95 31.75,100.95 32,101.2 32,102.85 32.13,102.98 35.81,102.98 35.94,102.85 35.94,99.42 35.95,99.41 35.71,99.17
GND on TOP: 180.14,198.97 179.88,199.22 179.88,202.4 180.01,202.52 181.66,202.52 181.89,202.75 181.89,204.73 181.66,204.96 181.13,204.96 180.95,205.14 180.95,206.26 179.96,207.25 179.96,210.73 180.06,210.83 183.79,210.83 184.07,210.55 184.07,199.3 183.74,198.97 ; 1 cut-out
GND on TOP: 29.21,78.72 28.96,78.98 28.96,81.9 29.59,82.53 30.48,82.53 30.86,82.15 30.86,78.98 30.61,78.72
GND on TOP: 129.54,52.56 129.29,52.82 129.29,54.85 129.54,55.1 132.46,55.1 132.72,54.85 132.72,53.7 132.46,53.45 131.57,53.45 131.32,53.2 131.32,52.69 131.19,52.56 ; 1 cut-out
GND on TOP: 14.99,216.26 14.73,216.52 14.73,220.2 14.99,220.46 17.27,220.46 17.4,220.33 17.4,216.52 17.14,216.26
GND on TOP: 76.6,158.36 76.35,158.6 76.35,159.53 76.59,159.78 78.15,159.78 78.15,158.36 78.15,158.36
GND on TOP: 133.6,111.36 133.35,111.62 133.35,113.78 133.86,114.28 133.86,125.08 144.4,135.62 144.4,140.7 142.75,142.35 129.29,142.35 127.38,144.26 127.38,187.56 135,195.18 153.16,195.18 155.07,197.09 158.88,197.09 160.27,195.69 171.07,195.69 172.21,194.55 172.21,191.63 171.58,190.99 149.73,190.99 147.45,188.71 147.45,169.27 142.37,164.19 142.37,147.18 143,146.54 144.78,146.54 146.69,144.64 146.69,116.82 146.43,116.57 136.27,116.57 135.25,115.55 135.25,111.62 135,111.36 ; 1 cut-out
GND on TOP: 93.22,27.42 92.41,28.23 92.41,31.4 92.74,31.73 94.51,31.73 95,31.25 96.09,31.25 96.37,30.97 96.39,30.97 96.39,27.8 96.01,27.42
GND on TOP: 25.78,73.9 25.4,74.28 25.4,76.44 25.91,76.95 27.56,76.95 27.56,74.15 27.3,73.9
GND on TOP: 63.22,147.52 63.19,147.54 62.98,147.54 62.86,147.66 62.86,148.17 63.08,148.39 63.47,148.39 66.23,151.15 66.55,151.15 66.65,151.06 66.65,150.61 63.55,147.52
GND on TOP: 95.91,87.77 95.76,87.92 95.76,88.99 95.63,89.11 95.63,89.87 95.78,90.03 97.16,90.03 98.02,90.89 98.73,90.89 99.06,91.22 99.77,91.22 99.82,91.17 99.82,88.2 99.39,87.77 ; 8 cut-outs
GND on TOP: 26.16,130.29 26.01,130.44 26.01,132.37 26.59,132.95 29.77,132.95 30.12,132.6 30.12,130.54 29.87,130.29 ; 4 cut-outs
GND on TOP: 70.5,24.74 70.48,24.75 68.33,24.75 67.06,26.02 67.06,28.94 67.39,29.27 68.94,29.27 69.37,28.84 73.2,28.84 73.76,28.28 73.76,25.08 73.43,24.75 70.51,24.75 ; 2 cut-outs
GND on TOP: 180.34,152.51 179.96,152.89 179.96,154.57 179.03,155.5 178.63,155.5 178.46,155.66 178.46,158.23 178.71,158.48 180.47,158.48 181.25,159.27 181.69,159.27 182.02,158.94 183.54,158.94 184.12,159.52 186.69,159.52 186.82,159.39 186.82,158.43 185.42,157.03 184.07,157.03 183.87,156.83 182.42,156.83 182.19,156.6 182.19,153.6 181.1,152.51 ; 13 cut-outs
GND on TOP: 27.97,227.19 27.84,227.31 27.84,230.87 28.22,231.25 39.78,231.25 40.16,230.87 40.16,227.57 39.78,227.19 36.35,227.19 36.22,227.31 36.22,228.96 35.97,229.22 34.19,229.22 34.06,229.09 34.06,228.46 33.81,228.2 31.9,228.2 31.65,227.95 31.65,227.44 31.39,227.19 ; 2 cut-outs
GND on TOP: 197.23,88.88 195.71,90.41 195.71,93.07 194.42,94.36 193.31,94.36 193.27,94.4 192.3,94.4 190.96,95.74 190.96,98.79 191.72,99.55 195.07,99.55 196.65,101.13 196.65,109.15 194.31,111.49 194.31,116.82 197.23,119.74 197.23,129.14 192.28,134.1 192.28,170.29 189.61,172.96 180.09,172.96 176.66,176.39 176.66,176.51 176.53,176.64 176.53,182.23 177.42,183.12 184.82,183.12 186.48,184.77 186.48,229.48 165.33,229.48 162.33,226.48 115.77,226.48 115.7,226.55 115.7,227.95 116.2,228.46 119.28,228.46 119.41,228.33 119.41,228.08 120.12,227.36 157.86,227.36 158.78,228.28 158.78,229.19 159.84,230.25 186.89,230.25 187.49,229.65 187.49,196.11 187.49,196.11 187.49,191.36 187.56,190.99 187.76,190.68 187.76,190.31 203.81,174.25 203.83,174.25 203.83,172.32 205.74,170.42 205.74,138.29 203.96,136.51 203.96,91.42 203.71,91.17 202.18,91.17 199.9,88.88 ; 1 cut-out
GND on TOP, BOTTOM: 79.53,35.34 79.12,35.75 79.12,40.45 79.88,41.21 83.62,41.21 83.85,40.98 83.85,35.72 83.46,35.34
GND on BOTTOM: 158.24,122.92 157.48,123.68 157.48,124.95 157.23,125.21 155.07,125.21 154.69,124.82 153.54,124.82 153.29,125.08 153.29,125.59 153.42,125.71 154.81,125.71 155.19,126.09 157.48,126.09 159.13,127.75 163.45,127.75 163.58,127.62 163.58,123.17 163.32,122.92 ; 11 cut-outs
GND on BOTTOM: 145.26,62.72 144.58,63.41 143.94,63.41 143.76,63.59 143.76,63.92 144.22,64.37 144.22,64.65 144.3,64.73 145.77,64.73 146.25,65.21 146.71,65.21 146.81,65.11 146.81,62.82 146.71,62.72 ; 3 cut-outs
GND on BOTTOM: 18.78,201.9 18.65,202.03 18.65,208.07 18.85,208.26 20.02,208.26 20.14,208.14 20.14,205.17 19.54,204.57 19.54,202.03 19.41,201.9
GND on BOTTOM: 76.68,76.18 76.58,76.29 76.58,79.26 76.66,79.33 76.99,79.33 77.6,78.72 77.6,76.29 77.5,76.18
GND on BOTTOM: 78.87,93.2 78.61,93.46 78.61,94.85 78.36,95.11 78.11,95.11 77.98,95.23 77.98,95.87 78.36,96.25 80.14,96.25 80.52,96.63 81.28,96.63 81.53,96.38 81.53,95.36 82.17,94.73 82.68,94.73 82.8,94.6 82.8,94.09 81.92,93.2 ; 9 cut-outs
GND on BOTTOM: 13.44,129.65 13.31,129.78 13.31,130.69 13.61,131 17.22,131 17.63,130.59 17.63,129.88 17.4,129.65 ; 2 cut-outs
GND on BOTTOM: 99.69,53.53 99.59,53.63 95.1,53.63 94.84,53.88 94.84,55.48 95.17,55.81 102.16,55.81 102.44,55.53 102.44,53.76 102.21,53.53
GND on BOTTOM: 181.23,86.72 179.2,88.76 177.93,88.76 177.42,89.26 177.42,90.53 177.55,90.66 178.82,90.66 179.2,91.04 180.47,91.04 183.26,88.25 183.26,86.85 183.13,86.72
GND on BOTTOM: 133.3,105.88 130.99,108.19 130.81,108.19 130.68,108.31 129.67,108.31 129.29,108.7 129.29,109.71 129.67,110.09 129.67,114.28 130.05,114.66 132.21,114.66 132.46,114.41 132.46,108.62 133.12,107.96 135.61,107.96 135.64,107.93 139.7,107.93 139.95,107.68 139.95,106.28 139.57,105.9 135.64,105.9 135.61,105.93 135.56,105.88 ; 2 cut-outs
GND on BOTTOM: 136.53,115.55 136.14,115.93 136.14,119.24 136.91,120 143.13,120 143.64,119.49 143.64,116.06 143.13,115.55 ; 2 cut-outs
GND on BOTTOM: 29.11,78.67 28.93,78.85 28.93,81.49 29.11,81.67 30.25,81.67 30.35,81.57 30.35,81.37 30.89,80.83 30.89,78.93 30.63,78.67 ; 2 cut-outs
GND on BOTTOM: outline of 85 points within 0.51,0.51 205.74,252.99 ; 3 cut-outs
GND on BOTTOM: 157.99,32.5 157.61,32.88 157.61,36.05 158.5,36.94 161.29,36.94 161.54,36.69 161.54,33.26 160.78,32.5 ; 4 cut-outs
GND on BOTTOM: 6.1,49.51 3.3,52.31 3.3,83.8 4.95,85.45 11.81,85.45 13.34,83.93 13.34,67.42 11.81,65.9 11.81,63.36 11.18,62.72 5.59,62.72 5.08,62.21 5.08,61.71 5.21,61.58 6.73,61.58 6.99,61.32 6.99,60.56 6.35,59.93 6.35,57.9 6.73,57.51 6.73,56.5 6.35,56.12 6.35,54.21 6.99,53.58 7.49,53.58 7.87,53.96 9.02,53.96 9.91,53.07 9.91,51.29 8.13,49.51 ; 2 cut-outs
GND on BOTTOM: 98.04,231.76 96.9,232.9 96.9,235.57 96.52,235.95 94.51,235.95 94.16,236.31 94.16,237.27 95.38,238.49 95.38,240.04 94.89,240.52 94.36,240.52 94.28,240.6 94.28,241.26 94.39,241.36 96.7,241.36 97.54,240.52 98.17,240.52 98.81,239.89 100.58,239.89 102.11,238.36 102.11,232.14 101.73,231.76
GND on BOTTOM: 68.35,24.16 68.02,24.49 68.02,28.38 68.33,28.69 73.38,28.69 73.71,28.36 73.71,24.49 73.38,24.16
GND on BOTTOM: 71.25,100.82 71.12,100.95 71.12,101.2 70.87,101.46 67.18,101.46 66.55,102.09 66.55,102.85 67.06,103.36 71.37,103.36 71.75,102.98 71.75,100.95 71.63,100.82 ; 2 cut-outs
GND on BOTTOM: 18.8,224.39 18.67,224.52 18.67,228.2 18.8,228.33 19.94,228.33 20.07,228.2 20.07,227.57 19.56,227.06 19.56,224.52 19.43,224.39
GND on BOTTOM: 49.35,14.59 49.35,16.47 53.9,16.47 53.9,14.59
GND on BOTTOM: 42.24,89.2 41.88,89.56 41.88,103.96 43.46,105.54 45.16,105.54 45.44,105.26 45.44,99.02 45.54,98.92 45.54,97.61 45.34,97.41 43.64,97.41 43.51,97.28 43.51,96.24 43.66,96.09 45.41,96.09 45.67,95.83 45.67,89.56 45.31,89.2 ; 18 cut-outs
GND on BOTTOM: 44.37,13.9 43.48,14.79 43.48,20.63 43.94,21.09 44.93,21.09 45.36,20.66 45.36,17.71 45.82,17.26 57.58,17.26 57.91,17.59 57.91,20.48 58.5,21.07 59.03,21.07 59.51,20.58 59.51,16.67 56.74,13.9
GND on BOTTOM: 21.67,99.17 20.8,100.03 20.8,105.17 21.21,105.57 24.16,105.57 26.75,102.98 30.48,102.98 30.61,102.85 30.61,101.84 30.99,101.46 35.56,101.46 35.94,101.08 35.94,99.42 35.69,99.17 ; 2 cut-outs
GND on BOTTOM: 179.32,160.51 179.07,160.77 179.07,163.69 178.94,163.81 178.44,163.81 178.05,164.19 178.05,164.96 178.44,165.34 180.59,165.34 181.18,164.75 186.64,164.75 187.07,164.32 187.07,162.67 186.94,162.54 186.31,162.54 186.18,162.67 186.18,163.94 185.8,164.32 182.5,164.32 182.37,164.19 182.37,163.56 182.25,163.43 180.72,163.43 180.59,163.31 180.59,162.16 179.96,161.53 179.96,160.64 179.83,160.51 ; 5 cut-outs
GND on BOTTOM: 27.94,34.53 27.05,35.42 27.05,37.7 27.3,37.96 30.1,37.96 30.35,37.7 30.35,35.67 30.86,35.16 30.86,34.78 30.61,34.53 ; 9 cut-outs
GND on BOTTOM: 93.22,27.42 92.41,28.23 92.41,31.4 92.74,31.73 96.01,31.73 96.39,31.35 96.39,27.8 96.01,27.42
GND on BOTTOM: 82.42,79.61 82.02,80.02 79.48,80.02 78.99,80.5 78.99,83.17 78.82,83.35 77.98,83.35 77.88,83.45 77.88,83.91 78.23,84.26 78.23,84.79 78.03,85 78.03,85.35 78.12,85.44 78.73,85.44 78.99,85.71 78.99,86.34 79.12,86.47 79.43,86.47 79.76,86.8 79.76,90.92 80.01,91.17 80.39,91.17 80.64,90.92 80.64,88.88 80.52,88.76 80.52,85.2 79.88,84.57 79.88,83.04 80.26,82.66 81.92,82.66 82.07,82.51 82.07,80.93 82.4,80.6 84.33,80.6 84.4,80.68 84.4,81.87 84.33,81.95 83.49,81.95 83.34,82.1 83.34,83.27 83.64,83.58 84.3,83.58 84.52,83.79 84.52,84.12 83.95,84.69 83.95,85.33 83.69,85.58 83.69,85.84 84.2,86.34 84.2,86.72 83.44,87.49 83.41,87.49 83.29,87.61 82.68,87.61 82.55,87.74 82.55,88.2 82.65,88.3 83.77,88.3 84.2,87.87 85.98,87.87 86.07,87.78 86.07,87.17 86,87.11 85.09,87.11 84.84,86.85 84.84,86.22 85.93,85.12 85.93,83.63 85.72,83.42 85.72,82.53 86.03,82.23 86.03,79.77 85.88,79.61 ; 17 cut-outs
GND on BOTTOM: 83.84,158.23 81.8,160.27 80.18,160.27 79.92,160.53 79.92,177.5 80.33,177.91 83.96,177.91 84.72,177.15 84.72,158.79 84.16,158.23 ; 2 cut-outs
GND on BOTTOM: 43.86,74.17 43.46,74.57 43.46,78.76 43.64,78.94 45.31,78.94 45.44,78.82 45.44,74.24 45.36,74.17 ; 7 cut-outs
GND on BOTTOM: 130.05,48.37 129.79,48.62 129.79,54.21 130.05,54.47 132.59,54.47 132.72,54.34 132.72,48.88 132.21,48.37
GND on BOTTOM: 4.7,42.4 4.32,42.78 4.32,45.7 5.33,46.72 7.49,46.72 9.27,48.5 13.34,48.5 13.72,48.12 13.72,46.21 11.56,44.05 9.27,44.05 9.27,42.78 8.89,42.4
GND on BOTTOM: 174.07,148.27 173.91,148.42 173.91,148.83 174.47,149.39 174.47,151.32 174.73,151.57 174.73,152.84 174.27,153.3 174.04,153.3 173.84,153.5 173.84,156.91 174.27,157.34 174.27,159.11 173.46,159.93 173.46,160.97 173.89,161.4 173.89,162.16 174.04,162.32 174.27,162.32 174.62,162.67 174.62,163.23 174.4,163.46 174.4,164.83 174.51,164.94 175.27,164.94 175.39,164.83 175.39,159.17 175.01,158.78 175.01,156.85 174.32,156.17 174.32,155.66 174.52,155.46 174.88,155.81 177.93,155.81 178.31,155.43 178.31,152.97 178.28,152.94 178.28,151.24 178.56,150.96 178.56,148.83 178,148.27 ; 14 cut-outs
GND on BOTTOM: 43.64,84.33 43.48,84.48 43.48,86.38 44.19,87.1 45.31,87.1 45.44,86.97 45.44,84.51 45.26,84.33 ; 2 cut-outs
GND on BOTTOM: 175.16,222.79 174.9,223.05 174.9,227.77 175.08,227.95 177.6,227.95 177.63,227.91 178.09,227.91 178.69,227.31 178.69,223.43 178.05,222.79 ; 2 cut-outs
GND on BOTTOM: 76.58,98.28 76.33,98.54 76.33,101.71 78.87,101.71 79.38,101.2 79.38,100.31 79.76,99.93 79.76,98.54 77.6,98.54 77.34,98.28 ; 9 cut-outs
GND on BOTTOM: 72.01,47.86 71.37,48.5 71.37,51.04 71.88,51.55 72.9,51.55 74.04,52.69 77.72,52.69 77.98,52.43 77.98,49.26 77.34,48.62 76.58,48.62 75.82,49.39 73.89,49.39 73.66,49.16 73.66,47.99 73.53,47.86 ; 1 cut-out
GND on BOTTOM: 24,117.43 23.75,117.69 23.75,127.75 24.51,128.51 27.94,128.51 28.57,127.87 28.57,122.41 28.07,121.9 26.95,121.9 25.86,120.81 25.86,117.66 25.63,117.43 ; 2 cut-outs
GND on BOTTOM: 146.41,97.77 146.28,97.9 146.28,98.28 146.13,98.43 145.82,98.43 145.64,98.61 145.64,99.5 144.9,100.24 144.84,100.24 144.83,100.25 141.64,100.25 141.15,100.75 141.15,105.27 141.33,105.44 142.65,105.44 142.88,105.22 142.88,102.09 143.38,101.58 148.92,101.58 149.2,101.3 149.2,97.9 149.07,97.77 ; 6 cut-outs
GND on BOTTOM: 129.54,23.61 129.16,23.99 129.16,27.54 129.79,28.18 130.81,28.18 131.32,27.67 131.32,23.73 131.19,23.61 ; 3 cut-outs
GND on L2GND: 179.97,66.91 179.8,66.9 179.64,66.87 179.64,76.11 181.94,78.41 188.26,78.41 189.53,77.14 191.98,77.14 196.93,82.09 198.55,82.09 199.71,80.93 199.71,79.06 198.95,78.29 198.95,76.87 200.84,74.98 201.75,74.98 203.66,76.88 203.99,76.88 203.99,67.15 203.92,66.98 203.75,66.91
GND on L2GND: outline of 122 points within 0.76,0.76 205.84,252.74 ; 58 cut-outs
GND on L3: outline of 96 points within 0.51,0.51 205.71,252.99
GND on L4: 0.76,0.76 0.76,1.51 0.51,1.51 0.51,250.17 0.51,250.17 0.51,252.99 119.49,252.99 119.49,248.01 119.49,248.01 119.49,228.5 119.79,227.79 120.5,227.49 157.5,227.49 158.21,227.79 158.51,228.5 158.51,229.29 159.71,230.49 187.49,230.49 187.49,194.59 187.49,194.59 187.49,191.36 187.57,190.97 187.79,190.64 193.79,184.64 193.8,184.64 203.89,174.56 203.89,172.25 205.71,170.42 205.71,138.29 203.94,136.51 203.94,91.37 204.24,91.07 204.34,91.07 204.34,77.45 204.09,77.2 204.09,67.04 203.71,66.66 179.97,66.66 179.39,66.48 179.02,66.01 178.83,65.5 178.69,65.64 178.69,65.69 171.7,47.1 171.65,46.51 171.56,46.27 171.51,46.09 171.49,45.91 171.49,3.79 171.24,3.54 171.24,2 171.17,1.83 171,1.76 135.41,1.76 134.91,1.66 134.49,1.36 134.34,1.16 134.22,0.92 134.2,0.87 134.11,0.79 134,0.76 ; 2 cut-outs
GND on L4: 143.13,56.14 143.13,49.87 143.43,49.87 144.86,51.29 144.86,56.5 144.63,56.73 144.63,56.83 143.94,57.51 143.18,57.51 142.93,57.26 142.93,56.35
GND on L4: 143.41,43.54 142.8,43.54 142.42,43.16 142.42,39.91 141.83,39.33 141.83,38.21 141.99,38.06 143.26,38.06 143.59,38.39 143.59,43.37
GND on L5GND: outline of 90 points within 0.76,0.76 205.84,252.74 ; 16 cut-outs
VBAT1 on TOP: 99.31,219.57 98.93,219.95 98.93,222.61 99.44,223.12 100.08,223.12 101.22,221.98 103,221.98 103.5,221.47 103.5,220.33 102.74,219.57 ; 2 cut-outs
VCC on TOP: 16.92,76.69 16.61,77 16.61,81.31 14.78,83.14 13.61,83.14 13.49,83.27 13.49,86.57 13.59,86.67 15.01,86.67 17.17,84.52 20.52,84.52 21.18,83.85 21.18,77.17 20.7,76.69
VCC on TOP: 133.6,10.4 132.72,11.29 132.72,14.33 132.08,14.97 130.68,14.97 128.02,17.64 128.02,21.57 125.88,23.71 125.88,26.53 126.34,26.98 129.95,26.98 130.89,26.04 130.89,25.13 131.27,24.75 132.08,24.75 132.16,24.67 132.16,23.78 132.72,23.22 134.75,23.22 141.1,16.87 141.1,10.91 140.59,10.4 ; 1 cut-out
VCC on TOP: 104.72,46.12 104.49,46.35 104.49,47.57 105.3,48.39 105.3,48.87 105.39,48.96 106.25,48.96 106.4,48.81 106.4,46.63 105.88,46.12 ; 1 cut-out
VCC on TOP: 127.89,34.15 127.25,34.78 127.25,36.31 128.02,37.07 134.24,37.07 135.38,38.21 135.38,40.5 133.73,42.15 133.73,44.05 135.25,45.58 135.25,46.21 137.16,48.12 137.16,49.89 137.03,50.02 134.87,50.02 134.75,50.15 134.75,50.78 135,51.04 140.21,51.04 140.59,50.66 140.59,48.5 139.57,47.48 139.57,46.34 137.54,44.31 137.54,37.14 136.91,36.51 136.35,36.51 134.87,35.04 131.32,35.04 131.19,34.91 131.19,34.4 130.94,34.15 ; 1 cut-out
VCC on TOP: 7.24,44.94 7.11,45.07 7.11,48.24 7.24,48.37 11.18,48.37 11.3,48.24 11.3,46.34 11.18,46.21 8.89,46.21 8.64,45.96 8.64,45.2 8.38,44.94 ; 2 cut-outs
VCC on BOTTOM: 14.43,83.14 11.84,85.73 4.98,85.73 4.65,86.06 4.65,87.64 5.05,88.05 13.72,88.05 17.07,84.69 17.07,83.45 16.76,83.14
VCC on BOTTOM: 124.71,23.48 124.46,23.73 124.46,28.94 126.75,31.23 126.75,34.65 127.38,35.29 130.56,35.29 131.06,34.78 131.06,34.4 129.92,33.26 129.92,32.88 129.29,32.24 129.29,27.92 128.91,27.54 128.91,23.73 128.65,23.48 ; 3 cut-outs
VCC on BOTTOM: 96.52,210.55 90.3,216.77 90.3,227.06 91.95,228.71 91.95,231.25 90.42,232.77 90.42,244.2 92.46,246.24 98.17,246.24 98.55,245.86 98.55,244.33 98.04,243.82 92.71,243.82 92.08,243.19 92.08,233.54 93.73,231.89 93.73,227.57 92.2,226.04 92.2,219.82 97.28,214.74 97.28,213.47 97.92,212.84 100.33,212.84 103.89,216.39 105.03,216.39 105.41,216.77 108.71,216.77 109.27,216.21 117.65,216.21 117.86,216.01 117.86,214.36 117.35,213.85 109.09,213.85 108.27,214.68 105.35,214.68 101.22,210.55
VCC on BOTTOM: 59.31,8.37 58.55,9.13 58.55,12.18 58.04,12.68 58.04,14.59 62.1,18.65 63.75,18.65 64.52,19.41 64.52,25.76 64.01,26.27 56.39,26.27 55.88,26.78 55.88,27.16 55.63,27.42 54.99,27.42 54.86,27.54 54.86,28.18 54.99,28.3 57.02,28.3 57.15,28.43 57.15,29.32 57.53,29.7 57.78,29.7 58.17,30.08 60.45,30.08 61.09,29.45 61.09,28.69 61.34,28.43 65.66,28.43 66.29,27.8 66.29,18.27 64.64,16.62 62.99,16.62 60.2,13.83 60.2,12.81 61.09,11.92 61.09,9.64 61.59,9.13 61.59,8.62 61.34,8.37 ; 2 cut-outs
VCC on L4: 140.46,12.3 137.54,12.3 133.73,8.49 133.73,7.86 132.33,6.46 88.14,6.46 87.88,6.71 80.39,6.71 79.63,5.95 73.66,5.95 72.26,7.35 62.87,7.35 60.96,9.25 59.94,9.25 58.67,7.98 28.96,7.98 15.62,21.32 15.62,25.38 9.53,31.48 9.53,41.64 10.79,42.91 10.79,49.39 6.22,53.96 6.22,85.07 7.37,86.22 7.37,92.69 5.84,94.22 5.84,105.77 7.62,107.55 7.62,110.85 5.84,112.63 5.84,115.3 5.97,115.43 5.97,124.57 6.86,125.46 6.86,131.3 13.72,138.16 13.72,143.87 14.35,144.51 14.35,147.2 12.78,148.78 12.78,161.58 7.87,166.48 7.87,171.81 8.13,172.07 8.13,182.86 5.97,185.02 5.97,241.66 9.78,245.47 92.96,245.47 94.61,243.82 98.17,243.82 98.68,244.33 98.68,248.78 98.04,249.41 4.06,249.41 1.65,247 1.65,17.51 17.27,1.89 133.58,1.89 133.59,1.9 133.97,1.9 134.32,2.24 139.55,2.24 140.97,3.67 140.97,11.79
VCC3 on TOP: 66.93,21.95 65.81,23.07 65.81,23.1 65.79,23.1 64.77,24.11 64.52,24.11 64.24,24.39 64.24,24.49 63.68,25.05 62.74,25.05 62.66,25.13 62.66,25.54 62.84,25.71 65.66,25.71 65.79,25.59 65.79,24.88 67.59,23.07 67.59,22.11 67.44,21.95 ; 1 cut-out
VCC3 on TOP: 6.43,87.92 6.18,88.16 6.18,92.3 6.4,92.52 7.49,92.52 7.65,92.36 7.65,89.82 7.85,89.62 9.68,89.62 9.91,89.39 9.91,88.33 9.5,87.92 ; 2 cut-outs
VCC3 on TOP: 32.77,6.59 32.64,6.71 32.64,11.03 32.51,11.16 31.62,11.16 31.5,11.29 31.5,12.05 31.62,12.18 33.15,12.18 33.27,12.05 33.27,7.6 33.4,7.48 34.29,7.48 34.54,7.22 34.54,6.71 34.42,6.59 ; 1 cut-out
VCC3 on TOP: 128.04,28.76 127.61,29.19 127.61,32.5 127.74,32.62 132.26,32.62 132.65,32.23 132.65,31.37 132.51,31.23 131.95,31.23 131.56,30.83 131.56,29.08 131.24,28.76 ; 1 cut-out
VCC3 on TOP: 119.38,208.77 119,209.15 119,210.3 119.13,210.42 119.13,211.57 121.92,214.36 123.83,214.36 124.08,214.11 124.08,213.09 119.76,208.77 ; 3 cut-outs
VCC3 on TOP: 163.19,72.75 163.07,72.88 163.07,80.12 163.19,80.25 164.34,80.25 164.59,79.99 164.59,72.88 164.47,72.75 ; 11 cut-outs
VCC3 on TOP: 153.16,52.33 150.6,54.9 144.98,54.9 144.58,55.31 144.58,61.3 144.86,61.58 145.47,61.58 145.79,61.9 145.79,62.92 146.49,63.62 146.49,64.76 146.11,65.14 145.34,65.14 144.58,65.9 143.69,65.9 142.42,67.17 141.79,67.17 141.53,67.43 141.53,67.68 141.66,67.81 141.91,67.81 142.04,67.93 142.04,68.44 141.91,68.57 141.53,68.57 140.93,69.17 140.3,69.17 139.37,70.09 139.25,70.09 139.12,70.22 138.88,70.22 138.46,70.65 138.46,70.93 138.73,71.21 139.04,71.21 139.04,71.19 139.5,70.73 139.62,70.61 140.01,70.22 140.9,70.22 141.53,69.59 141.53,69.33 141.79,69.08 142.04,69.08 142.42,68.7 142.42,68.19 142.68,67.93 143.18,67.93 143.31,67.81 143.31,67.29 143.53,67.07 144.17,67.07 144.71,66.54 144.84,66.54 145.22,66.16 145.72,66.16 145.85,66.28 147.25,66.28 147.76,65.78 147.76,60.94 148.29,60.41 149.05,60.41 152.27,57.18 154.2,57.18 155.07,56.32 165.86,56.32 166.57,55.61 166.62,55.61 166.62,55 163.96,52.33
VCC3 on TOP: 129.21,41.84 128.32,42.73 128.32,45.4 128.63,45.7 131.24,45.7 131.37,45.58 131.37,43.93 131.55,43.75 132.33,43.75 132.64,43.44 132.64,42.12 132.36,41.84
VCC3 on TOP: 15.88,31.86 15.62,32.11 13.59,32.11 12.83,32.88 10.41,32.88 9.91,32.37 8.76,32.37 8.51,32.62 8.51,34.02 8.76,34.27 12.7,34.27 13.72,33.26 14.86,33.26 15.75,34.15 16.51,34.15 17.14,33.51 17.81,33.51 18.24,33.94 18.24,34.2 18.49,34.45 19.33,34.45 19.46,34.32 19.46,33.84 19.2,33.59 18.87,33.59 17.91,32.62 16.89,32.62 16.64,32.37 16.64,31.99 16.51,31.86 ; 2 cut-outs
VCC3 on TOP: 177.93,148.32 177.16,149.08 177.16,152.38 176.66,152.89 175.77,152.89 174.62,154.03 174.62,154.34 174.66,154.38 174.66,159.56 176.77,161.67 176.78,161.67 177.41,162.29 180.95,162.29 182.52,163.86 183.74,163.86 183.82,163.79 183.82,160.61 183.13,159.93 183.13,159.32 183.08,159.27 182.91,159.27 182.88,159.29 182.19,159.29 181.91,159.57 181.18,159.57 180.34,158.73 178.82,158.73 178.18,158.1 178.16,158.1 178.16,153.43 179.07,152.51 179.58,152.51 179.83,152.26 179.83,148.57 179.58,148.32 ; 11 cut-outs
VCC3 on TOP: 113.92,54.54 113.46,55 113.06,55 111.72,56.33 108.78,56.33 106.3,58.81 104.9,58.81 104.27,59.45 104.27,61.58 104.47,61.78 104.47,67.73 104.62,67.88 107.16,67.88 107.34,67.7 107.34,63.41 107.42,63.33 110.03,63.33 110.34,63.03 110.34,61.32 111.12,60.54 112.29,60.54 113.54,59.29 113.54,58.66 114.05,58.15 114.68,58.15 116.69,56.14 116.69,55.36 115.87,54.54
VCC3 on TOP: 155.7,75.42 155.57,75.55 155.57,81.14 155.7,81.14 155.83,81.26 157.35,81.26 157.61,81.52 157.61,83.17 157.73,83.3 158.75,83.3 158.88,83.17 158.88,81.52 157.35,79.99 156.84,79.99 156.72,79.87 156.72,75.68 156.46,75.42 ; 6 cut-outs
VCC3 on TOP: 46.28,29.4 45.72,29.96 44.58,29.96 44.2,30.34 44.2,31.99 44.45,32.24 47.12,32.24 47.24,32.11 47.24,30.46 47.37,30.34 48.01,30.34 48.26,30.59 48.26,31.1 48.64,31.48 48.64,31.63 48.79,31.78 51.56,31.78 51.77,31.99 51.77,32.24 51.89,32.37 54.41,32.37 54.48,32.29 54.48,30.74 54.08,30.34 53.62,30.34 53.59,30.36 49.63,30.36 48.69,29.42 47.29,29.42 47.27,29.4 ; 5 cut-outs
VCC3 on BOTTOM: 67.94,1.89 67.31,2.52 67.31,5.44 68.07,6.21 87,6.21 89.15,4.05 133.99,4.05 134.37,4.43 155.32,4.43 158.88,7.98 158.88,14.21 156.84,16.24 146.94,16.24 143.89,13.19 143.89,9.89 143.51,9.51 140.97,9.51 140.08,10.4 140.08,15.6 131.83,23.86 131.83,28.13 131.19,28.76 130.05,28.76 129.54,29.27 129.54,32.15 129.92,32.53 130.77,32.53 131.06,32.83 131.06,33 131.11,33.05 133.48,33.05 134.07,32.46 135.37,32.46 136.09,31.73 138.05,31.73 140.65,29.13 140.65,24.69 145.92,19.41 165.23,19.41 167.39,21.57 167.39,50.4 164.08,53.7 164.08,54.59 165.23,55.74 167.39,55.74 170.05,53.07 170.05,16.75 168.53,15.22 166.24,15.22 164.21,13.19 164.21,6.71 160.02,2.52 134.87,2.52 134.24,1.89 ; 4 cut-outs
VCC3 on BOTTOM: 4.75,107.38 4.32,107.81 4.32,110.68 4.34,110.7 4.34,111.13 4.83,111.62 17.27,111.62 17.78,111.11 17.78,109.06 17.53,108.81 12.56,108.81 11.13,107.38
VCC3 on BOTTOM: 144.83,57.34 144.78,57.39 144.78,60.21 144.55,60.44 144.25,60.44 143.76,60.92 143.76,62.54 143.87,62.65 145.06,62.65 145.31,62.39 145.31,60.97 145.54,60.74 147.07,60.74 147.68,61.35 147.98,61.35 148.84,62.21 148.84,62.34 147.83,62.34 147.56,62.61 147.21,62.61 147.12,62.7 147.12,65.26 146.89,65.49 146.18,65.49 145.72,65.03 144.32,65.03 144.15,65.21 144.15,65.67 143.94,65.87 143.46,65.87 143.23,66.1 143.23,66.35 142.8,66.79 142.8,67.19 143.81,68.21 145.44,68.21 146.18,68.94 148.11,68.94 149.38,67.67 149.38,66.38 150.11,65.64 150.62,65.64 151.64,64.63 151.64,61.96 151.26,61.58 150.5,61.58 150.24,61.32 150.24,61.07 149.38,60.21 149.38,59.45 147.27,57.34 ; 14 cut-outs
VCC3 on BOTTOM: 183.39,162.54 182.63,163.31 182.63,163.81 182.75,163.94 185.8,163.94 185.93,163.81 185.93,162.67 185.8,162.54 ; 4 cut-outs
VCC3 on BOTTOM: 168.91,221.09 168.66,221.34 168.66,222.23 168.78,222.36 169.93,222.36 170.31,222.74 170.31,223.63 170.56,223.88 172.59,223.88 172.97,223.5 172.97,221.73 172.34,221.09
VCC3 on L3: 131.14,29.35 131.83,30.03 131.9,30.03 132.97,31.1 132.97,33.92 131.24,33.92 130.78,34.38 130.78,35.09 128.6,37.27 127.76,37.27 125.83,39.2 125.83,41.16 131.19,41.16 132.46,42.43 132.46,43.88 131.83,44.51 118.21,44.51 116.94,43.24 116.94,38.95 120.7,35.19 125.98,35.19 125.98,35.16 127.23,33.92 127.23,31.76 127.25,31.73 127.25,30.21 128.12,29.35
VCC3 on L3: 148.59,198.74 149.78,199.93 149.78,216.16 146.99,218.96 143.21,218.96 142.39,218.14 142.39,213.42 143.56,212.25 143.56,206.03 143,205.47 138.61,205.47 136.27,207.81 131.62,207.81 127.88,211.55 118.25,211.55 118.24,211.57 117.86,211.57 117.5,211.21 117.5,208.49 117.51,208.48 117.51,206.57 119.63,204.45 125.22,204.45 126.24,203.44 126.24,199.5 127,198.74
VCC3 on L3: 84.58,6.33 89.28,6.33 90.17,5.44 128.52,5.44 128.55,5.47 134.39,5.47 141.35,12.43 143.38,12.43 143.64,12.18 143.64,6.33 140.78,3.48 85.92,3.48 84.2,5.19 84.2,5.95
