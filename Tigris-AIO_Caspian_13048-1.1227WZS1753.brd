# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PORTC_SPK_L: length 67.2
  TOP w0.203: C267.1 156.72,43.44 158.29,45.02 166.8,45.02 168.12,46.34 168.12,51.9 v1(170.28,54.06) 170.94,54.72 170.94,57.51 172.97,59.55 172.97,62.2 172.97,62.2 172.97,65.92 177.09,70.04 v3(177.52,70.04) ; v3(184.41,89.52) 184.4,89.52 183.67,89.52 183.36,89.21 U16.43
  L3 w0.203: v3(177.52,70.04) 177.52,70.36 177.75,70.58 177.75,76.64 180.14,79.03 180.14,80.85 182.37,83.08 182.37,89.84 182.99,90.46 183.48,90.46 184.4,89.53 184.4,89.53 v3(184.41,89.52)
PORTC_SPK_L_1: length 2.5
  TOP w0.203: C267.2 154.23,43.34 v1(153.97,43.09) 153.87,42.99 R511.1
PORTC_SPK_R: length 55.9
  TOP w0.203: v3(183.26,89.87) 183.26,89.82 183.05,89.61 U16.44 ; C279.1 167.26,43.65 168.71,45.09 168.71,51.61 171.53,54.43 171.53,57.27 173.56,59.3 173.56,62.44 173.56,62.45 173.56,63.69 173.56,65.52 v1(175.59,67.55) 177.47,69.43 v3(178.1,69.43)
  L3 w0.203: v3(178.1,69.43) 178.1,70.11 178.33,70.34 178.33,76.4 180.72,78.79 180.72,80.6 182.96,82.84 182.96,89.6 183.24,89.87 v3(183.26,89.87)
PORTC_SPK_R_1: length 4.3
  TOP w0.203: C279.2 167.26,39.99 v1(166.62,39.35) 166.6,39.33 165.51,39.33 164.44,38.26 R526.1
PRIVACY_MSR_EN_N: length 7.1
  BOTTOM w0.102: XDPC1.60 48.86,241.65 v2(47.09,243.42) 46.32,243.42 R646.1
PRW_VGA_CORE_RBIAS: length 3.9
  TOP w0.203: U9.3 42,143.17 42.37,143.55
  TOP w0.254: PR9.1 43.41,144.48 v1(43.16,144.23) 43.05,144.23 42.37,143.55
PS_0: length 7.6
  TOP w0.102: U13.AC19 85.89,90.28 v4(86.36,90.28)
  BOTTOM w0.102: v4(86.36,90.28) 87.02,89.62 87.52,89.62 87.73,89.41 v2(89.01,89.41) 89.41,89.41 R394.1 C227.2 91.15,90 R388.1
PS_1: length 7.8
  TOP w0.102: U13.AD19 86.48,89.74 86.81,90.07 87.5,90.07 87.71,90.28 v4(87.73,90.28)
  BOTTOM w0.102: v2(87.02,90.71) 87.45,90.28 v4(87.73,90.28) 88.06,89.95 89.19,89.95 90.07,90.83 R948.1 C593.2 91.97,91.08 R943.1
PS_2: length 12.4
  TOP w0.102: C200.1 95.12,89.07 95.06,89.14 R294.1 R303.1 94.49,90.79 v4(92.58,88.88) ; U13.AE17 86.95,88.81 v4(87.35,89.21)
  BOTTOM w0.102: v4(92.58,88.88) 92.41,88.71 91.44,88.71 90.92,88.19 v2(90.55,88.19) 90.18,88.19 89.48,88.88 88.87,88.88 88.82,88.93 87.63,88.93 v4(87.35,89.21)
PS_3: length 14.3
  TOP w0.102: R940.1 98.31,91.82 C565.1 98.11,91.74 R935.2 96.46,91.74 96.35,91.84 96.35,91.85 96.12,92.08 96.11,92.08 96.09,92.11 95.46,92.11 v1(95.1,91.75) 94.56,91.75 93.22,90.41 88.23,90.41 88.08,90.56 88.08,91.08 87.89,91.27 87.29,91.27 86.96,90.94 U13.AE20
PSI#: length 3.3
  TOP w0.254: PR4.2 PR3.1 ; PR3.1 v1(43.56,147.32) ; PR3.1 PR10.2
PSID_D: length 7.2
  TOP w0.102: L8.2 15.18,151.18 16.81,149.54 18.14,149.54 Q37.D 19.08,148.94 v1(19.08,148.35) 19.23,148.19 R155.1
PSID_D_1: length 4
  TOP w0.102: R156.1 22.33,148.45 v1(22.2,148.32) 22.07,148.19 R155.2 21.09,148.25 21.09,149.88 Q36.B
PSID_G: length 7.7
  TOP w0.102: v1(24.33,152.61) 22.91,152.61 Q36.C 21.93,151.63 19.31,151.63 Q37.G 18.98,151.61 18.08,152.51 R150.2
PSPWRGD: length 226.3
  TOP w0.102: v3(60.96,31.23) 60.32,31.87 R562.1 ; v3(26.92,139.51) v1(24.41,139.51) 22.49,139.51 v1(21.32,140.68) 17.11,144.89 17.11,144.9 R161.2 16.98,144.89 R160.2 15.02,145.78 C116.1 13.89,145.91 12.88,144.89 11.84,144.89 10.46,143.52 7.39,143.52 ATX2.4
  L3 w0.127: v3(26.92,139.51) 26.08,139.51 19.55,132.97 19.55,121.74 19.7,121.59 19.7,96.2 20.24,95.66 20.24,74.5 25.75,69 25.75,53.67 23.79,51.71 23.79,40.92 25.36,39.35 25.36,38.6 26.47,37.5 26.47,34.25 27.01,33.71 27.01,30.94 27.27,30.69 27.27,25.96 28.39,24.84 28.39,23.94 29.6,22.73 30.38,22.73 31.25,21.85 32.16,20.95 32.16,13.77 37.43,8.5 42.92,8.5 43.93,7.49 55.97,7.49 v3(61.16,12.68)
  BOTTOM w0.102: v3(61.16,12.68) 61.65,13.17 61.65,14.08 62.66,15.1 64.9,15.1 67.22,17.42 67.22,22.12 67.56,22.46 67.56,29.8 v2(65.9,31.47) 64.39,32.98 62.23,32.98 v2(61.52,32.27) 60.96,31.71 v3(60.96,31.23)
PW_CLEAR: length 37.3
  TOP w0.102: PSWD1.2 150.37,109.62 150.37,108.31 149.1,107.04 149.1,104.78 v1(149.61,104.28) 149.61,103.41 147.22,101.03 147.22,99.07 149.66,96.63 150.14,96.63 v3(150.16,96.66) ; v4(142.47,82.66) 142.33,82.66 U29.AM36
  L3 w0.127: v3(150.16,96.66) 150.16,96.32 149.45,95.61 149.45,95.54 148.21,94.29 147,94.29 146.05,93.34 146.05,89.82 146.52,89.36 v4(146.52,87.02)
  BOTTOM w0.102: v4(142.47,82.66) 142.8,82.99 142.8,83.37 143.06,83.63 R947.1 143.06,84.36 145.72,87.02 v4(146.52,87.02)
PWM1: length 23.7
  L3 w0.305: v3(15.75,225.43) 15.75,236.51 16.84,237.6 18.85,237.6 20.42,239.18 v3(21.31,239.18)
  BOTTOM w0.203: R666.1 21.46,239.02 v3(21.31,239.18) 21.16,239.32 U35.12
  BOTTOM w0.305: U17.2 17.49,225.88 v2(16.64,225.03) 16.15,225.03 v3(15.75,225.43)
PWM1_BT: length 3.7
  BOTTOM w0.254: R704.1 v2(16.89,222.93)
  BOTTOM w0.305: 18.15,224.26 18.12,224.28 U17.1
  BOTTOM w0.508: R704.1 18.15,224.26
PWM1_BT_1: length 3.1
  BOTTOM w0.635: C400.1 v2(21.72,223.22) 21.43,222.93 R704.2
PWM1_EN: length 2.5
  BOTTOM w0.254: U17.3 v2(16.64,226.38) 15.64,226.38 R701.2
PWM1_HG: length 4.3
  TOP w0.635: v5(20.21,224.53) v1(21.07,223.67) 21.57,223.18 21.57,223.07 R34.1
  BOTTOM w0.305: v5(20.21,224.53) 20.15,224.59 U17.8
PWM1_HG_1: length 14.3
  TOP w0.635: R29.1 24.83,223.69 24.33,223.2 24.33,222.11 R34.2 24.66,222.11 25.68,221.09 25.69,221.09 25.8,220.98 27.39,220.98 v5(27.43,220.94) Q8.4 ; v5(27.43,214.59) Q12.4
  BOTTOM w0.635: v5(27.43,220.94) v2(27.43,218.42) v5(27.43,214.59)
PWM1_LG: length 16.6
  TOP w0.635: v5(34.32,227.95) Q6.4 ; Q5.4 v5(25.93,227.95)
  BOTTOM w0.305: 21.48,227.2 21.16,226.88 U17.5
  BOTTOM w0.635: v5(34.32,227.95) v5(25.93,227.95) v2(24.13,227.95) 22.23,227.95 21.48,227.2
PWM1_LX: length 32.3
  TOP w0.508: 30.95,217.99 L1.1 ; L1.1 34.15,217.99 ; L1.1 32.55,216.39 ; L1.1 32.55,219.6
  TOP w0.635: Q5.5 28.38,224.58 R29.2 22.7,224.58 v5(21.48,225.8)
  L3 w0.508: 32.55,216.39 L1.1 ; L1.1 32.55,219.6 ; L1.1 34.15,217.99 ; L1.1 30.95,217.99
  BOTTOM w0.305: U17.7 21.41,225.88 v5(21.48,225.8)
  BOTTOM w0.508: G1.1 35.36,217.99 L1.1 ; 32.55,216.39 L1.1 ; L1.1 32.55,219.6 ; L1.1 30.95,217.99
  BOTTOM w0.635: C400.2 22.59,225.61 21.68,225.61 v5(21.48,225.8)
  vias: v2(32.46,212.66) v2(37.19,224.47) v5(29.46,219.82) v5(29.46,218.68) v5(29.46,217.53) v5(29.46,216.39) v5(29.46,214.99) v5(29.46,213.47) v5(29.46,211.95) v5(29.46,210.55) v5(29.46,209.28) v5(30.35,220.84) v5(30.73,216.9) v5(30.73,214.23) v5(30.73,212.71) v5(30.73,211.31) v5(30.73,209.91) v5(31.5,220.84) v5(32.26,221.73) v5(32.64,220.84) v5(33.53,221.73) v5(33.78,220.84) v5(34.92,220.84) v5(36.02,219.74) v5(36.07,220.84) v5(37.21,220.84) v5(37.16,219.74) v5(38.3,219.74) v5(38.35,220.84) v5(39.45,219.74) v5(39.5,220.84)
PWM1_SNB: length 2.3
  TOP w0.635: R28.1 v1(33.02,226.12) C10.1
PWM1_VCC: length 5
  BOTTOM w0.305: U17.4 17.56,226.88 16.74,227.69 v2(16.74,227.94) 16.42,227.63 C395.2
  BOTTOM w0.508: R694.2 15.51,228.37 15.55,228.32 C395.2
PWM2: length 53.1
  L3 w0.305: v3(15.04,202.96) 16.43,204.35 16.43,221.45 14.4,223.48 14.4,228.74 14.43,228.76 14.43,239.61 16.13,241.31 21.44,241.31 21.54,241.21 21.54,241.11 21.59,241.06 v3(21.59,241.03)
  BOTTOM w0.203: R657.1 21.79,241.31 21.59,241.11 v3(21.59,241.03) 21.54,241.08 21.31,241.08 20.35,240.12 U35.10
  BOTTOM w0.305: U38.2 17.42,203.38 16.66,202.63 v2(16.18,202.63) 15.37,202.63 v3(15.04,202.96)
PWM2_BT: length 4
  BOTTOM w0.254: R779.1 v2(16.89,200.26)
  BOTTOM w0.305: 18.21,201.74 18.1,201.85 U38.1
  BOTTOM w0.508: R779.1 18.21,201.74
PWM2_BT_1: length 2.9
  BOTTOM w0.635: R779.2 21.21,200.26 v2(21.6,200.65) C410.1
PWM2_EN: length 2.6
  BOTTOM w0.254: R750.2 15.62,203.88 v2(16.51,203.88) U38.3
PWM2_HG: length 5.1
  TOP w0.635: v5(20.19,202.04) v1(21.33,200.9) 23.04,199.2 R88.1
  BOTTOM w0.305: U38.8 20.13,202.1 v5(20.19,202.04)
PWM2_HG_1: length 13.9
  TOP w0.635: Q21.4 v5(27.3,197.7) 26.14,197.7 24.97,198.87 R88.2 25.27,199.3 R84.2 ; Q23.4 v5(27.3,191.35)
  BOTTOM w0.635: v5(27.3,197.7) v2(27.3,194.17) v5(27.3,191.35)
PWM2_LG: length 16.8
  TOP w0.635: Q16.4 v5(26.31,204.96) ; v5(34.7,204.96) Q17.4
  BOTTOM w0.305: 21.46,204.71 21.14,204.38 U38.5
  BOTTOM w0.635: 21.46,204.71 21.72,204.96 v5(26.31,204.96) v2(29.21,204.96) v5(34.7,204.96)
PWM2_LX: length 31.6
  TOP w0.508: L5.1 32.55,196.61 ; L5.1 34.15,195.01 ; L5.1 32.55,193.41 ; L5.1 30.95,195.01
  TOP w0.635: v5(21.46,203.31) 23.11,201.66 25.21,201.66 R84.1 28.77,201.6 Q16.5
  L3 w0.508: 32.55,193.41 L5.1 ; L5.1 34.15,195.01 ; L5.1 30.95,195.01 ; L5.1 32.55,196.61
  BOTTOM w0.305: U38.7 21.39,203.38 v5(21.46,203.31)
  BOTTOM w0.508: L5.1 34.15,195.01 ; L5.1 32.55,193.41 ; L5.1 30.95,195.01 ; L5.1 32.55,196.61 ; G3.1 35.69,193.15 35.18,193.15
  BOTTOM w0.635: C410.2 21.66,203.12 v5(21.46,203.31)
  vias: v2(32.49,187.79) v2(37.47,201.86) v5(29.21,196.96) v5(29.21,195.82) v5(29.21,194.67) v5(29.21,193.53) v5(29.21,192.26) v5(29.21,191.12) v5(29.21,189.98) v5(29.21,188.83) v5(29.21,187.69) v5(29.21,186.55) v5(30.23,197.85) v5(30.48,194.04) v5(30.48,192.9) v5(30.48,191.75) v5(30.48,190.61) v5(30.48,189.59) v5(30.48,188.45) v5(30.48,187.31) v5(30.48,186.17) v5(31.37,197.85) v5(32.51,197.85) v5(32.77,198.74) v5(33.66,197.85) v5(34.04,198.74) v5(34.8,197.85) v5(35.94,197.85) v5(36.07,196.45) v5(37.08,197.85) v5(37.21,196.45) v5(38.23,197.85) v5(38.35,196.45) v5(39.37,197.85) v5(39.5,196.45)
PWM2_SNB: length 2.3
  TOP w0.635: C42.2 v1(33.4,203.29) R79.1
PWM2_VCC: length 6
  BOTTOM w0.305: U38.4 17.09,204.38 16.2,205.27 C403.2
  BOTTOM w0.508: v2(16.76,206.93) R729.2 15.38,205.45 C403.2
PWM3: length 90.5
  TOP w0.305: v3(16.56,167.88) 20.18,167.88 20.57,167.49 20.58,167.49 20.58,167.49 U5.2
  L3 w0.305: v3(21.54,240.27) 20.93,240.27 20.52,240.67 16.69,240.67 15.04,239.02 15.04,223.71 17.04,221.7 17.04,203.97 v3(15.04,201.96)
  L4 w0.305: v3(15.04,201.96) 15.16,201.84 15.16,200.36 13.59,198.79 13.59,194.62 14.63,193.58 14.63,183.69 17.07,181.25 17.07,169.24 16.94,169.11 16.94,169.11 16.56,168.73 v3(16.56,167.88)
  BOTTOM w0.203: U35.11 21.02,239.72 21.54,240.24 v3(21.54,240.27) 21.64,240.17 R662.1
PWM3_BT: length 4.1
  TOP w0.305: U5.1 21.21,169.17 21.64,169.61
  TOP w0.508: 21.64,169.61 R108.1 v1(20.19,170.42)
PWM3_BT_1: length 3.2
  TOP w0.635: R108.2 24.77,170.42 v1(25.02,170.16) 25.4,169.78 C67.1
PWM3_EN: length 2.8
  TOP w0.254: v1(19.81,165.87) 19.55,166.14 R112.1 20.75,166.91 20.83,166.99 U5.3
PWM3_HG: length 6.2
  TOP w0.305: U5.8 23.46,167.99 23.86,168.39 v5(24.26,168.39)
  BOTTOM w0.635: R813.1 v2(24.46,171.38) 24.46,168.59 v5(24.26,168.39)
PWM3_HG_1: length 13.9
  TOP w0.635: v5(27.3,178.14) 27.3,176.97 Q25.4 ; v5(27.3,184.24) Q24.4
  BOTTOM w0.635: R813.2 R812.2 24.46,177.78 24.91,178.23 v2(25.78,178.23) 27.21,178.23 v5(27.3,178.14) v5(27.3,184.24)
PWM3_LG: length 20.2
  TOP w0.305: U5.5 23.86,166.49 24.26,166.1 24.26,165.67 v5(24.28,165.64)
  TOP w0.635: v5(40.57,165.02) 39.66,165.02 Q28.4 ; Q27.4 31.28,165.02 v5(32.19,165.02)
  BOTTOM w0.635: v5(24.28,165.64) 24.91,165.02 v5(32.19,165.02) v2(35.18,165.02) v5(40.57,165.02)
PWM3_LX: length 27.1
  TOP w0.305: U5.7 23.93,167.49 24.31,167.12 v5(24.36,167.12)
  TOP w0.508: L6.1 33.33,175.59 ; L6.1 31.73,177.19 ; L6.1 30.13,175.59 ; L6.1 31.73,173.99
  TOP w0.635: C67.2 v5(24.36,167.12)
  L3 w0.508: 31.73,173.99 L6.1 ; L6.1 30.13,175.59 ; L6.1 31.73,177.19 ; L6.1 33.33,175.59
  BOTTOM w0.508: L6.1 31.73,173.99 ; L6.1 31.73,177.19 ; L6.1 33.33,175.59 ; L6.1 30.13,175.59 ; 34.29,176.64 34.29,178.03 G6.1
  BOTTOM w0.635: 27.05,167.12 v5(24.36,167.12)
  vias: v2(29.24,168.39) v2(35.81,175.42) v5(29.08,172.32) v5(29.21,181.04) v5(29.21,179.89) v5(29.21,178.75) v5(29.21,177.66) v5(29.21,176.51) v5(29.21,175.37) v5(29.21,174.23) v5(30.05,173.67) v5(30.1,172.32) v5(30.3,181.64) v5(30.3,180.5) v5(30.3,179.36) v5(30.3,178.22) v5(31.11,172.32) v5(31.19,173.67) v5(32.13,172.32) v5(32.33,173.67) v5(32.89,171.43) v5(33.15,172.32) v5(33.48,173.67) v5(34.04,171.43) v5(34.29,172.32) v5(34.92,173.72) v5(35.43,172.32) v5(36.32,173.72) v5(36.58,172.32) v5(37.72,172.32) v5(38.86,172.32) v5(39.88,172.32)
PWM3_SNB: length 2.5
  TOP w0.635: R111.1 33.5,166.89 v1(33.53,166.86) 33.53,165.97 C71.2
PWM3_VCC: length 5.9
  TOP w0.305: C75.2 21.21,165.72 U5.4
  TOP w0.508: C75.2 20.57,164.32 R113.1 22.76,163.33 v1(22.76,162.75)
PWM4: length 3.8
  BOTTOM w0.203: v2(20.83,241.54) 20.42,241.13 20.42,240.93 20.02,240.53 U35.9
  BOTTOM w0.305: R655.1 21.74,242.45 v2(20.83,241.54)
PWR2_PRSN_1: length 4.1
  BOTTOM w0.254: R1059.2 55.91,35.84 v2(55.91,35.04) 55.61,35.04 R1064.1 54.22,35.96 54.18,35.92 Q110.2
PWR2_PRSN_2: length 5.7
  BOTTOM w0.254: R1060.2 49.85,36.88 50.8,37.83 v2(51.18,37.83) 51.31,37.83 51.61,37.52 51.61,36.81 Q110.6 50.61,36.58 50.42,36.38 50.42,36.13 50.62,35.92 Q110.5
PWR2_PRSNT: length 6.8
  TOP w0.203: v3(52.25,34.43) 52.25,34.69 51.67,35.27 U24.108
  TOP w0.508: R565.2 52.17,32.99 52.17,34.16 52.25,34.23 v3(52.25,34.43)
  BOTTOM w0.406: v3(52.25,34.43) 52.32,34.5 52.32,34.61 52.98,35.27 Q110.3 54.12,35.27 v2(54.61,34.78)
PWR_5V_BOOT1_1: length 4.1
  TOP w0.635: 94.23,32.88 95.3,32.88 PR90.1 v3(97.16,32.29)
  BOTTOM w0.635: v3(97.16,32.29) v2(97.16,33.26)
PWR_DEBUG: length 43.9
  TOP w0.102: CPU1.N40 73.75,187.19 74.98,188.42 74.98,194.84 78.18,198.04 78.18,200.19 71.86,206.51 R74.2 R73.2 69.52,207.07 69.52,209.08 69.22,209.38 R64.1 69.7,210.33 69.7,211 68.77,211.92 65.96,211.92 65.55,212.34 65.55,214.25 67.23,215.93 v1(67.23,216.19) 67.08,216.34 Q9.3
PWR_DEBUG_1: length 6.2
  TOP w0.102: v1(64.83,222.11) R37.2 64.9,221.03 Q9.5 64.9,217.53 64.64,217.28 64.39,217.28 64.25,217.42 Q9.6
PWR_DEBUG_N: length 9.8
  TOP w0.102: R38.2 v1(63.53,219.87) 63.86,219.87 63.96,219.76 63.96,219.14 63.63,218.8 62.71,218.8 R42.2 R47.2 ; C20.1 R51.1 62.62,216.64 R47.2 ; R47.2 63.2,217 63.94,217 63.97,217.03 64.52,217.03 64.55,217 64.59,217 64.9,216.7 Q9.2
PWR_LED_YELLOW_1: length 2.5
  TOP w0.254: R1027.2 19.94,44.21 v1(20.06,44.33) 20.8,44.33 R1031.1
PWR_LED_YELLOW_C: length 21.7
  TOP w0.254: v3(19.05,44.15) 19.05,44.33 20.19,45.48 R1031.2
  L3 w0.254: v3(19.05,44.15) 11.23,44.15 v3(9.47,42.4)
  BOTTOM w0.254: v3(19.05,44.15) 18.57,44.15 17.71,43.29 Q103.D 17.71,42.34 17.92,42.14 R1033.1 ; v3(9.47,42.4) 9.09,42.02 6.59,42.02 PWRCN1.2
PWR_VGA_CORE_BOOT1: length 3.4
  TOP w0.203: PR43.1 36.98,135.68 v1(36.98,136.61) 36.98,137.19 37.89,138.11 U9.19
PWR_VGA_CORE_COMP: length 10.1
  TOP w0.203: PR13.2 39.69,144.07 40.4,143.36 U9.7
  TOP w0.254: v1(39.78,148.65) 39.45,148.98 39.21,148.98 38.99,149.21 PR1.2 PC4.2 PC6.1 38.54,146.41 PC8.1 39.2,146.22 39.27,146.29 PC7.2 PR13.2
PWR_VGA_CORE_DPRSLPVR: length 5.2
  TOP w0.203: U9.39 44.07,140.91 44.32,141.16 44.32,142.29
  TOP w0.254: PR17.2 45.92,143.82 v1(45.62,143.52) 45.42,143.32 45,143.32 44.92,143.24 44.89,143.24 44.89,143.24 44.74,143.24 44.32,142.82 44.32,142.29
PWR_VGA_CORE_FB: length 16.5
  TOP w0.203: U9.8 40,143.12 39.37,143.75 39.12,143.75 38.99,143.87
  TOP w0.508: PR8.2 PC8.2 v3(38.73,144.48) 38.73,144.13 38.99,143.87 ; v3(31.25,141.83) PR20.1 32.68,141.83 32.74,141.77 PR21.1
  L3 w0.508: v3(38.73,144.48) 36.08,141.83 v3(31.25,141.83)
  BOTTOM w0.508: v2(37.85,144.51) 38.71,144.51 v3(38.73,144.48)
PWR_VGA_CORE_FB2: length 9.8
  TOP w0.203: U9.9 39.6,142.54 39.09,143.05
  TOP w0.508: 39.09,143.05 38.74,143.05 37.88,143.91 37.88,144.15 36.8,145.22 36.8,145.81 36.68,145.94 v1(36.68,146.03) 36.32,146.39 36.32,146.54 35.56,147.3 PC5.2 36.07,148.19 PC4.1
PWR_VGA_CORE_IMON: length 8.3
  TOP w0.203: U9.18 37.68,138.51 37.34,138.16 36.37,138.16 v3(36.14,138.39)
  BOTTOM w0.254: v2(31.5,137.02) 31.5,137.49 PR99.2 32.5,137.86 PC59.2 PR98.1 34.7,137.96 35.56,137.96 36,138.39 v3(36.14,138.39)
PWR_VGA_CORE_ISEN1: length 19.3
  TOP w0.203: v3(36.42,143.49) 36.66,143.49 38.04,142.11 38.11,142.11 38.44,141.78 U9.11
  TOP w0.254: v3(36.42,143.49) 35.94,143.98 PC10.2 PR12.2 ; v1(33.02,133.71) 32.61,133.31 v3(32.61,132.95) PR46.1
  L4 w0.254: v3(36.42,143.49) 34.26,141.34 34.26,135.85 32.61,134.2 v3(32.61,132.95)
PWR_VGA_CORE_ISEN2: length 6.9
  TOP w0.203: 38.28,142.6 38.81,142.06 U9.10
  TOP w0.254: 38.28,142.6 38.24,142.6 36.97,143.86 36.97,143.92 v1(36.54,144.35) 36.17,144.72 36.17,145.55 35.75,145.97 PR12.1 PR11.2
PWR_VGA_CORE_ISUM+: length 13.5
  TOP w0.203: PR34.1 35.63,137.85 35.63,138.61 36.95,139.93 37.6,139.93 37.82,139.71 U9.15
  TOP w0.254: PR34.1 36.13,135.87 PR42.1 35.85,135.59 PC16.1 34.73,135.66 PR41.1 32.74,135.66 PC15.1 32.4,135.63 31.37,134.6 v1(31.37,134.48) PR45.1
PWR_VGA_CORE_ISUM-: length 17.4
  TOP w0.203: 36.41,140.26 37.73,140.26 37.88,140.11 U9.14
  TOP w0.254: 36.41,140.26 35.2,139.05 34.65,139.05 33.21,137.61 PC14.1 30.91,137.35 v1(30.86,137.4) 30.11,138.15 30.11,143.25 30.86,144 PR16.2
PWR_VGA_CORE_LGATE1A: length 46.5
  TOP w0.203: U9.23 40,135.76 39.42,135.19 v5(39.42,135.06)
  TOP w0.635: PU4.4 v5(36.7,100.67) ; PU3.4 v5(31.24,102.09)
  L3 w0.635: v5(39.42,135.06) 39.42,134.81 39.51,134.72 39.51,115.92 36.7,113.12 v5(36.7,100.67)
  BOTTOM w0.635: v5(31.24,102.09) v2(34.16,102.09) 35.81,102.09 35.81,102.08 35.82,102.08 36.7,101.19 v5(36.7,100.67)
PWR_VGA_CORE_LGATE1B: length 3.1
  TOP w0.203: U9.24 40.4,135.63 40.16,135.39 40.16,134.5 TP9.1
PWR_VGA_CORE_NTC: length 58
  TOP w0.203: 42.25,145.28 41.2,144.23 U9.5
  TOP w0.254: v3(24.1,107.76) 24.63,108.28 PR60.2 ; v3(41.53,145.28) PC9.1
  L4 w0.254: v3(41.53,145.28) 41.09,145.73 32.96,145.73 32.66,145.38 32.66,141.9 33.27,141.29 33.27,137.1 30.88,134.7 30.88,133.33 30.07,132.52 30.07,131.49 29.76,131.17 29.72,131.17 29.02,130.47 28.02,130.47 24.1,126.55 v3(24.1,107.76)
  BOTTOM w0.254: v3(41.53,145.28) v2(42.42,145.28)
PWR_VGA_CORE_ON: length 9.1
  TOP w0.203: PC12.1 47.45,142.02 45.44,142.02 45.41,141.99 45.26,141.99 45.21,141.94 45.14,141.94 44.83,141.64 44.83,141.18 44.15,140.51 U9.38
  TOP w0.254: PC12.1 48.11,143.57 48.36,143.82 v1(48.41,143.82) PR18.2 PR19.2
PWR_VGA_CORE_PGOOD: length 5.8
  TOP w0.203: U9.1 43.4,142.06 43.56,142.22 43.56,142.94 43.87,143.24
  TOP w0.254: PR14.1 46.37,145.12 v1(45.54,145.12) 45.33,144.91 45.33,144.36 44.71,143.75 44.68,143.75 44.68,143.75 44.4,143.75 43.9,143.24 43.87,143.24
PWR_VGA_CORE_PHASE1: length 43.3
  TOP w0.203: U9.21 39.2,136.64 38.56,136
  TOP w0.508: PL1.1 31.42,113.28 ; PL1.1 29.82,111.68 ; PL1.1 28.22,113.28 ; PL1.1 29.82,114.88
  TOP w0.635: v5(38.07,132.62) 38.56,133.11 PC19.1 38.56,136
  L3 w0.635: PL1.1 34.78,113.28 38.07,116.57 v5(38.07,132.62)
  BOTTOM w0.508: PL1.1 29.82,114.88 ; PL1.1 29.82,111.68 ; PL1.1 28.22,113.28 ; PL1.1 31.42,113.28
  vias: v2(30.96,105.77) v2(34.59,111.62) v5(27.43,109.1) v5(27.51,112.89) v5(27.58,110.91) v5(27.84,114.82) v5(28.4,118.02) v5(28.4,116.49) v5(28.78,110.04) v5(29.41,117.23) v5(30.12,110.85) v5(30.2,109.08) v5(30.3,118.07) v5(30.4,116.06) v5(31.5,110.04) v5(32.16,112.1) v5(33.22,109.23) v5(33.32,110.78) v5(34.62,110.4) v5(35.1,109.28)
PWR_VGA_CORE_PSI#: length 4.5
  TOP w0.203: 43.18,143.24 42.8,143.24 42.4,142.84 U9.2
  TOP w0.254: PR10.1 44.55,144.51 44.45,144.41 ; 44.45,144.41 v1(44.45,144.38) ; 44.45,144.41 44.37,144.33 44.3,144.33 44.22,144.26 44.2,144.26 43.18,143.24
PWR_VGA_CORE_RTN: length 145.9
  TOP w0.203: v3(37.26,140.78) 37.45,140.59 37.87,140.59 37.95,140.51 U9.13
  TOP w0.254: v3(37.26,140.78) 36.83,141.21 36.83,141.33 36.2,141.96 PR22.1 35.78,141.96 35.65,141.83 PC13.2 35.26,141.23 34.8,140.78 34.8,140.29 33.76,139.25 v1(33.73,139.25) 33.73,139.23 32.92,138.41 v3(31.24,138.41) ; v3(82.42,74.02) 82.41,74.02 82.41,71.48 79.01,68.07 76.71,68.07 74.41,65.77 69.1,65.77 66.62,68.25 50.15,68.25 46.91,71.49 44.04,71.49 41.2,74.33 41.2,89.47 38.99,91.68 v3(38.99,108.7)
  L3 w0.254: v3(31.24,138.41) 31.37,138.54 34.16,138.54 35.37,137.34 39.73,137.34 40.91,136.16 40.91,110.87 38.99,108.95 v3(38.99,108.7)
  BOTTOM w0.254: PC59.1 32.5,139.38 PR99.1 31.89,139.06 v3(31.24,138.41) ; v3(82.42,74.02) 82.42,74.12 83.9,75.6 83.9,77.81 83.82,77.89 PR29.2 ; v3(37.26,140.78) 37.85,140.19 PC57.1
PWR_VGA_CORE_SNB1: length 3.1
  BOTTOM w0.635: PC65.1 PR114.2 v2(26.29,105.57)
PWR_VGA_CORE_UGATE1: length 23.1
  TOP w0.203: v5(37.95,136.59) 38.44,137.08 U9.20
  L3 w0.635: v5(37.95,136.59) 36.75,135.39 36.75,133.99 34.54,131.78 32.16,131.78 30.91,130.54 30.91,122.49 v5(30.3,121.88)
  BOTTOM w0.254: v2(37.08,136) 37.67,136.59 v5(37.95,136.59)
  BOTTOM w0.635: PR105.2 v5(30.3,121.88)
PWR_VGA_CORE_UGATE1_R: length 11.3
  TOP w0.635: 25.53,120.51 v5(26.92,120.51) ; 25.53,114.16 v5(25.53,115.15)
  L3 w0.635: v5(26.92,120.51) 26.92,116.93 25.53,115.53 v5(25.53,115.15)
  BOTTOM w0.635: v5(26.92,120.51) PR105.1 v2(28.37,122.03)
PWR_VGA_CORE_VCCP: length 5.4
  TOP w0.203: PC17.1 41.35,134.71 v1(40.84,135.21) 40.84,136.18 40.8,136.23 U9.25
  TOP w0.508: PR44.1 43.22,134.59 PC18.1 PC17.1
PWR_VGA_CORE_VDD: length 6.5
  TOP w0.203: U9.16 37.44,139.31 37.39,139.36 v3(37.39,139.42)
  BOTTOM w0.508: PR95.2 34.59,140.26 PR98.2 34.59,139.28 34.65,139.23 35.53,139.23 35.74,139.43 v2(35.94,139.43) 37.37,139.43 v3(37.39,139.42) 37.63,139.18 PC58.1
PWR_VGA_CORE_VID0: length 7.1
  TOP w0.102: U9.31 43.96,137.71 44.7,136.97 44.7,134.91 45.32,134.3 v1(46.91,134.3) 46.91,134.73 46.65,135 PR39.2
PWR_VGA_CORE_VID1: length 5.6
  TOP w0.102: PR37.2 45.5,135.19 v1(45.47,135.19) 44.93,135.72 44.93,137.14 43.97,138.11 U9.32
PWR_VGA_CORE_VID2: length 4.8
  TOP w0.102: U9.33 44.23,138.51 44.83,137.91 44.83,137.64 45.29,137.19 45.29,136.74 v1(45.57,136.45) 45.75,136.45 PR35.2
PWR_VGA_CORE_VID3: length 3.9
  TOP w0.102: U9.34 44.36,138.91 v1(45.54,137.72) 46.01,137.72 PR32.2
PWR_VGA_CORE_VID4: length 3.4
  TOP w0.102: PR30.2 46.26,138.99 v1(45.66,138.99) 45.34,139.31 U9.35
PWR_VGA_CORE_VID5: length 3.4
  TOP w0.102: U9.36 44.79,139.71 v1(45.28,140.2) 45.48,140.4 PR25.2
PWR_VGA_CORE_VID6: length 3.7
  TOP w0.102: PR23.2 v1(45.67,141.41) 45.57,141.41 44.26,140.11 U9.37
PWR_VGA_CORE_VIN: length 5.6
  TOP w0.203: v3(36.96,138.67) 37.2,138.91 U9.17
  BOTTOM w0.254: v2(38.86,136.76) 38.86,137.47 PC60.2
  BOTTOM w0.508: v3(36.96,138.67) 37.27,138.35 PR101.2 37.9,137.52 PC60.2
PWR_VGA_CORE_VSEN: length 144.8
  TOP w0.203: U9.12 37.96,140.91 37.47,141.4 v3(37.47,141.72)
  TOP w0.254: v3(37.47,141.72) 36.46,142.72 PC13.1 34.24,142.72 PC11.2 PR21.2 34.18,140.78 PR27.2 32.7,139.3 v3(31.24,139.3) ; v3(81.66,74.02) 82.06,73.63 82.06,71.84 78.91,68.69 76.45,68.69 74.04,66.28 69.47,66.28 66.99,68.76 50.36,68.76 47.12,72 46.91,72 46.8,72.11 44.14,72.11 41.73,74.52 41.73,89.8 39.5,92.03 39.5,108.34 v3(39.85,108.7)
  L3 w0.254: v3(39.85,108.7) 39.85,109.05 41.41,110.61 41.41,136.37 39.9,137.89 36.38,137.89 36.36,137.86 35.6,137.86 35.05,138.41 35.01,138.41 34.37,139.05 31.5,139.05 v3(31.24,139.3)
  BOTTOM w0.254: PC56.1 38.1,141.08 v3(37.47,141.72) v2(37.47,142.6) ; v3(81.66,74.02) 83.54,75.9 83.54,77.5 83.44,77.61 83.44,80.57 PR28.2
PWR_VGA_CORE_VSUM-: length 36.6
  TOP w0.254: PR51.2 35.9,122.04 36.09,122.23 36.09,128.63 35.69,129.04 v1(35.69,129.78) 35.69,130.29 36.27,130.87 36.27,131.73 35.13,132.88 PC20.2 ; PC20.2 34.77,134.05 PC16.2 34.1,134.77 PR41.2 32.74,134.77 PC15.2 ; PC20.2 34.05,132.15 PR47.1 v3(33.66,132.95) ; v3(33.22,144.92) 32.83,144.52 PR16.1 32.85,143.98 PC10.1
  L4 w0.254: v3(33.66,132.95) 33.66,134.52 34.77,135.64 34.77,141.09 36.95,143.27 36.95,143.71 35.75,144.92 v3(33.22,144.92)
PWR_VGA_CORE_VW: length 4.3
  TOP w0.203: PR13.1 v1(40.58,144.26) 40.58,143.94 40.8,143.72 U9.6
  TOP w0.254: PR13.1 PC7.1
PWRBTN_N: length 484.4
  TOP w0.102: R549.2 16.51,35.28 16.51,35.02 C297.1 15.96,35.14 13.44,35.14 12.95,34.65 v3(11.43,34.65) ; U29.AK41 140.91,86.08 141.55,86.72 141.55,88.93 141.2,89.29 141.2,89.69 141.92,90.41 v4(142.11,90.41) 142.49,90.79 142.49,91.56 143.45,92.52 144.44,92.52 145.57,93.65 v3(145.57,95.84) ; v3(55.12,61.71) 56.12,61.71 56.59,61.24 56.59,60.51 59.49,57.62 60.21,57.62 60.5,57.32 60.5,54.21 59.79,53.5 v3(59.79,53.32) 59.65,53.32 59.27,52.94 U24.34
  L4 w0.127: v3(145.57,95.84) 143.66,97.75 143.66,104.35 150.08,110.77 150.08,112.78 150.46,113.16 150.46,113.51 152.53,115.58 163.89,115.58 165.31,117 169.32,117 176.96,124.64 176.96,140.69 178.3,142.03 178.3,154.43 178.23,154.5 178.23,159.1 177.77,159.55 177.77,173.57 177.29,174.05 177.29,190.19 168.59,198.89 164.22,198.89 157.11,206 153.91,206 153.47,206.44 145.21,206.44 143.5,208.15 143.5,208.83 139.94,212.39 139.55,212.39 139.23,212.39 136.56,215.06 129.6,215.06 129.21,215.45 127.91,215.45 127,216.36 127,216.68 126.31,217.37 124.09,217.37 123.99,217.47 123.39,217.47 122.9,217.95 119.66,217.95 118.48,216.77 117.68,216.77 117.34,216.43 114.77,216.43 114.26,215.92 109.48,215.92 107.37,218.03 107.37,223.68 105.68,225.37 94.91,225.37 93.34,226.93 90.14,226.93 89.12,227.95 53.87,227.95 v3(52.32,226.4) ; v3(34.1,49.13) 34.1,49.32 33.44,49.98 33.44,53.51 35.83,55.9 36.9,55.9 38.07,57.08 38.07,57.14 41.35,60.41 43.55,60.41 45.7,62.56 54.27,62.56 v3(55.12,61.71) 55.68,61.15 67.62,61.15 73.12,66.65 76.28,66.65 76.83,67.2 85.06,67.2 87.41,69.55 94.68,69.55 94.84,69.39 109,69.39 116.38,76.77 116.38,78.68 119.51,81.8 119.51,82.02 119.77,82.28 123.99,82.28 124.65,82.93 127.34,82.93 128.22,83.81 129.1,83.81 129.17,83.74 129.91,83.74 131.27,85.1 135.22,85.1 136.98,86.86 136.98,87.14 139.58,89.73 140,89.73 140.65,90.38 142.09,90.38 v4(142.11,90.41)
  BOTTOM w0.102: v3(59.79,53.32) 60.07,53.32 61,52.4 R1001.2 ; R697.1 52.25,226.48 v3(52.32,226.4) ; v3(11.43,34.65) 9.78,34.65 8.51,35.92 5.6,35.92 3.46,38.06 3.46,44.03 3.46,44.03 3.46,46.1 5.8,48.45 8.36,48.45 9.2,49.29 32.77,49.29 v2(33.05,49.01) 33.97,49.01 v3(34.1,49.13)
PWRCN_DET_N: length 161.8
  TOP w0.102: R349.1 R340.1 121.12,81.16 v3(121.59,81.16) ; U29.N34 v4(131.12,81.76)
  L4 w0.127: v3(34.92,49.06) 34.92,49.52 33.82,50.62 33.82,53.35 35.97,55.51 37.04,55.51 38.46,56.92 38.46,56.98 41.51,60.03 43.71,60.03 45.86,62.18 54.04,62.18 54.65,61.57 54.65,61.51 55.39,60.77 67.78,60.77 73.28,66.27 76.44,66.27 76.99,66.82 85.21,66.82 87.57,69.17 94.52,69.17 94.72,68.97 103.31,68.97 103.64,68.64 108.88,68.64 111.2,70.95 111.28,70.95 116.76,76.43 116.76,77.7 120.22,81.16 v3(121.59,81.16) 121.8,81.37 126.17,81.37 126.59,81.79 126.94,81.79 127.35,81.38 130.74,81.38 v4(131.12,81.76)
  BOTTOM w0.102: v3(34.92,49.06) 34.29,48.42 32.79,48.42 32.28,48.93 9.35,48.93 8.51,48.09 5.95,48.09 3.82,45.96 3.82,38.85 PWRCN1.6
PWRGD_3V: length 366.6
  TOP w0.102: U29.AT40 143.82,85.38 143.82,86.35 143.84,86.38 143.84,86.73 144.6,87.49 145.12,87.49 v4(147.32,89.68) 147.78,89.68 148.27,89.19 R287.1 ; v3(104.65,102.47) 104.65,111.02 R162.1 ; Q119.G 30.13,149.81 31.65,148.29 v3(33.02,148.29) ; v3(42.21,54.04) 42.16,54.09 42.16,54.49 42.42,54.75 R456.2 42.98,54.85 43.18,54.85 43.48,54.55 43.48,53.47 v3(45,51.96)
  L3 w0.127: v3(42.21,54.04) 42.04,54.04 40.64,55.43 30.2,55.43 29.74,55.89 29.74,64.47 27.99,66.23 27.99,72.4 28.56,72.98 28.56,74.04 28.56,74.52 21.39,81.69 21.39,97.29 21.13,97.55 21.13,119.16 22.53,120.56 22.53,135.42 26.14,139.02 27.86,139.02 28.47,139.63 28.47,146.8 29.44,147.76 32.49,147.76 v3(33.02,148.29)
  L4 w0.127: DB1.1 115.92,49.64 110.41,49.64 101.85,58.21 85.15,58.21 82.06,55.12 74.89,55.12 73.41,53.65 67.26,53.65 65.88,52.27 54.61,52.27 54.31,51.96 v3(45,51.96) ; v4(147.32,89.68) 146.33,90.66 143.88,90.66 143.49,91.06 138.63,91.06 137.61,90.03 137.05,90.03 135.53,88.52 135.53,88.17 133.37,86.01 127.52,86.01 125.83,84.32 119.26,84.32 113.97,79.03 113.97,78.78 106.62,71.43 v3(104.81,71.43)
  BOTTOM w0.102: DB1.1 119,46.56 v2(119,52.35) 105.47,65.88 105.47,69.1 104.83,69.74 104.83,69.81 104.81,69.82 v3(104.81,71.43) 104.81,75 103.76,76.06 103.76,87.36 100.84,90.28 100.84,94.62 101.35,95.13 105.81,95.13 106.4,95.72 106.4,100.72 v3(104.65,102.47) ; v2(42.3,53.23) 42.3,53.95 v3(42.21,54.04)
PWRGD_3V_B_1: length 9.3
  TOP w0.102: Q59.B 44.65,60.34 43.61,61.37 43.61,61.9 43.98,62.26 44.84,62.26 v1(44.86,62.25) 45.9,61.21 R440.2 47.52,59.74 Q60.D
PWRGD_3V_LL: length 9.5
  TOP w0.102: C262.1 R478.1 41.25,53.57 v1(41.25,55.31) 41.25,57.38 R449.2 41.78,56.99 41.78,56.63 42.1,56.31 R456.1 42.74,56.31 43.66,57.24 Q59.C
PWRGOOD_GPU: length 4.2
  TOP w0.102: U13.N10 77.38,82.97 v4(77.75,82.97)
  BOTTOM w0.102: R1158.2 78.57,81.05 78.47,81.16 78.47,81.51 77.85,82.13 77.42,82.13 v2(77.22,82.33) 77.22,82.71 77.47,82.97 v4(77.75,82.97)
PWROK3: length 10
  TOP w0.102: R454.1 45.43,56.71 v3(45.85,57.13) ; v1(40.36,57.36) 40.36,57.74 40.92,58.3 41.29,58.3 R449.1 R441.2 41.62,59.48 42.24,58.86 42.24,57.57 v3(42.67,57.13)
  L3 w0.127: v3(45.85,57.13) v3(42.67,57.13)
PWROK3_1: length 8
  TOP w0.102: R454.2 45.57,55.31 v1(45.57,54.54) 45.57,54.22 46.74,53.04 48.5,53.04 49.14,53.68 49.56,53.68 50.07,53.17 U24.57
PX_EN: length 2.1
  TOP w0.305: v4(85.21,86.7) 85.21,86.73 84.55,87.39 U13.AB16
  BOTTOM w0.508: TP159.1 85.22,86.47 85.22,86.7 v4(85.21,86.7)
Q46_PIN2: length 2.7
  BOTTOM w0.102: Q101.2 132.58,47.26 R1018.2 v2(132.14,45.83)
Q46_PIN3: length 9.1
  BOTTOM w0.102: R1015.2 133.63,47.86 Q101.3 133.68,49.72 Q100.G Q99.G 138.81,48.75 v2(138.81,48.66)
Q46_PIN6: length 4
  BOTTOM w0.102: Q101.4 134.92,47.91 134.62,47.61 134.62,46.97 134.98,46.61 Q101.6 136.68,46.61 v2(136.78,46.52)
Q54_B: length 5.1
  TOP w0.102: Q22.B 177.61,190.93 176.44,192.1 176.44,192.86 177.14,193.56 v1(177.14,193.66) 176.86,193.94 R97.2
Q54_C: length 4.8
  TOP w0.102: Q22.C 175.7,191 176.94,189.77 177.11,189.77 v1(177.72,189.16) 177.46,188.9 R103.1
QF2_1: length 3.3
  BOTTOM w0.102: QF1.2 144.65,97.27 143.58,98.34 v2(143.51,98.34) R873.2
QF2_2: length 5.3
  BOTTOM w0.102: QF1.6 146.19,96.62 146.05,96.76 146.05,97.14 146.18,97.27 QF1.5 147.88,97.27 148.07,97.08 R880.2 149.42,97.08 v2(149.61,97.27)
QSAN_0: length 37.5
  TOP w0.127: v4(72.95,96.75) 73.19,96.75 73.35,96.59 U13.H27
  L3 w0.152: v4(72.95,96.75) 73.25,97.05 73.25,97.7 73.54,97.99 73.54,98.17 73.28,98.43 73.1,98.43 72.87,98.21 72.11,98.21 71.72,98.59 71.72,101.54 71.07,102.19 69.83,102.19 69.29,102.73 69.29,103.26 69.57,103.54 69.57,103.78 68.45,104.9 65.99,104.9 65.48,104.39 65.48,103.51 65.05,103.08 64.28,103.08 63.95,103.41 63.95,103.54 63.79,103.69 63.49,103.69 63.34,103.54 63.34,103.41 63.01,103.08 62.45,103.08 62.12,103.41 62.12,103.54 61.97,103.69 61.66,103.69 61.51,103.54 61.51,103.41 61.18,103.08 60.69,103.08 60.19,102.57 59.58,102.57 59.27,102.88 59.27,104.76 59.15,104.89 58.67,104.89 58.55,104.76 58.55,102.2 58.44,102.09 58.44,102.06 58.03,101.65 57.1,101.65 57.01,101.74 57,101.74 56.89,101.85 54.5,101.85 54.34,101.69 54.34,101.49 54.61,101.22 v4(54.77,101.22)
  BOTTOM w0.127: v4(72.95,96.75) 72.95,97.26 v2(73.19,97.5) ; MEM3.G3 54.36,101.08 54.5,101.22 v4(54.77,101.22)
QSAN_1: length 35.1
  TOP w0.102: U13.A27 68.19,96.34 67.9,96.62 67.9,96.73
  TOP w0.127: v4(66.73,97.88) 67.08,97.52 67.28,97.52 67.9,96.9 67.9,96.73
  BOTTOM w0.127: MEM3.B7 51.16,104.49 51.27,104.38 51.48,104.38 51.69,104.59 51.69,105.07 52.24,105.61 52.91,105.61 53.06,105.76 53.06,106.03 52.93,106.15 52.64,106.15 52.32,106.47 52.32,107.12 52.59,107.4 53.74,107.4 54,107.13 54,106.76 54.2,106.56 54.48,106.56 54.68,106.76 54.68,107.12 54.93,107.37 57.57,107.37 60.86,104.09 60.86,102.33 ; v4(66.73,97.88) 66.5,97.64 66.14,97.64 65.48,96.99 64.85,96.99 64.72,97.11 64.72,97.55 64.45,97.82 63.98,97.82 63.71,97.55 63.71,97.11 63.58,96.99 63.33,96.99 63.2,97.11 63.2,97.52 62.92,97.8 62.46,97.8 62.18,97.52 62.18,97.11 62.06,96.99 61.6,96.99 61.37,97.22 61.37,100.68 60.86,101.19 60.86,102.33 ; 60.86,102.33 v2(61.14,102.33)
QSAN_2: length 36
  TOP w0.102: 65.94,93.17 65.96,93.15 67.98,93.15 68.18,92.95 69.07,92.95 69.21,92.81 69.49,92.81 69.5,92.82 69.59,92.9 70.05,92.9 70.15,92.99 U13.C23
  TOP w0.127: 65.94,93.17 65.31,93.17 62.26,96.22 62.26,97.09 ; 62.26,97.09 62.26,100.26 62.53,100.54 63.04,100.54 63.17,100.66 63.17,100.92 63.04,101.04 62.53,101.04 62.26,101.32 62.26,101.78 62.53,102.06 63.09,102.06 63.22,102.19 63.22,102.94 62.12,104.03 61.94,104.03 61.68,103.77 61.29,103.77 60.96,104.1 60.96,104.49 61.22,104.75 61.22,104.93 60.9,105.26 60.72,105.26 60.44,104.98 60.05,104.98 59.72,105.31 59.72,105.7 60,105.98 60,106.16 59.82,106.34 59.64,106.34 59.36,106.06 58.97,106.06 58.64,106.39 58.64,106.78 58.92,107.06 58.92,107.24 58.6,107.56 55.23,107.56 53.76,106.09 53.65,106.09 53.4,105.85 53.4,105.5 54.07,104.84 54.35,104.84 MEM1.B7 ; 62.26,97.09 v1(61.87,97.09)
QSAN_3: length 35
  TOP w0.102: v4(66.27,90.84) 66.93,90.18 68.24,90.18 69.12,90.18 69.21,90.27 69.47,90.27 arc(69.54,90.22) 69.62,90.21 69.87,90.21 70.14,89.94 U13.C19
  TOP w0.127: v4(52.55,102.04) 52.32,102.04 51.82,101.54 51.62,101.54 51.36,101.28 51.36,101.02 MEM1.G3
  L4 w0.152: v4(66.27,90.84) 66.09,91.02 66.09,94.21 64.29,96.02 64.29,96.81 62.25,98.84 62.25,99.47 62.46,99.67 62.46,100.16 62.08,100.54 61.6,100.54 61.03,99.97 60.8,99.97 60.6,100.17 60.6,100.4 61.24,101.04 61.24,101.51 60.84,101.9 60.38,101.9 59.61,101.14 59.38,101.14 59.18,101.33 59.18,101.57 59.95,102.34 59.95,102.8 59.55,103.2 59.08,103.2 58.8,102.92 58.59,102.92 58.17,103.34 56.99,103.34 56.55,103.77 54.73,103.77 54.13,103.17 53.48,103.17 53.44,103.13 53.15,103.13 52.9,102.88 52.89,102.88 52.79,102.78 52.65,102.78 52.43,102.55 52.43,102.17 v4(52.55,102.04)
QSAN_4: length 34.4
  TOP w0.102: U13.C15 69.9,86.62 69.67,86.51 69.47,86.41 68.24,86.41 67.98,86.15 67.32,86.15 67.24,86.08 67.24,85.78 v4(67.24,85.78)
  L4 w0.152: v4(67.24,85.78) 67.19,85.73 63.9,85.73 62.91,84.73 62.91,78.08 62.56,77.74 62.35,77.74 62.07,78.02 61.58,78.02 61.2,77.65 61.2,77.16 61.49,76.88 61.49,76.66 61.27,76.44 61.05,76.44 60.82,76.68 60.33,76.68 59.95,76.31 59.95,75.82 60.19,75.58 60.19,75.37 59.32,74.5 59.12,74.5 58.7,74.08 56.67,74.08 56.5,74.26 56.5,74.74 55.86,75.38 55.14,75.38 54.81,75.04 54.81,74.85 54.71,74.75 54.36,74.75 54.26,74.86 54.26,76.74 53.8,77.19 53.02,77.19 52.5,77.72 52.05,77.72 51.72,78.05 v4(51.64,78.05)
  BOTTOM w0.127: v4(51.64,78.05) 51.27,78.05 51.16,78.16 MEM4.G3
QSAN_5: length 36.7
  TOP w0.102: U13.E9 70.23,82.27 70.03,82.27 70.02,82.26 69.97,82.24 69.82,82.21 69.67,82.21 69.46,82.27 68.91,82.27 68.02,82.27 67.76,82.01 67.4,82.01 66.6,81.21 66.55,81.21
  TOP w0.127: 62.46,80.4 61.7,80.4 61.57,80.27 61.57,76.77 61.31,76.5 60.83,76.5 60.68,76.36 60.68,75.96 60.77,75.87 61.33,75.87 61.57,75.63 61.57,74.96 61.36,74.75 60.63,74.75 60.52,74.64 60.52,74.22 60.62,74.12 61.21,74.12 61.49,73.84 61.49,71.95 61.22,71.68 60.41,71.68 60.16,71.93 60.16,72.64 59.99,72.81 59.69,72.81 59.52,72.64 59.52,71.72 59.24,71.44 58.91,71.44 58.68,71.68 58.29,71.68 58.05,71.44 52.44,71.44 52.22,71.66 52.22,72.14 51.8,72.56 51.8,73.72 51.32,74.21 MEM2.B7 ; 62.46,80.4 64.02,80.4 64.84,81.21 66.55,81.21 ; 62.46,80.4 v1(62.46,80.04)
QSAN_6: length 29.6
  TOP w0.102: U13.C5 69.88,79.01 69.65,79.01 69.42,79.1 69.2,79.1 68.07,77.96 67.91,77.96 67.68,77.73 67.23,77.73 v4(66.83,78.14)
  TOP w0.127: MEM2.G3 53.94,77.93 53.85,77.93 v4(53.85,77.93)
  L3 w0.152: v4(66.83,78.14) 66.55,78.42 65.02,78.42 64.02,77.42 64.02,76 63.71,75.69 63.22,75.69 62.91,76 62.91,76.76 62.79,76.89 62.53,76.89 62.41,76.76 62.41,76 62.1,75.69 61.62,75.69 61.31,76 61.31,76.76 61.19,76.89 60.93,76.89 60.81,76.76 60.81,76 60.5,75.69 59.97,75.69 59.66,76 59.66,76.76 59.54,76.89 59.18,76.89 59.05,76.76 59.05,75.82 58.75,75.51 58.14,75.51 57.84,75.82 57.84,77.82 57.71,77.95 57,77.95 56.87,77.82 56.87,77.11 56.57,76.81 54.41,76.81 54.03,77.2 54.03,77.75 v4(53.85,77.93)
QSAN_7: length 32.5
  TOP w0.102: U13.H4 73.2,78.34 73.09,78.23 73.09,77.81 73.04,77.69 73.02,77.66 72.98,77.62 72.98,77.53 73.08,77.33 73.08,76.9 73,76.81 72.94,76.75 72.77,76.59 72.77,76.38 72.67,76.27 72.67,76.17 72.81,76.03 v4(73.05,76.03)
  BOTTOM w0.127: 64.66,74.75 63.49,74.75 63.07,74.33 63.07,73.03 62.94,72.91 62.42,72.91 62.3,73.03 62.3,73.88 62.02,74.15 61.45,74.15 61.18,73.88 61.18,72.93 61.05,72.81 60.67,72.81 60.54,72.93 60.54,73.92 60.27,74.19 59.7,74.19 59.43,73.92 59.43,72.91 58.89,72.37 57.61,72.37 57.16,72.83 54.32,72.83 53.48,73.67 53.48,74.48 53.81,74.81 54.22,74.81 54.36,74.67 MEM4.B7 ; 64.66,74.75 70.47,74.75 71.43,75.71 72.04,75.71 72.54,76.21 72.87,76.21 v4(73.05,76.03) ; 64.66,74.75 v2(64.66,75.09)
QSAP_0: length 37.8
  TOP w0.127: v4(73.75,96.73) 73.35,97.13 U13.H28
  L3 w0.152: v4(73.75,96.73) 73.56,96.92 73.56,97.57 73.85,97.86 73.85,98.29 73.41,98.74 72.97,98.74 72.75,98.51 72.24,98.51 72.03,98.72 72.03,101.67 71.2,102.5 69.95,102.5 69.6,102.85 69.6,103.13 69.88,103.41 69.88,103.91 68.58,105.21 65.86,105.21 65.18,104.52 65.18,103.64 64.92,103.39 64.4,103.39 64.25,103.54 64.25,103.67 63.92,104 63.36,104 63.03,103.67 63.03,103.54 62.88,103.39 62.57,103.39 62.42,103.54 62.42,103.67 62.09,104 61.53,104 61.2,103.67 61.2,103.54 61.05,103.39 60.57,103.39 60.06,102.88 59.7,102.88 59.58,103.01 59.58,104.89 59.27,105.19 58.55,105.19 58.24,104.89 58.24,102.33 58.13,102.22 58.13,102.19 57.9,101.95 57.22,101.95 57.13,102.04 57.13,102.04 57.01,102.16 54.38,102.16 54.04,101.83 v4(53.82,101.83)
  BOTTOM w0.127: v4(53.82,101.83) 54.21,101.77 MEM3.F3 ; v2(74.46,97.52) 74.45,97.52 73.75,96.82 v4(73.75,96.73)
QSAP_1: length 35.4
  TOP w0.102: 67.65,96.59 68.1,96.14 69.08,96.14 69.16,96.05 69.22,96.03 69.27,96.01 69.36,96.01 69.42,96.01 69.49,96.04 69.58,96.1 69.82,96.34 U13.C27
  TOP w0.127: v4(66.7,97.27) 67.18,97.27 67.65,96.8 67.65,96.59
  BOTTOM w0.127: 60.8,100.89 60.6,101.09 60.6,103.98 57.47,107.12 55.03,107.12 54.94,107.02 54.94,106.65 54.59,106.3 54.09,106.3 53.74,106.65 53.74,107.03 53.63,107.14 52.7,107.14 52.58,107.02 52.58,106.58 52.75,106.41 53.04,106.41 53.31,106.13 53.31,105.66 53.01,105.36 52.35,105.36 51.95,104.96 51.95,104.49 51.59,104.13 51.27,104.13 MEM3.C7 ; 60.8,100.89 61.11,100.58 61.11,97.11 61.49,96.73 62.16,96.73 62.44,97.01 62.44,97.42 62.56,97.55 62.82,97.55 62.95,97.42 62.95,97.01 63.22,96.73 63.69,96.73 63.96,97.01 63.96,97.44 64.09,97.57 64.34,97.57 64.47,97.44 64.47,97.01 64.74,96.73 65.58,96.73 66.24,97.39 66.58,97.39 v4(66.7,97.27) ; 60.8,100.89 v2(60.6,100.7)
QSAP_2: length 36.1
  TOP w0.102: 65.94,93.43 65.95,93.43 65.99,93.39 66.03,93.39 66.06,93.35 68.07,93.35 68.27,93.15 69.16,93.15 69.17,93.14 U13.A23
  TOP w0.127: MEM1.C7 54.36,104.18 53.15,105.39 53.15,105.95 53.54,106.35 53.65,106.35 55.12,107.81 58.7,107.81 59.17,107.34 59.17,106.95 58.9,106.67 58.9,106.5 59.08,106.31 59.26,106.31 59.53,106.59 59.92,106.59 60.25,106.26 60.25,105.87 59.98,105.6 59.98,105.42 60.16,105.24 60.34,105.24 60.61,105.51 61,105.51 61.48,105.04 61.48,104.65 61.21,104.39 61.21,104.21 61.39,104.02 61.57,104.02 61.84,104.29 62.23,104.29 63.47,103.04 63.47,102.08 63.2,101.81 62.64,101.81 62.51,101.68 62.51,101.42 62.64,101.3 63.15,101.3 63.42,101.02 63.42,100.56 63.15,100.28 62.64,100.28 62.51,100.15 62.51,96.33 63.49,95.35 ; v1(63.74,95.6) 63.49,95.35 ; 63.49,95.35 65.41,93.43 65.94,93.43
QSAP_3: length 35.3
  TOP w0.102: U13.E19 70.62,89.94 70.15,90.41 69.66,90.41 69.58,90.44 69.55,90.47 69.13,90.47 69.04,90.38 68.16,90.38 68.16,90.38 67.01,90.38 66.69,90.71 66.69,91.01 66.49,91.21
  TOP w0.127: 66.49,91.21 66.44,91.26 66.07,91.26 65.82,91.01 65.82,91 v4(65.66,90.84) ; MEM1.F3 51.34,101.62 51.52,101.8 51.71,101.8 52.38,102.46 53.08,102.46 v4(53.13,102.51)
  L4 w0.152: v4(65.66,90.84) 65.79,90.97 65.79,94.09 63.98,95.89 63.98,96.68 61.95,98.72 61.95,99.59 62.15,99.8 62.15,100.03 61.96,100.23 61.72,100.23 61.16,99.66 60.67,99.66 60.29,100.04 60.29,100.53 60.93,101.17 60.93,101.38 60.72,101.6 60.5,101.6 59.74,100.83 59.25,100.83 58.87,101.21 58.87,101.69 59.64,102.46 59.64,102.68 59.42,102.89 59.21,102.89 58.93,102.61 58.46,102.61 58.04,103.03 56.86,103.03 56.43,103.46 54.85,103.46 54.25,102.87 53.62,102.87 53.58,102.82 53.44,102.82 v4(53.13,102.51)
QSAP_4: length 34.9
  TOP w0.102: U13.E15 70.31,86.43 70.02,86.35 69.73,86.31 69.51,86.21 68.32,86.21 v4(67.86,85.75)
  L4 w0.152: v4(67.86,85.75) 67.46,85.34 66.83,85.34 66.75,85.42 64.03,85.42 63.21,84.6 63.21,77.95 62.69,77.43 62.22,77.43 61.94,77.72 61.71,77.72 61.51,77.52 61.51,77.29 61.79,77 61.79,76.53 61.4,76.14 60.93,76.14 60.69,76.38 60.46,76.38 60.26,76.18 60.26,75.95 60.5,75.71 60.5,75.24 59.45,74.19 59.24,74.19 58.83,73.78 56.54,73.78 56.19,74.13 56.19,74.61 55.74,75.07 55.27,75.07 55.11,74.91 55.11,74.72 54.84,74.45 54.24,74.45 53.95,74.73 53.95,76.61 53.68,76.89 52.9,76.89 52.37,77.41 v4(51.74,77.41)
  BOTTOM w0.127: MEM4.F3 51.6,77.56 v4(51.74,77.41)
QSAP_5: length 36.9
  TOP w0.102: U13.D10 70.22,82.74 69.92,82.44 69.79,82.41 69.7,82.41 69.49,82.47 68.83,82.47 67.94,82.47 67.68,82.21 67.31,82.21 66.57,81.47 66.55,81.47
  TOP w0.127: v1(60.91,77.38) 61.32,77.38 ; 61.32,77.38 61.32,80.38 61.59,80.65 63.92,80.65 64.73,81.47 66.55,81.47 ; 61.32,77.38 61.32,76.87 61.21,76.76 60.72,76.76 60.43,76.47 60.43,75.85 60.67,75.62 61.23,75.62 61.31,75.53 61.31,75.06 61.25,75.01 60.53,75.01 60.26,74.74 60.26,74.11 60.51,73.86 61.11,73.86 61.24,73.73 61.24,72.06 61.11,71.93 60.52,71.93 60.41,72.04 60.41,72.75 60.1,73.06 59.58,73.06 59.27,72.75 59.27,71.83 59.14,71.7 59.02,71.7 58.78,71.93 58.18,71.93 57.95,71.7 52.54,71.7 52.48,71.76 52.48,72.24 52.05,72.67 52.05,73.83 51.56,74.32 51.56,74.76 MEM2.C7
QSAP_6: length 29.7
  TOP w0.102: U13.D6 70.55,79.36 70.4,79.21 69.69,79.21 69.46,79.3 69.12,79.3 67.98,78.17 67.46,78.17 v4(67.44,78.14)
  TOP w0.127: MEM2.F3 54.36,77.56 v4(54.76,77.96)
  L3 w0.152: v4(54.76,77.96) 54.53,77.96 54.28,77.71 54.28,77.3 54.47,77.11 56.44,77.11 56.57,77.24 56.57,77.95 56.87,78.26 57.84,78.26 58.14,77.95 58.14,75.95 58.27,75.82 58.62,75.82 58.75,75.95 58.75,76.88 59.05,77.19 59.66,77.19 59.97,76.88 59.97,76.12 60.09,76 60.37,76 60.5,76.12 60.5,76.88 60.81,77.19 61.31,77.19 61.62,76.88 61.62,76.12 61.75,76 61.97,76 62.1,76.12 62.1,76.88 62.41,77.19 62.91,77.19 63.22,76.88 63.22,76.12 63.35,76 63.58,76 63.71,76.12 63.71,77.54 64.89,78.72 66.85,78.72 67.26,78.32 v4(67.44,78.14)
QSAP_7: length 32.9
  TOP w0.102: U13.G5 72.88,78.41 72.88,77.85 72.86,77.79 72.83,77.75 72.78,77.69 72.78,77.48 72.88,77.28 72.88,76.98 72.8,76.9 72.57,76.67 72.57,76.46 72.47,76.36 72.47,76.09 72.6,75.96 v4(72.6,75.56)
  BOTTOM w0.127: MEM4.C7 54.27,75.06 53.7,75.06 53.22,74.58 53.22,73.56 54.21,72.57 57.05,72.57 57.51,72.12 58.99,72.12 59.68,72.81 59.68,73.81 59.81,73.94 60.16,73.94 60.29,73.81 60.29,72.83 60.57,72.55 61.16,72.55 61.43,72.83 61.43,73.77 61.56,73.9 61.92,73.9 62.04,73.77 62.04,72.93 62.32,72.65 63.05,72.65 63.32,72.93 63.32,73.63 ; v2(63.63,73.63) 63.32,73.63 ; 63.32,73.63 63.32,74.22 63.59,74.49 70.58,74.49 71.53,75.45 72.14,75.45 72.25,75.56 v4(72.6,75.56)
RASA0#: length 41.2
  TOP w0.127: v4(53.32,98.9) 53.63,98.59 53.63,98.44 53.5,98.31 52.91,98.31 52.62,98.59 52.51,98.59 52.19,98.91 51.92,98.91 51.61,99.22 MEM1.J3 ; U13.G22 72.86,92.14 73.21,91.8 73.57,91.8 v4(73.74,91.63)
  L3 w0.165: v4(53.32,98.9) 53.32,98.57 54.58,97.31 55.17,97.31 55.3,97.18 55.3,96.66 55.42,96.53 55.93,96.53 56.06,96.66 56.06,97.18 56.18,97.31 57.71,97.31 57.84,97.18 57.84,96.35 57.71,96.22 57.3,96.22 57.18,96.1 57.18,95.61 57.3,95.49 58.36,95.49 58.48,95.61 58.48,96.5 58.61,96.63 58.88,96.63 59.12,96.39 59.39,96.39 59.55,96.22 59.55,95.68 59.72,95.51 60.2,95.51 60.36,95.68 60.36,96.22 60.53,96.39 65.7,96.39 66.57,95.51 66.82,95.51 66.82,95.51 67.33,95.51 67.82,96 69.04,96 69.16,95.87 69.16,95.59 69.29,95.46 69.85,95.46 69.98,95.59 69.98,95.87 70.1,96 70.5,96 70.63,95.87 70.63,95.13 70.89,94.87 71.25,94.87 71.25,94.87 72.48,94.87 74.07,93.28 74.07,91.96 v4(73.74,91.63)
  BOTTOM w0.127: MEM3.J3 54.34,99.19 54.34,98.88 54.21,98.75 53.96,98.75 53.83,98.88 53.83,99.22 53.66,99.4 53.66,99.77 53.53,99.9 53.32,99.9 53.11,99.69 53.11,99.11 v4(53.32,98.9)
RASA1#: length 42.2
  TOP w0.127: U13.G17 73.03,89.01 v4(73.03,89.04) ; MEM2.J3 54.62,79.96 54.72,80.06 54.72,80.31 54.62,80.41 53.37,80.41 53.22,80.27 v4(53.22,80)
  L3 w0.165: v4(53.22,80) 53.42,80 54.13,80.7 57.07,80.7 57.88,81.52 68.3,81.52 68.46,81.68 68.82,81.68 68.99,81.52 70.09,80.41 73.63,80.41 74.56,81.34 74.86,81.34 75.69,82.17 75.69,82.33 76.12,82.76 76.12,83.5 75.99,83.63 75.99,84.48 76.12,84.61 76.5,84.61 76.63,84.74 76.63,87.28 76.5,87.41 76.16,87.41 76,87.58 76,87.91 76.16,88.07 76.5,88.07 76.63,88.2 76.63,88.76 76.5,88.88 75.89,88.88 75.52,88.52 75.16,88.52 74.96,88.72 74.28,88.72 74.12,88.89 73.2,88.89 73.05,89.04 v4(73.03,89.04)
  BOTTOM w0.127: MEM4.J3 51.29,79.96 51.59,79.66 52.17,79.66 52.52,80.01 53.21,80.01 v4(53.22,80)
RED_CRT: length 28.6
  TOP w0.102: L22.2 37.83,19.59 C350.1 38.87,20.37 v3(39.01,20.51)
  L3 w0.127: v3(39.01,20.51) 39.01,21.53 40.93,23.44 41.55,23.44 43.11,21.88 44.98,21.88 45.95,20.91 47.9,20.91 50.58,18.23 53.84,18.23 54.38,17.69 54.9,17.17 55.29,17.17 55.56,16.89 55.56,13.21 VGA1.1
  BOTTOM w0.102: v3(39.01,20.51) 39.61,21.1 U43.6
REMOTE2+: length 246.3
  TOP w0.127: 56.13,57.64 56.13,58.32 54.16,60.29 51.72,60.29 50.17,61.85 48.14,61.85 46.4,63.58 46.4,65.94 v3(46.74,66.28) ; 56.13,57.64 v1(56.52,57.64) ; 56.13,57.64 56.13,56.59 C253.1 56.14,56.01 56.14,55.11 55.59,54.56 55.59,52.97 55.67,52.9 U24.43 ; v3(49.99,158.76) 49.68,159.07 49.68,159.45 46,163.13 46,167.57 Q26.E 46.86,170.81 45.85,171.81 C60.2 ; v3(126.8,126.24) 127.1,125.94 133.12,125.94 142.37,135.19 142.37,135.48 R153.1
  L3 w0.127: v3(49.99,158.76) 49.68,158.46 49.68,157.9 69.95,137.63 82.68,137.63 88.49,131.81 110.54,131.81 116.13,126.22 125.45,126.22 125.73,125.94 126.5,125.94 v3(126.8,126.24)
  L4 w0.127: v3(46.74,66.28) 46.48,66.53 46.48,67.88 43.79,70.57 43.79,76.05 43.79,77.37 43.79,77.95 43.79,104.54 48.92,109.67 48.92,109.89 49.68,110.65 49.68,144.99 50.04,145.34 50.04,149.5 49.68,149.86 49.68,158.46 v3(49.99,158.76)
REMOTE2-: length 247.2
  TOP w0.127: C60.1 45.01,171.35 45.01,171.19 Q26.C 45.87,169.41 Q26.B 45.74,167.57 45.74,163.02 49.43,159.34 49.43,159.07 v3(49.12,158.76) ; 55.27,58.83 54.06,60.04 53.56,60.04 51.62,60.04 50.06,61.59 48.03,61.59 46.15,63.47 46.15,66.11 v3(45.97,66.28) ; 55.27,58.83 55.88,58.22 55.88,56.64 C253.2 55.89,55.94 55.89,55.22 55.34,54.67 55.34,52.97 55.27,52.9 U24.44 ; 55.27,58.83 v1(55.04,58.61) ; R154.1 142.62,135.48 142.62,135.08 133.23,125.69 127.1,125.69 v3(126.8,125.39)
  L3 w0.127: v3(49.12,158.76) 49.43,158.46 49.43,157.79 69.85,137.37 82.57,137.37 88.39,131.56 110.44,131.56 116.02,125.97 125.35,125.97 125.63,125.69 126.5,125.69 v3(126.8,125.39)
  L4 w0.127: v3(49.12,158.76) 49.43,158.46 49.43,149.75 49.78,149.4 49.78,145.45 49.43,145.09 49.43,110.76 48.67,110 48.67,109.78 43.54,104.65 43.54,77.84 43.54,77.26 43.54,77.26 43.54,76.16 43.54,70.47 46.23,67.77 46.23,66.44 46.06,66.28 v3(45.97,66.28)
RING2: length 25
  TOP w0.203: U16.31 179.52,84.51 180.21,83.83 v3(180.59,83.83) C204.1
  TOP w0.508: R336.2 176.59,80.54 176.45,80.4 v3(176.45,80.37)
  L4 w1.016: v3(189.26,86.55) 194.26,86.55 194.94,87.23 200.28,87.23 UHS1.3
  BOTTOM w0.508: v3(180.59,83.83) 180.22,83.83 177.86,81.47 177.55,81.47 v3(176.45,80.37)
  vias: v2(183.67,84.41)
ROM_CS#: length 5.4
  TOP w0.102: R1167.2 90.04,59.24 v1(90.45,58.84) 90.83,59.22 90.83,60.41 91.05,60.63 U49.1 91.57,60.54 R1168.2
ROM_SI_D3: length 4.3
  TOP w0.102: R1171.1 95.29,69.35 95.29,68.49 94.82,68.02 v1(94.82,67.67) 94.82,67.41 95.29,66.94 U49.5
ROM_SLK_D4: length 4.3
  TOP w0.102: R1170.1 94.11,69.39 94.11,68.46 93.55,67.9 v1(93.55,67.65) 93.55,67.19 94.02,66.72 U49.6
ROM_SO_C4: length 3.2
  TOP w0.102: R1169.2 93.56,58.98 v1(93.7,59.12) 93.19,59.62 92.91,59.62 92.75,59.79 U49.2
RSMRST*_R: length 2.7
  TOP w0.102: v1(48.16,56.47) Q60.G 47.02,57.83 R448.2
RSMRST_N: length 268.8
  TOP w0.102: v3(151.55,96) 151.17,95.61 R275.1 ; R448.1 45.96,59.01 R445.2 45.59,59.04 45.09,58.53 45.09,58.02 43.52,56.46 R453.1 43.63,56.34 44.86,55.12 44.86,53.91 46.23,52.54 46.23,51.85 47.68,50.4 v3(47.75,50.4)
  L3 w0.127: v3(47.75,50.4) 47.21,50.4 45.83,49.02 45.83,41.4 v3(47.12,40.12) 46.7,39.7 46.7,34.74 49.34,32.1 49.34,29.56 55.14,23.76 56.56,23.76 57.47,22.86 57.47,18.95 57.59,18.82 57.59,18.43 57.47,18.31 57.47,16.79 57.94,16.32 63.09,16.32 66.67,12.73 66.67,9.28 67.42,8.53 70.59,8.53 73.5,5.62 81.83,5.62 86.2,10 90.4,10 91.88,8.52 92.6,8.52 94.44,10.36 105.57,10.36 106.21,11 119.31,11 119.72,11.4 127.62,11.4 129.18,12.96 134.88,12.96 140.31,18.4 151.94,18.4 152.53,18.98 v3(152.53,20.18)
  L4 w0.127: v3(47.12,40.12) 47.36,40.36 50.94,40.36 51.01,40.43 51.4,40.43 51.48,40.36 55.15,40.36 v3(55.37,40.13) ; v3(152.53,20.18) 156.21,23.86 156.21,26.3 156.46,26.55 156.46,27.16 156.97,27.67 156.97,35.42 157.48,35.92 157.48,42.15 158,42.67 158.37,43.04 158.37,46.37 162,50.01 162,53.4 164.12,55.52 164.49,55.89 164.49,55.89 164.49,61.62 164.12,61.99 163.94,61.99 163.17,62.76 163.17,65.27 162.95,65.49 162.95,65.96 163.44,66.45 163.44,71.21 160.53,74.12 160.53,88.2 156.27,92.46 151.37,92.46 150.96,92.86 150.96,95.41 v3(151.55,96)
  BOTTOM w0.102: R1051.1 59.63,37.82 v2(59.46,37.98) 59.2,38.24 58.71,38.24 58.28,38.67 57.43,38.67 57.07,39.02 56.48,39.02 v3(55.37,40.13)
RSMRST_SIO_N_1: length 11.1
  TOP w0.102: U24.58 49.67,50.15 49.46,49.95 47.56,49.95 45.85,51.66 45.85,52.42 44.22,54.04 v1(44.22,54.44) 44.22,54.75 R453.2
RT8243_3D3VFB: length 7
  TOP w0.254: v3(100.76,42.27) 101.03,42.01 PC46.2 PR82.2
  BOTTOM w0.254: v3(100.76,42.27) 99.24,42.27 v2(98.05,43.47) 97,44.51 PG5.1
RT8243_5VFB: length 13.9
  TOP w0.203: PU6.20 97.21,36.63 98.21,35.63 98.21,34.34 PC50.1
  TOP w0.254: PG2.2 101.55,27.47 v1(102.03,27.95) 99.69,30.29 99.69,32.18 PC51.2 99.48,32.39 PR89.2 99.43,34.2 PC50.1
RT8243_BOOT1: length 4.2
  TOP w0.203: PU6.19 96.34,35.95 96.49,35.8 96.92,35.8 97.28,35.43 v1(97.28,35.21)
  TOP w0.635: v1(97.28,35.21) 97.28,34.68 96.82,34.22 PR90.2
RT8243_BOOT2: length 3.4
  TOP w0.203: PU6.7 96.34,40.26 96.84,40.76
  TOP w0.635: 96.84,40.76 96.93,40.85 v1(96.93,41.56) 97.16,41.79 PR80.1
RT8243_BOOT2_1: length 2.9
  TOP w0.635: PC44.2 95.5,45.09 v3(95.48,45.12) 95.63,45.27 96.65,45.27 PR80.2
RT8243_ENLDO: length 3.1
  TOP w0.203: PU6.12 93.5,38.59 v3(93.34,38.74)
  BOTTOM w0.254: PR117.2 v2(92.46,38.45) 93.05,38.45 v3(93.34,38.74)
RT8243_ENTRIP1: length 3.4
  TOP w0.203: PU6.2 98.09,37.79 98.3,37.58
  TOP w0.254: 98.3,37.58 98.54,37.34 98.54,37.05 v1(99,36.59) 99.29,36.31 PR87.2
RT8243_ENTRIP1_1: length 4.7
  TOP w0.254: 103.76,37.12 103.99,37.35 Q73.G ; 103.76,37.12 v3(103.73,37.12) ; 103.76,37.12 103.49,36.85 C291.1 102.52,35.85 R550.2
  BOTTOM w0.254: v3(103.73,37.12) 103.85,37 v2(104.73,37)
