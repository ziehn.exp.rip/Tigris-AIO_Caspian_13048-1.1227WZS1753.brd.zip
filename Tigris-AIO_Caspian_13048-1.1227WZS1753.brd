# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND: length 2631.7
  TOP w0.127: v4(56.67,83.73) 56.31,83.36 56.31,82.96 55.96,82.62 MEM2.M1 ; U29.AP4 142.7,65.92 142.68,65.9 142.33,65.9 v4(142.09,65.66) ; v3(71.46,153.15) CPU1.L6 ; CPU1.AY3 v7(102.67,149.95)
  TOP w0.165: v3(56.64,53.32) 56.77,53.2 56.77,52.96 56.87,52.87 U24.40 ; v3(59,53.32) 58.87,53.19 U24.35
  TOP w0.178: U29.U1 134.25,64.21 134.25,63.72 134.11,63.59 134.11,62.47 v4(133.99,62.34)
  TOP w0.203: v4(122.94,74.95) 125.21,74.95 U29.A21 ; v4(68.05,90.87) 68.17,90.74 U13.B20 ; U29.T17 133.9,72.64 135.65,72.64 U29.AA17 ; v3(39.34,135.9) 39.6,136.15 U9.22 ; U24.59 49.27,50.52 v3(49.15,50.4) ; U9.27 41.6,136.37 v3(42.11,135.85) ; U13.B26 69.74,95.53 68.69,95.53 v4(68.68,95.52) ; v3(130.47,86.68) 130.5,86.64 U29.L41 ; v4(146.56,73.14) 145.62,73.14 U29.AV17 ; v3(62.74,37.45) 62.51,37.45 61.98,37.98 U24.1 ; U24.3 v3(59.92,38.78) ; U24.86 44.9,41.98 v3(44.4,42.48) ; U24.117 55.27,37.43 54.97,37.73 v3(54.69,37.73) ; v4(154.69,176.89) 155.17,176.41 155.88,176.41 156.07,176.6 DIMM2.38 ; U24.88 46.95,41.18 47.03,41.26 v3(47.04,41.26) 47.03,41.25 47.03,40.89 46.52,40.38 U24.90 ; v4(155.14,172.78) 155.14,173.01 155.73,173.6 DIMM2.48 ; v3(47.12,49.64) 46.78,49.98 U24.66 ; U29.B3 126.12,65.57 126.64,66.1 v4(126.72,66.1) ; v4(68.64,81.24) 68.75,81.14 U13.B8 ; U24.82 44.67,43.58 v3(44.42,43.33) 44.44,43.33 44.58,43.18 U24.83 ; U13.B12 v4(68.8,84.34) ; U29.R1 132.73,63.86 132.73,63.37 v4(132.59,63.23) ; v4(68.32,92.34) U13.B22 ; v4(68.49,85.76) 68.56,85.76 68.74,85.94 U13.B14 ; U24.18 62.28,44.78 62.64,44.42 v3(62.64,44.18) 62.2,44.18 62,44.38 U24.17
  TOP w0.229: U13.B6 69.74,79.54 69.71,79.57 68.87,79.57 68.67,79.37 v4(68.61,79.37) ; U13.H2 73.42,77.47 v4(73.42,76.63)
  TOP w0.254: v4(170.89,139.23) 171.32,138.8 DIMM1.156 ; v4(167.84,140.93) 167.84,140.98 166.72,142.1 DIMM1.145 ; MEM1.G8 55.25,100.74 55.88,100.74 MEM1.G9 55.96,100.94 56.11,101.08 56.11,101.48 MEM1.F9 ; U29.AV33 144.88,81.2 v4(144.5,81.2) 144.03,81.2 U29.AT33 ; U29.B30 124.48,79.68 v4(124.16,79.99) ; v4(71.52,79.06) 71.83,78.75 71.92,78.75 72.16,78.51 72.16,78.12 71.75,77.71 U13.F2 ; DIMM1.13 165.49,184.1 v4(165.68,183.91) ; v4(68.79,77.63) 69.1,77.94 U13.A3 ; U29.AM24 141.83,76.75 v4(141.49,77.09) 141.12,76.72 U29.AK24 ; v4(166.91,173.02) 166.41,173.53 165.6,173.53 165.37,173.3 DIMM1.49 ; v4(70.18,76.54) 70.15,76.57 U13.C1 ; U29.AV12 145.48,70.37 146.24,70.37 146.28,70.32 v4(146.45,70.32) ; U29.Y1 135.63,63.41 v4(135.58,63.36) ; v4(151.51,172.78) 151.51,172.96 151.17,173.3 DIMM2.49 ; U29.H38 129.43,83.78 129.94,83.78 U29.J37 129.99,83.24 v4(130.04,83.19) 130.38,83.53 U29.L37 ; U13.A30 69.13,97.94 68.98,98.09 68.81,98.09 68.68,97.96 v4(68.47,97.96) ; v4(151.51,176.29) 151.51,176.62 151.23,176.9 DIMM2.37 ; U13.B16 69.73,87.52 68.84,87.52 68.84,87.53 v4(68.73,87.53) ; U13.K2 74.95,76.83 75.03,76.75 75.03,76.51 75.19,76.34 v4(75.19,76.28) ; v3(67.81,160.46) CPU1.G15 ; U13.B18 69.56,89.33 v4(68.84,89.33) ; U29.AG30 139.55,79.69 140.16,79.08 140.18,79.08 U29.AJ28 ; v4(138.78,83.32) 138.92,83.32 139.47,83.87 U29.AG38 139.54,83.87 139.96,83.45 140.72,83.45 U29.AK37 ; U29.AL37 141.48,83.87 U29.AM38 ; DIMM2.136 156.3,144.8 156.08,145.02 154.71,145.02 v4(154.11,144.42) ; v4(138.22,86.81) 138.18,86.77 138.18,85.9 U29.AE41 ; v4(155.85,147.86) 155.85,147.74 156.39,147.2 DIMM2.128 ; v4(168.44,173.02) 167.55,172.14 165.91,172.14 165.27,171.5 DIMM1.55 ; U29.AR35 143.97,82.92 U29.AT36 143.76,83.17 U29.AR37 ; DIMM1.46 171.05,174.2 170.77,174.48 v4(170.77,174.8) ; CPU1.T37 v3(76.04,183.69) ; v4(68.66,82.88) 69.61,82.88 U13.B10 ; U13.B24 69.7,93.94 69.59,94.05 v4(68.66,94.05) ; v4(136.83,84.44) 136.97,84.31 U29.AC38 ; v4(151.47,140.88) 150.89,140.3 DIMM2.151 ; v4(170.89,140.83) 171.12,140.6 DIMM1.150 ; DIMM2.134 157.28,145.52 156.39,145.52 156.36,145.55 153.72,145.55 v4(152.59,144.42) ; DIMM2.14 155.89,183.8 155.69,184 155.23,184 v4(154.72,183.49) ; DIMM1.9 167.13,185.3 168.69,186.87 v4(168.69,187.01) ; v3(76.95,182.78) CPU1.U36 ; U29.AL5 141.25,66.73 v4(141.15,66.83) ; U29.Y41 135.66,85.91 135.66,86.72 135.73,86.8 v4(135.73,86.85) ; v4(150.83,178.7) 150.82,178.7 DIMM2.31 ; CPU1.T38 v3(76.95,184.61) ; DIMM1.11 167.44,184.7 v4(168.26,185.52) ; v3(76.04,184.61) CPU1.R38 ; DIMM1.172 170.92,134
  TOP w0.279: U29.AK37 140.81,83.53 141.11,83.83 U29.AL37
  TOP w0.305: v4(76.43,84) 76.43,84.22 U13.M12 ; DIMM1.189 167.53,128.9 168.07,129.45 168.07,130.06 ; DIMM1.187 167.51,129.5 168.07,130.06 ; v4(132.48,83.33) 132.45,83.33 U29.N38 ; DIMM1.38 v4(170.92,176.6) ; v3(68.72,153.15) CPU1.J7 ; CPU1.P40 74.66,186.73 v3(74.68,186.74) ; U29.AM4 141.9,65.86 v4(142.09,65.66) ; v4(93.34,182.79) 93.8,182.32 CPU1.AR36 ; MEM2.M9 49.08,82.36 v4(48.97,82.47) ; U29.M16 132.03,73 v4(132.03,73.14) 131.85,73.32 131.74,73.32 U29.M18 ; CPU1.AH1 86.52,148.12 v4(86.09,148.55) 86.55,149.01 CPU1.AH2 ; v4(53.93,74) 54.3,74.36 MEM2.B3 ; v4(132.03,76.03) 131.54,75.54 U29.M22 ; v4(171.65,188.32) 171.65,188.15 DIMM1.2 173.8,187.4 173.95,187.55 v4(173.95,188.54) ; v4(55.56,77.96) MEM2.G1 ; v4(48.63,102.38) 48.68,102.33 49.4,102.33 49.49,102.42 MEM1.E1 MEM1.E2 ; v4(151.67,186.74) 151.14,187.27 150.69,187.27 150.52,187.1 DIMM2.3 ; U29.E35 127.34,82.43 U29.D34 ; U29.E35 127.93,82.73 v4(128.14,82.94) ; U29.E35 127.16,83.22 U29.D37 ; v4(155.83,129.92) 155.84,129.92 156.32,130.4 DIMM2.184 ; MEM2.E1 55.96,76.75 v4(55.56,76.35) ; v4(170.55,185.52) 170.63,185.6 DIMM1.8 ; U29.AM14 141.83,71.07 141.51,70.75 v4(141.51,70.74) 141.51,70.7 141.46,70.66 U29.AL11 ; v4(139.04,71.85) 138.66,72.23 U29.AF16 ; v4(56.67,83.73) 56.44,83.96 MEM2.P1 ; U29.H16 129.75,72.11 v4(129.75,71.78) 129.41,71.44 U29.H14 ; DIMM2.155 150.45,139.1 v4(150.88,138.67) 150.88,139.46 150.65,139.7 DIMM2.153 ; U14.2 122.45,103.06 123,103.06 124.42,101.63 125.93,101.63 125.96,101.66 v3(126.06,101.66) ; v4(54.77,79.56) 55.16,79.96 MEM2.J2 ; U29.W5 134.3,66.26 U29.U4 134.27,65.78 v4(134.36,65.68) 134.48,65.57 U29.W3 ; v3(130.68,219.54) 130.51,219.72 130.51,220.58 130.12,220.97 LVDS1.24 ; DIMM2.133 150.22,145.7 151.21,146.68 v4(151.29,146.68) ; DIMM1.179 165.02,131.9 165.56,131.35 166.01,131.35 v4(166.52,131.86) ; DIMM1.3 165.69,187.1 v4(165.79,187) ; DIMM2.55 153.05,171.5 153.67,172.12 v4(153.67,172.78) ; v4(128.14,82.94) 128.27,82.81 U29.F35 128.27,82.38 v4(128.85,81.8) ; v4(128.14,82.94) 128.05,83.02 U29.F37 U29.F38 ; U29.R8 132.73,68.34 v4(132.31,67.92) 131.89,68.34 U29.N8 ; U29.R8 U29.R10 ; U29.R8 133.29,68.34 133.31,68.36 133.77,68.36 133.79,68.34 U29.U8 ; v3(80.61,154.06) CPU1.AA8 ; DIMM1.167 165.19,135.5 165.68,135.01 166.27,135.01 v4(166.75,135.49) ; DIMM2.20 158.14,182 158.17,181.97 v4(159.13,181.97) ; v4(173.81,127.02) 173.59,126.8 DIMM1.196 ; DIMM2.65 152.07,168.5 v4(153.3,167.27) 153.3,167.24 152.77,166.7 DIMM2.71 ; CPU1.AT2 93.87,149.04 v4(94.32,149.49) 94.77,149.03 CPU1.AU2 ; CPU1.AT38 94.73,184.15 v4(94.32,184.56) 94.32,184.69 94.7,185.07 CPU1.AT39 ; v4(166.61,167.92) 166.03,168.5 DIMM1.65 ; CPU1.J3 v3(68.72,149.49) ; v4(90.62,152.24) 91.07,152.69 CPU1.AN6 ; v4(90.62,152.24) 91.07,151.78 CPU1.AN5 ; v4(90.62,152.24) 90.21,151.83 CPU1.AM5 ; DIMM1.28 171.49,179.6 v4(170.89,180.2) 171.04,180.2 171.05,180.2 DIMM1.26 ; NGFF1.57 v4(116.35,232.8) ; DIMM1.31 165.38,178.7 165.52,178.84 166.08,178.84 v4(166.54,178.38) ; LVDS1.17 137.12,220.11 v3(137.08,220.07) ; v4(168.68,143.21) 168.68,143.2 169.58,142.29 171.42,142.29 171.52,142.4 DIMM1.144 ; MEM1.G1 48.92,100.82 48.91,100.84 v4(48.57,100.84) ; U29.AV40 145.29,85.68 U29.AV41 145.96,86.35 v4(145.98,86.35) ; CPU1.N3 v3(73.29,150.41) CPU1.N4 ; U29.AF17 139.12,73.03 v4(139.15,73.01) 139.71,72.45 U29.AH16 ; U5.6 22.47,166.99 U5.9 ; v3(76.04,183.69) CPU1.R37 ; MEM2.D8 50.38,75.96 v4(50.78,76.36) 50.39,76.76 MEM2.E8 ; U23.18 U22.18 147.26,40.31 146.94,39.99 v3(146.61,39.99) ; DIMM2.25 147.8,180.5 v4(146.23,178.93) ; 166.67,139.7 166.67,139.72 167.67,140.71 167.67,140.75 v4(167.84,140.93) ; 166.67,139.7 166.67,139.4 166.37,139.1 DIMM1.155 ; 166.67,139.7 DIMM1.153 ; U29.H20 129.41,74.44 129.72,74.13 v4(129.72,74.11) ; v3(72.83,186.69) CPU1.M40 ; v4(153.2,186.74) 151.76,185.3 DIMM2.9 ; v4(93.46,185.53) 93.87,185.12 CPU1.AR39 ; v4(153.75,138.62) 155.73,140.6 DIMM2.150 ; v4(155.93,138.46) 155.93,138.61 156.12,138.8 DIMM2.156 ; v5(118.87,243.98) 118.04,244.81 NGFF1.7 ; MEM2.A9 49.54,73.56 v4(49.16,73.94) 49.19,73.97 49.19,73.99 MEM2.B9 ; v4(89.78,174.52) 89.35,174.09 CPU1.AK27 ; v4(152.96,170.37) 152.96,170.32 151.74,169.1 DIMM2.63 ; DIMM2.196 156.01,126.8 v4(155.19,127.62) ; v4(165.76,169.71) 165.75,169.7 ; 165.75,169.7 165.15,169.1 DIMM1.63 ; 165.75,169.7 DIMM1.61 ; v4(170.92,183.8) DIMM1.14 ; U29.AG34 139.66,81.53 139.92,81.53 v4(139.96,81.48) ; v4(165.74,145.7) 165.63,145.7 165.63,145.7 DIMM1.133 ; v4(154.72,186.74) 155.38,187.4 DIMM2.2 ; v4(153.09,181.52) 154.22,180.39 154.9,180.39 155.69,179.6 DIMM2.28 ; U29.AV1 145.46,64.11 v4(145.08,63.73) 144.7,64.1 U29.AU1 ; U29.V38 134.44,84.25 v4(134.31,84.38) 134.44,84.5 U29.V40 ; CPU1.AY5 97.52,151.75 v4(98,151.27) ; v4(72.39,84.26) 72.31,84.34 U13.F12 ; v4(78.46,79.1) 78.15,79.41 U13.P6 ; DIMM1.48 170.54,173.6 v4(169.96,173.02) ; NGFF1.18 v3(108.46,242.55) ; DIMM1.195 166.94,127.1 v4(167.11,126.93) ; NGFF1.24 108.73,241.05 v3(108.58,240.9) ; CPU1.AJ35 88.32,181.41 v4(87.93,181.02) ; U13.U25 80.37,95.12 v4(80.14,95.12) ; v4(87.92,182.79) 88.37,183.24 CPU1.AJ37 ; v4(170.92,130.21) 171.11,130.4 DIMM1.184 ; v4(89.15,83.82) 89.15,82.94 U13.AH10 ; v4(146.66,67.35) 146.6,67.41 U29.AW7 ; DIMM1.66 170.89,168.2 170.64,168.45 170.19,168.45 v4(169.66,167.92) ; DIMM1.134 170.61,145.4 170.15,145.86 v4(170.15,145.96) ; DIMM2.46 156.26,174.2 v4(155.91,174.56) 155.96,174.56 156.2,174.8 DIMM2.44 ; v4(145.7,63.59) 145.7,63.59 145.85,63.59 146.03,63.77 146.03,64.6 U29.AW2 145.75,64.88 U29.AV2 144.7,65.47 144.7,65.49 U29.AU3 ; v4(170.92,132.2) DIMM1.178 ; DIMM1.136 170.89,144.8 ; 170.89,144.8 171.49,144.2 DIMM1.138 ; 170.89,144.8 v4(170.87,144.8) ; U29.AV21 144.26,75 U29.AT21 143.91,74.65 U29.AT20 144.47,73.81 v4(144.47,73.74) 144.43,73.74 144.39,73.7 U29.AT18 ; NGFF1.30 v3(108.46,239.55) ; v4(77.72,81.64) 78.02,81.94 U13.P9 ; U13.C32 70.15,99.05 v4(69.9,99.3) ; U13.AC9 85.35,81.94 v4(85.75,81.54) 86.15,81.14 U13.AD8 ; CPU1.AP1 92.04,148.05 v4(92.61,147.48) ; v4(155.94,136.99) 156.21,136.99 156.22,137 DIMM2.162 ; v4(165.76,174.89) 165.55,175.1 DIMM1.43 ; 49.09,77.98 49.12,77.98 49.51,78.36 MEM2.G9 49.66,78.46 50.26,78.46 MEM2.G8 ; 49.09,77.98 49.51,77.56 MEM2.F9 ; 49.09,77.98 v4(49.07,77.98) ; DIMM2.161 150.32,137.3 150.42,137.4 150.98,137.4 v4(151.49,136.89) ; U29.E38 127.46,83.64 U29.D37 ; DIMM2.32 156.33,178.4 v4(155.93,178.8) ; v4(165.76,180.27) 165.54,180.5 DIMM1.25 ; DIMM2.11 152.28,184.7 v4(152.92,185.34) ; 168.07,130.06 v4(168.07,130.21) ; U13.N27 77.6,96.09 77.6,95.19 U13.N25 ; v4(153.3,142.82) 153.3,142.8 152.6,142.1 DIMM2.145 ; CPU1.AM2 90.68,148.56 ; 90.68,148.56 v4(90.69,148.56) ; 90.68,148.56 90.64,148.56 90.21,148.13 CPU1.AM1 ; U13.P25 U13.T25 ; DIMM1.60 v4(170.92,170) ; U29.AT24 143.91,76.9 v4(144.49,76.32) 144.39,76.23 U29.AT23 ; DIMM2.127 150,147.5 150.91,148.41 151.58,148.41 v4(152.08,147.91) ; U29.A16 124.73,72.52 124.36,72.14 v3(122.05,72.14) ; v4(73.67,87.89) 73.67,88.2 73.35,88.52 U13.H17 ; U29.AA34 136.49,81.35 v4(136.61,81.35) 136.74,81.35 U29.AC34 ; U29.A35 125,82.69 v4(124.71,82.41) ; CPU1.AE40 84.76,186.02 84.76,186.52 v4(84.86,186.61) ; v4(155.45,169.53) 155.84,169.53 156.31,170 DIMM2.60 ; v4(170.92,133.99) 171.52,134.6 DIMM1.170 ; v4(151.67,183.49) 151.06,184.1 DIMM2.13 ; R424.2 148.21,33.07 148.21,33.09 147.27,34.02 147.26,34.02 U23.11 U22.11 ; U29.AT16 144.25,72.19 U29.AT15 143.94,71.84 v4(144.46,71.33) 144.39,71.33 144.24,71.17 U29.AT14 ; DIMM2.190 154.62,128.6 v4(153.67,127.65) ; DIMM2.139 150.49,143.9 v4(151.07,144.48) ; v3(76.04,150.41) CPU1.U4 ; U29.AT28 144.41,78.76 v4(144.45,78.8) 144.45,78.88 U29.AT29 ; U29.D37 127.12,83.3 U29.C37 126.47,83.34 126.47,83.72 U29.B38 ; v4(116.33,239) 116.53,238.8 NGFF1.33 ; MEM2.P9 49.56,83.95 v4(49.96,83.56) ; DIMM1.71 166.92,166.7 v4(168.13,167.92) 169.65,166.4 DIMM1.72 ; DIMM2.54 155.89,171.8 154.77,170.68 v4(154.77,170.48) ; U29.A12 125.12,69.94 v4(124.82,69.63) ; MEM1.E8 55.05,102.53 55.05,103.04 55.16,103.15 MEM1.D8 ; U29.AM26 141.49,77.31 v4(141.49,77.09) ; v4(155.64,144.4) 155.74,144.4 155.94,144.2 DIMM2.138 ; v3(148.21,79.82) 147.72,79.82 147.54,79.99 146.1,79.99 U29.AW30 ; v4(116.33,237.09) 116.54,237.3 NGFF1.39 ; DIMM1.139 165.79,143.9 v4(166.42,143.27) ; U29.AM6 141.23,66.91 v4(141.15,66.83) ; CPU1.P39 v3(74.21,184.61) ; v4(129.75,76.05) 129.75,75.86 U29.H22 ; U29.AT7 144.25,67.6 U29.AT8 143.76,67.95 143.39,68.31 v4(143.03,68.31) 143.03,68.63 U29.AP9 143.48,68.86 143.9,69.28 U29.AT10 144.25,69.66 U29.AT11 143.63,69.93 U29.AR11 ; DIMM2.172 155.66,134 v4(155.57,133.92) ; v4(153.2,183.49) 152.01,182.3 DIMM2.19 ; U29.N4 v4(131.74,65.68) ; U29.D41 127.26,85.96 127.2,86.02 127.2,86.12 126.81,86.51 126.71,86.51 126.58,86.64 126.55,86.64 v4(126.42,86.76) ; v3(66.89,183.69) CPU1.E38 ; CPU1.AK1 88.4,148.14 88.4,148.18 v4(88.85,148.62) ; v4(144.05,63.66) 143.98,63.74 U29.AT1 ; v4(84.84,81.52) 84.84,82.25 U13.AB10 U13.Y10 ; CPU1.R39 v3(76.04,184.61) ; v4(116.2,239.89) 116.29,239.8 NGFF1.29 ; v4(86.59,96.76) 86.59,96.7 U13.AE27 ; NGFF1.23 116.45,241.3 v4(116.28,241.13) ; v4(127.53,63.75) 127.25,64.03 U29.D1 ; MEM2.D1 55.95,75.96 v4(55.56,76.35) ; U29.AJ1 140.74,63.71 140.7,63.67 v4(140.7,63.67) ; v4(151.49,170.39) 151.49,170.19 151,169.7 DIMM2.61 ; v4(170.84,182) DIMM1.20 173.9,182 v4(173.93,182.03) ; v4(165.71,133.7) DIMM1.173 ; v4(170.92,178.39) 171,178.39 171.01,178.4 DIMM1.32 ; U29.AM18 141.83,73.62 141.48,73.97 v4(141.48,74.15) 141.48,74.23 U29.AM20 ; v3(68.72,157.72) CPU1.J11 ; DIMM2.170 153.29,134.6 152.95,134.95 v4(152.95,135.32) ; U11.8 U11.3 v3(191.03,104.53) ; U29.B40 126.54,85.81 U29.C41 U29.B41 125.53,86.1 v3(125.53,86.75) ; CPU1.AG40 86.54,185.98 86.12,185.56 v4(86.12,185.52) ; CPU1.AL40 90.21,185.96 v4(89.79,185.55) 90.21,185.13 CPU1.AL39 CPU1.AL38 ; v4(85.05,147.36) 85.05,147.5 84.72,147.83 CPU1.AF1 ; DIMM1.128 v4(170.92,147.2) ; MEM2.T1 55.94,85.56 55.56,85.18 v4(55.55,85.18) ; DIMM2.168 155.87,135.2 v4(155.73,135.34) ; DIMM2.26 155.93,180.2 154.7,181.43 v4(154.7,181.53) ; U29.AT41 144.16,86.39 v4(144.25,86.48) ; U13.U9 81.17,81.52 v4(81.28,81.52) ; DIMM1.190 v4(170.89,128.6) ; v4(83.12,83.93) 83.51,83.54 U13.AA11 ; U29.AM8 141.14,68.22 U29.AK9 140.71,69.06 140.59,69.17 v4(140.59,69.2) ; v4(55.56,76.35) 55.16,76.75 MEM2.E2 ; NGFF1.69 v3(116.31,229.8) ; v4(116.33,231.5) 116.62,231.5 116.82,231.3 NGFF1.63 ; HDMI1.11 v3(50.83,19.95) ; v3(72.38,148.58) CPU1.M1 ; v4(166.47,176.34) 166.45,176.36 166.45,176.4 165.95,176.9 DIMM1.37 ; HDMI1.17 47.83,19.97 v3(48.26,19.54) ; DIMM2.72 155.67,166.4 154.87,167.2 v4(154.83,167.2) ; DIMM2.43 150.54,175.1 150.6,175.04 v4(150.7,175.04) ; U29.AT36 143.98,83.17 U29.AT38 144.52,83.89 v4(144.63,84) 144.64,84.01 U29.AU39 ; HDMI1.2 v3(55.33,19.97) ; CPU1.AD8 83.34,154.97 v4(83.37,154.97) 83.75,154.58 83.75,154.58 CPU1.AE8 ; v4(160.4,147.86) 160.76,147.5 DIMM1.127 ; NGFF1.36 v3(108.64,238.05) ; v4(152.97,169.54) 152.97,169.45 154.22,168.2 DIMM2.66 ; v4(54.76,98.82) MEM1.J8 ; DIMM1.151 165.82,140.3 166.42,140.9 v4(166.42,140.93) ; HDMI1.5 v3(53.83,19.94) ; U20.5 v3(33.15,73.86) ; HDMI1.8 v3(52.33,19.93) ; DIMM2.167 150.51,135.5 v4(150.66,135.35) ; v4(170.92,171.8) DIMM1.54 ; v4(165.68,137.02) 165.4,137.3 DIMM1.161 ; U13.K32 74.95,99.2 v4(75.08,99.34) ; v4(162.69,130.29) 162.87,130.1 DIMM1.185 ; DIMM1.168 171.44,135.2 171.12,134.88 170.59,134.88 v4(170.13,135.34) ; DIMM2.8 155.46,185.6 v4(155.2,185.34) ; NGFF1.45 v3(116.23,235.8) ; DIMM2.144 156.01,142.4 155.73,142.68 v4(155.73,142.76) ; v4(165.84,182.08) 165.61,182.3 DIMM1.19 ; CPU1.AM31 91.12,177.74 v4(91.54,177.32) 92.02,176.84 CPU1.AN30 ; DIMM1.44 170.78,174.8 v4(170.77,174.8) ; v4(170.92,137) DIMM1.162 ; U29.C25 126.59,77.15 U29.B25 ; CPU1.AG39 86.55,185.04 86.98,184.61 v4(87.06,184.61)
  TOP w0.33: DIMM2.189 152.79,128.9 153.54,129.65 v4(153.54,129.9) ; v4(150.67,130.11) 150.65,130.11 150.64,130.1 DIMM2.185 ; DIMM2.173 151.32,133.7 151.4,133.78 v4(152.62,133.78) 152.91,133.49 152.91,132.38 v4(152.91,132.38) ; v4(151.39,132.32) 151.38,132.31 151.38,132.23 150.91,131.76 150.46,131.76 150.32,131.9 DIMM2.179 ; DIMM2.187 151.57,129.5 151.96,129.88 151.96,129.94 v4(152.12,130.11) ; DIMM2.178 153.97,132.2 v4(153.8,132.38) ; DIMM1.136 175.55,144.8 176.02,145.27 ; v4(150.75,126.6) 150.75,126.67 150.32,127.1 DIMM2.195
  TOP w0.356: v4(94.33,159.87) 93.93,159.46 CPU1.AR11 ; v4(94.33,159.87) 94.73,159.46 CPU1.AT11 ; v4(94.33,159.87) 94.78,160.32 CPU1.AT12 ; CPU1.T39 v3(76.04,185.52) CPU1.R40 ; CPU1.AJ8 v4(87.01,154.98) CPU1.AH8 ; U29.AC30 137.39,79.63 v4(137.66,79.9) ; v4(135.62,75.04) 135.24,74.65 U29.W20 ; v4(135.62,75.04) U29.AA22 ; v4(135.62,75.04) 135.21,75.45 U29.W22 ; v4(83.12,83.93) 83.05,84 82.01,84 U13.V11 ; v3(61.1,153.61) 61.14,153.61 CPU1.A7 ; v3(66.89,158.63) CPU1.G12 v3(67.81,157.72) ; CPU1.C19 63.71,164.58 v3(64.15,164.13) 63.69,163.67 CPU1.C18 ; CPU1.AT25 94.88,172.36 95.59,172.36 CPU1.AU25 ; CPU1.AJ40 88.38,186.01 v4(88.86,186.49) ; CPU1.D9 v3(64.15,155.89) ; v3(65.98,171.44) CPU1.F26 ; MEM1.J2 50.36,99.22 v4(49.96,99.63) ; U29.AA14 136.08,71.42 v4(136.47,71.82) 136.87,71.42 U29.AB14 ; v3(67.81,175.09) CPU1.H30 ; v4(80.16,95.87) 80.55,96.26 U13.U27 ; CPU1.T7 v3(76.04,153.15) CPU1.T6 ; CPU1.AA6 v3(79.69,152.23) CPU1.Y6 ; U13.P32 78.15,100.23 v4(78.99,101.08) ; U29.AA28 U29.AB28 U29.AD28 ; U29.AA28 136.08,78.72 U29.AA30 ; U29.AA28 U29.W28 ; CPU1.AV38 96.61,184.28 96.65,184.32 96.65,184.83 96.61,184.87 CPU1.AV39 CPU1.AU40 ; v4(74.52,92.56) 74.94,92.14 U13.K22 ; CPU1.N7 v3(72.38,153.15) CPU1.N6 ; U13.R27 78.95,95.79 v4(78.99,95.74) ; v4(138.2,79.11) 138.58,78.73 U29.AF28 ; v4(138.2,79.11) 138.3,79.22 138.93,79.22 139.4,79.69 U29.AG30 ; v4(138.2,79.11) 137.76,78.68 U29.AD28 ; v3(71.46,180.04) CPU1.K34 ; CPU1.G16 v3(66.89,161.38) CPU1.F16 ; CPU1.A11 61.34,157.26 v3(61.21,157.13) ; v3(67.81,178.21) CPU1.F32 ; v4(129.39,69.45) 129.35,69.41 U29.H9 ; U29.K9 130.46,68.71 v4(130.05,68.29) 129.97,68.22 U29.H8 ; v4(85.74,79.98) 85.74,79.95 U13.AD6 U13.AE7 ; v4(88.83,170.82) 88.77,170.82 CPU1.AJ23 88.38,170.27 88.32,170.21 88.32,169.69 88.38,169.64 CPU1.AJ22 ; CPU1.AD36 83.88,182.32 v4(84.29,182.73) 84.7,182.32 CPU1.AE36 ; U29.H33 129.29,81.37 v4(128.85,81.8) 128.94,81.88 U29.H34 ; CPU1.AW32 97.52,178.69 v4(98.01,179.17) ; CPU1.AT4 93.91,150.86 v4(94.38,150.39) 94.38,150.39 94.78,149.99 CPU1.AU3 ; CPU1.AR19 93.81,166.78 v4(93.39,167.2) ; CPU1.B8 62.11,154.52 v3(62.03,154.6) ; CPU1.AA7 v3(80.61,154.06) CPU1.AB7 ; CPU1.AN37 92.04,183.22 v4(92.46,182.8) ; v4(92.46,186.65) 92.04,186.22 CPU1.AN40 ; CPU1.AR16 93.87,164.02 v4(94.32,163.57) CPU1.AT16 ; U29.N35 131.1,82.47 v4(131.09,82.48) ; CPU1.T4 v3(76.04,150.41) ; Q66.1 39.5,45.63 v3(39.98,46.11) ; U29.N31 131.28,80.34 131.22,80.4 ; v4(133.93,78.28) 134.33,77.87 U29.V26 ; v4(133.93,78.28) 133.53,77.87 U29.T26 ; v4(133.93,78.28) 133.53,78.68 U29.T28 ; v4(133.93,78.28) 134.33,78.68 U29.V28 ; v3(61.07,162.92) 61.24,162.75 CPU1.A17 ; U13.F6 71.53,79.32 71.53,79.07 v4(71.52,79.06) ; MEM2.B1 56.8,74.36 v4(56.96,74.52) ; CPU1.AY23 98.79,170.44 v4(99.04,170.69) ; CPU1.K24 70.09,169.17 v3(69.63,169.62) ; v4(81.03,99.3) 81.35,98.97 U13.V32 ; CPU1.K30 70.09,174.65 v3(69.63,175.11) ; CPU1.W1 78.32,147.36 v3(78.17,147.21) ; CPU1.AK14 89.35,162.21 v4(89.78,161.78) 90.2,162.21 CPU1.AL14 ; U29.B33 126.67,81.46 v4(126.76,81.37) ; CPU1.AJ11 v4(88.84,159.92) CPU1.AK11 ; v3(36.75,44.48) 36.75,44.35 37.35,43.75 Q66.4 ; CPU1.Y5 v3(78.78,151.32) CPU1.W4 ; CPU1.AT15 94.78,163.08 v4(94.32,162.62) ; v3(78,187.28) 78.32,186.89 CPU1.V40 ; Q54.1 85.33,63.82 85.04,63.53 85.04,62.86 v3(84.07,61.9) ; U13.J7 74.51,79.98 74.51,79.97 v4(74.54,79.94) 74.55,79.94 U13.K6 ; CPU1.AJ19 88.38,166.77 v4(87.94,166.33) ; CPU1.G21 67.35,166.44 v3(67.8,166.89) 68.26,166.43 CPU1.H21 ; v3(78.11,155.33) 77.41,154.62 CPU1.V8 ; U13.H6 73.66,79.23 73.66,79.15 v4(73.69,79.12) ; CPU1.F14 v3(66.89,159.55) CPU1.G13 ; U13.AB32 84.55,99.51 v4(84.49,99.57) ; v3(77.86,149.49) CPU1.V3 ; U13.G27 72.55,96.33 v4(72.15,95.93) 72.07,95.85 72.06,95.85 U13.F26 ; v3(71.46,162.3) 71.92,161.84 CPU1.M16 ; U29.W8 135.26,68.34 v4(135.61,68.69) ; CPU1.H9 v3(67.81,154.98) CPU1.G9 ; CPU1.E20 v3(65.98,165.04) CPU1.F19 ; v4(84.87,79.99) 84.87,79.86 U13.AB6 ; U13.AC17 85.74,88.93 v4(85.74,89.24) ; CPU1.AM15 91.14,163.12 v4(91.58,163.56) 92.04,164.02 CPU1.AN16 ; v4(94.32,162.62) 94.74,162.21 CPU1.AT14 ; v4(94.32,162.62) 93.91,162.21 CPU1.AR14 ; CPU1.D6 v3(65.06,152.23) CPU1.D5 ; CPU1.E6 v3(65.98,153.15) CPU1.E7 ; U13.J27 74.15,96.33 74.55,95.93 v4(74.55,95.92) ; U13.AH32 89.35,98.91 v4(89.7,99.27) ; U13.AB15 84.55,86.69 v4(84.02,87.22) 84.02,87.28 83.77,87.54 U13.AA16 ; v4(76.81,79.05) 76.55,79.31 U13.M6 ; CPU1.A13 61.51,158.74 61.5,158.74 v3(61.4,158.64) ; U13.AF32 87.75,99.26 v4(87.71,99.3) ; v3(69.63,167.79) 70.09,167.34 CPU1.K22 ; CPU1.H4 v3(67.81,150.41) CPU1.G3 ; v3(76.95,183.69) CPU1.U37 ; CPU1.AL17 90.21,164.96 v4(90.66,165.41) ; CPU1.E3 CPU1.F4 ; CPU1.K20 v3(69.63,165.95) CPU1.J20 ; v3(69.63,180.04) CPU1.H34 ; CPU1.AP11 92.91,159.46 v4(92.49,159.04) 92.06,159.46 CPU1.AN11 91.91,159.46 91.84,159.39 91.32,159.39 91.25,159.46 CPU1.AM11 ; CPU1.F7 v3(66.89,153.15) ; CPU1.AR18 93.88,165.86 v4(94.36,165.38) 93.94,164.95 CPU1.AR17 ; CPU1.J20 v3(68.72,165.04) ; CPU1.J20 v3(68.72,165.95) ; v3(73.29,183.69) CPU1.M37 ; v3(78.78,183.69) CPU1.W37 ; v4(49.08,93.88) 49.29,93.88 49.55,93.62 MEM1.T1 ; U13.AD25 86.17,94.74 v4(86.54,94.37) ; U33.8 U33.3 61.98,21.04 61.54,20.61 v3(61.54,19.54) ; CPU1.N1 v3(72.38,148.58) ; CPU1.AV21 96.6,168.61 v4(96.17,169.04) ; v4(72.24,90.47) 72.15,90.47 71.88,90.74 U13.F20 ; v4(128,67.12) 127.87,66.99 U29.E5 ; CPU1.AJ27 88.38,174.09 v4(88.83,173.64) 88.83,173.64 89.29,173.18 CPU1.AK26 ; CPU1.AM14 v4(90.67,161.75) ; CPU1.AU7 94.79,153.61 v4(95.23,154.04) 95.66,153.61 CPU1.AV7 ; U29.AA10 136.04,69.05 135.69,68.69 v4(135.61,68.69) ; CPU1.AT10 93.87,156.28 v4(94.29,155.85) 93.88,155.43 CPU1.AT9 ; MEM1.B9 56.66,104.82 v4(56.75,104.73) ; CPU1.B10 62.05,156.35 v3(61.97,156.26) ; U13.F24 71.73,93.96 v4(71.15,93.96) ; U29.T25 133.54,77.07 v4(133.94,76.67) ; v3(71.46,164.12) CPU1.M18 ; CPU1.E8 v3(65.06,154.98) ; MEM1.A9 55.91,105.67 v4(55.91,106.26) ; U13.T32 79.75,99.69 v4(79.12,100.31) ; U13.AC26 84.97,95.92 84.97,95.92 v4(84.95,95.95) 84.96,95.96 84.97,95.96 U13.AC27 ; CPU1.AW7 96.65,153.61 v4(97.06,154.02) 97.47,153.61 CPU1.AY7 ; CPU1.AY27 98.44,174.02 v4(98.02,173.61) ; U29.D14 126.92,71.34 v4(126.77,71.19) ; U13.E28 70.97,97.14 v4(71.37,97.55) ; CPU1.AK18 v4(89.75,165.41) ; v4(137.66,79.9) 137.22,80.34 U29.AC31 ; v4(137.66,79.9) 137.76,79.9 138.02,80.16 138.04,80.16 U29.AE31 ; MEM1.G9 56.48,100.82 v4(56.54,100.76) ; CPU1.D30 v3(64.15,175.09) ; CPU1.AL37 90.28,183.24 v4(90.71,182.81) ; v4(72.31,89.09) 72.29,89.09 72.25,89.14 U13.F18 ; CPU1.N39 73.77,185.07 v3(74.23,185.52) ; CPU1.H7 v3(68.72,153.15) ; v3(141.35,37.45) 142.27,37.45 142.71,37.01 U22.4 U23.4 ; v4(82.61,94.37) 82.98,94.74 U13.Y25 ; U13.AA27 v4(83.75,96.94) ; v3(67.81,171.44) CPU1.H26 ; v3(69.63,173.28) 70.09,172.82 CPU1.K28 ; v3(87.5,66.18) 87.35,66.33 Q54.4 ; v4(77.04,96.83) 77.26,96.61 77.26,96.43 U13.N27 ; U29.AD28 137.73,78.59 137.63,78.48 137.63,78.04 137.73,77.94 U29.AD26 ; U13.H14 73.2,86.14 72.9,86.44 v4(72.9,86.67) ; v3(71.46,167.78) CPU1.M22 ; v4(88.84,165.34) 88.38,165.8 CPU1.AJ18 ; CPU1.A15 61,160.92 v3(60.96,160.89) ; MEM1.M1 49.04,96.82 v4(49,96.78) ; v3(65.06,153.15) CPU1.D7 ; v3(78.78,150.41) CPU1.Y4 ; CPU1.AV34 96.61,180.49 v4(97.07,180.02) 97.52,180.47 CPU1.AW34 ; v4(98.02,173.61) 98.44,173.2 CPU1.AY26 ; v4(98.02,173.61) 97.59,173.18 CPU1.AW26 ; MEM1.E8 55.53,102.05 MEM1.F9 ; U13.L27 75.74,96.34 v4(75.34,96.74) 75.27,96.81 75.27,96.82 U13.K28 ; CPU1.F28 v3(65.98,173.27) ; U13.Y17 82.16,88.73 v4(82.14,88.73) 82.14,88.75 U13.V18 ; CPU1.C14 v3(63.23,160.46) ; U13.M32 76.55,99.3 v4(76.56,99.31) ; v4(91.57,161.76) 92.02,162.21 CPU1.AN14 ; CPU1.M6 v3(71.46,153.15) CPU1.M7 ; U29.T22 133.54,75.45 v4(133.94,75.85) 133.54,76.26 U29.T23 ; CPU1.AR23 93.87,170.46 v4(93.4,170.92) 92.98,171.35 CPU1.AP24 ; CPU1.K1 70.09,147.4 v3(70.37,147.12) ; CPU1.AW30 97.52,176.85 v4(98,177.33) 98.44,176.89 CPU1.AY30 ; CPU1.B28 v3(62.32,173.27) ; U4.4 176.48,186.29 176.73,186.55 v3(178.82,186.55) ; v4(56.62,96.81) 56.61,96.82 MEM1.M9 ; CPU1.AK13 v4(88.84,160.83) CPU1.AK12 ; MEM1.D1 49.29,103.5 v4(48.51,103.5) ; CPU1.AA35 v3(80.61,181.87) ; v3(62.79,166.4) 63.06,166.4 63.06,166.41 CPU1.C21 ; CPU1.T2 CPU1.T1 75.58,147.24 v3(75.81,147.01) ; CPU1.AR24 93.87,171.38 v4(94.29,171.81) 94.75,171.35 CPU1.AT24 ; CPU1.AP5 92.04,151.75 v4(92.49,151.29) 92.95,151.75 CPU1.AR5 ; v3(65.98,178.21) CPU1.D32 ; MEM1.P1 49.55,95.22 49.18,95.59 v4(49.07,95.59) ; v3(64.15,180.04) CPU1.B34 ; v4(75.42,83.09) 75.42,83.11 74.95,83.58 U13.K11 ; U13.W27 82.03,96.34 81.55,95.86 81.54,95.86 81.46,95.78 v4(81.41,95.78) 81.65,95.54 U13.W26 ; v4(89.74,166.32) 89.29,166.77 CPU1.AK19 ; MEM2.J8 50.36,79.96 v4(50.76,80.36) ; U29.AN28 142.54,78.85 142.03,78.34 v4(142.03,78.23) ; v3(68.72,185.52) CPU1.H39 ; v3(72.38,149.49) CPU1.N2 ; CPU1.B24 v3(62.32,169.61) ; v3(67.81,159.55) CPU1.H13 ; v3(71.46,171.44) CPU1.M26 ; CPU1.AK9 88.38,155.48 v3(87.87,155.99) 88.24,156.35 CPU1.AK10 ; U29.AA12 136.19,70.47 136.53,70.14 v4(136.6,70.14) 136.22,69.76 U29.AA11 ; v3(63.22,162.28) 63.24,162.28 CPU1.C16 ; v3(62.32,171.44) CPU1.B26 ; U13.Y32 82.95,99.33 v4(82.97,99.35) ; CPU1.AK24 89.29,171.36 v4(89.77,171.84) 90.21,171.4 CPU1.AL24 ; v3(87.86,164.47) 88.29,164.03 CPU1.AJ16 ; CPU1.C6 v3(63.23,153.15) ; U13.AD32 86.15,99.26 v4(86.08,99.32) ; v4(71.21,82.58) 71.23,82.58 71.39,82.74 U13.F10 U13.G10 ; U29.AM35 141.82,82.53 142.42,81.94 v4(142.42,81.79) ; U13.H20 73.35,90.87 73.69,90.53 v4(73.69,90.48) ; CPU1.H22 v3(67.81,167.78) ; CPU1.AY17 v4(98.01,165.38) ; v3(71.46,169.61) CPU1.M24 ; CPU1.AK7 88.33,153.61 v4(87.9,154.03) 88.38,154.52 CPU1.AK8 ; MEM1.B1 49.38,104.82 49.28,104.92 49.15,104.92 v4(49.05,105.02) ; U13.J31 v4(74.15,98.9) ; v3(27.92,24.64) 27.92,25.56 27.89,25.6 U30.2 ; CPU1.C12 v3(63.23,158.63) ; CPU1.AP14 92.95,162.21 v4(92.53,162.62) 92.95,163.05 CPU1.AP15 ; v4(89.15,83.82) 88.63,84.34 U13.AG12 ; CPU1.K26 70.09,170.99 v3(69.63,171.45) ; CPU1.AJ14 v4(87.92,162.66) ; MEM1.T9 55.58,94 v4(55.58,94.03) ; U13.AC24 85.05,93.64 v4(84.85,93.64) 84.65,93.64 U13.AB24 ; v4(92.43,169.97) 92.43,169.91 CPU1.AN22 ; U13.V13 81.36,85.54 80.9,85.07 80.21,85.07 v4(80.14,85.15) 80.14,85.15 U13.T13 ; CPU1.AL21 90.21,168.66 v4(90.62,169.08) 90.21,169.49 CPU1.AL22 ; CPU1.U35 v3(76.95,181.87) ; MEM1.P9 55.57,95.62 v4(55.55,95.62) ; v4(91.55,166.28) 91.97,165.86 CPU1.AN18 ; v4(91.55,166.28) 92.04,166.76 CPU1.AN19 ; v4(91.55,166.28) 91.12,166.71 CPU1.AM19 ; CPU1.AB5 81.04,151.78 v3(80.58,152.24) ; v4(71.19,87.51) 71.26,87.51 71.28,87.54 U13.F16 ; CPU1.L7 v3(70.55,153.15) CPU1.K7 ; CPU1.AT8 93.86,154.52 v4(93.4,154.06) 93.85,153.61 CPU1.AT7 ; v3(71.46,183.69) CPU1.L38 ; v3(77.86,153.15) CPU1.W7 ; U13.V16 81.56,87.54 v4(82.09,87) 82.55,86.55 U13.Y15 ; CPU1.F30 v3(65.98,175.09) ; v3(71.46,178.21) CPU1.K32 ; v3(69.63,178.21) CPU1.H32 ; CPU1.AN10 91.2,156.35 v4(91.64,155.9) 91.17,155.43 CPU1.AN9 ; U13.F22 71.45,92.34 v4(71.2,92.59) ; CPU1.AA3 80.15,149.37 v3(79.98,149.2) ; v4(72.23,85.42) 72.21,85.44 72.21,85.48 U13.F14 ; v3(72.38,152.23) CPU1.M5 ; U13.T25 79.93,95.12 v4(80.14,95.12) ; v3(69.63,183.69) CPU1.J37 ; U13.AA13 83.8,85.54 v4(84.05,85.79) ; CPU1.R5 CPU1.T5 v3(76.04,152.23) ; v3(64.15,171.44) CPU1.D26 ; CPU1.AJ34 88.38,180.45 v4(87.95,180.02) ; CPU1.D28 v3(64.15,173.27) ; v3(73.29,178.21) CPU1.M32 ; U29.R34 132.68,81.42 132.57,81.42 v4(132.47,81.32) ; v3(77.86,152.23) CPU1.V6 ; CPU1.H10 v3(67.81,156.81) CPU1.H11 ; CPU1.D11 v3(64.15,157.72) ; U29.U31 133.9,80.34 v4(133.58,80.66) 133.65,80.66 134.05,81.05 U29.U32 ; v4(141.55,71.95) 141.55,72.17 U29.AM16 ; v3(71.46,175.09) CPU1.M30 ; v3(67.81,169.61) CPU1.H24 ; v3(61.19,151.56) 61.64,151.56 CPU1.A5 ; U13.G31 v4(72.55,98.97) ; U29.K31 U29.J31 129.78,79.5 v4(129.79,79.49) ; v3(66.89,160.46) CPU1.G14 ; v3(69.63,150.41) CPU1.K4 ; CPU1.B30 v3(62.32,175.09) ; v3(178.69,183.73) 178.36,184.06 U4.1 ; v3(65.98,180.04) CPU1.D34 ; CPU1.AR20 93.87,167.81 93.77,167.9 93.77,168.42 93.87,168.51 CPU1.AR21 ; v4(87.38,85.71) 87.38,85.71 U13.AE14 ; CPU1.G11 v3(66.89,157.72) CPU1.F12 ; MEM1.B3 51.85,105.5 v4(51.85,106.69) ; v3(67.81,173.27) CPU1.H28 ; CPU1.F1 66.43,147.54 v4(66.38,147.48) ; v3(76.95,148.58) CPU1.U2 ; v4(94.29,160.83) 94.75,161.29 CPU1.AT13 ; CPU1.J6 v3(69.63,153.15) ; MEM2.T9 49.56,86.31 v4(49.61,86.36) ; CPU1.N33 v3(74.21,180.04) ; CPU1.AM35 v4(91.54,181.83) CPU1.AN36 ; v3(64.15,178.21) CPU1.B32 ; CPU1.R3 v3(74.21,149.49) CPU1.P2 ; U13.Y20 82.8,90.59 v4(83.06,90.59) ; CPU1.M4 v3(71.46,150.41) CPU1.L3 ; v3(71.46,160.47) 71.92,160.01 CPU1.M14 ; v3(67.81,180.04) CPU1.F34 ; v3(71.46,165.95) CPU1.M20 ; CPU1.G7 v3(67.81,154.06) CPU1.H8 ; CPU1.AA38 81.06,184.56 80.33,185.3 v3(80.33,186.51) ; CPU1.E10 v3(65.06,155.89) ; v4(135.61,68.69) 135.96,68.34 U29.AA8 ; U29.H6 129,66.91 v4(128.8,67.12) ; v3(70.32,187.1) 71.01,186.41 CPU1.K40 ; CPU1.D13 v3(64.15,159.55) ; U13.G8 72.43,81.02 72.4,81.02 72.38,81 71.94,81 71.92,81.02 71.87,81.02 U13.F8 71.75,81.14 71.52,81.14 v4(71.24,80.85) ; v4(87.06,184.61) 87.03,184.58 86.98,184.58 CPU1.AG38 ; v3(70.55,157.72) CPU1.L11 ; CPU1.AN8 91.15,154.52 v4(91.61,154.06) 91.15,153.61 CPU1.AN7 ; v4(79.44,79.1) 79.44,79.23 U13.T6 ; U13.W25 81.54,94.74 v4(81.3,94.98) ; CPU1.AL11 v4(89.75,159.01) ; CPU1.C4 63.69,150.89 v3(63.25,151.33) ; CPU1.AR40 93.87,185.94 v4(93.46,185.53) ; v3(65.98,169.61) CPU1.F24 ; v3(74.21,184.61) CPU1.P38 ; v3(71.46,173.27) CPU1.M28 ; CPU1.AW36 v4(98.05,182.85) ; CPU1.AE5 v3(84.28,151.31) ; v3(76.95,153.15) CPU1.U7 ; v3(70.55,156.81) CPU1.K10 ; CPU1.G6 v3(67.81,153.15) ; CPU1.D24 v3(64.15,169.61) ; v3(67.81,163.21) 67.81,163.16
  TOP w0.381: CPU1.AM30 91.11,176.85 91.11,176.86 v4(90.67,177.3) 90.23,176.86 90.23,176.86 CPU1.AL30 ; U29.AD14 137.73,70.82 v4(137.72,70.81) 137.82,70.81 U29.AE12 ; CPU1.AF4 v3(84.28,151.31) 84.72,151.75 CPU1.AF5 ; CPU1.AV3 96.11,149.53 96.13,149.53 v4(96.14,149.52) 96.18,149.52 96.61,149.95 CPU1.AW3 ; v3(82.44,185.5) 82.87,185.07 CPU1.AC39 ; v4(136.69,68.68) 136.81,68.68 U29.AC8 137.29,68.48 138.08,68.48 U29.AE8 ; CPU1.AM34 CPU1.AM35 ; CPU1.AT5 93.84,151.78 v4(93.36,152.26) 93.79,152.69 CPU1.AT6 ; CPU1.AC3 v4(82.44,149.49) ; v4(82.44,149.49) CPU1.AD2 ; v4(82.44,149.49) CPU1.AD3 82.74,150.1 82.74,150.71 CPU1.AD4 ; 90.69,150.38 90.64,150.38 CPU1.AM3 ; 90.69,150.38 CPU1.AM4 ; 90.69,150.38 v4(90.71,150.38) ; CPU1.AV28 96.22,175.4 96.18,175.4 v4(96.1,175.48) ; v4(94.37,152.23) 94.74,151.86 94.74,151.82 CPU1.AU5 ; v4(138.78,68.79) 139.24,68.34 U29.AG8 ; CPU1.B4 v3(63.25,151.33) ; CPU1.AR33 93.89,179.58 94.35,179.12 v4(94.38,179.12) ; CPU1.AG5 85.64,151.75 v4(86.08,151.31) 86.08,151.31 CPU1.AH5 ; v4(84.29,182.73) 84.72,183.17 CPU1.AE37 ; CPU1.AR30 93.87,176.9 v4(93.45,177.32) ; U29.M24 131.54,76.53 v4(132.03,76.03) ; CPU1.AT34 94.78,180.49 v4(94.32,180.96) ; v4(92.43,169.97) 92.43,170.05 CPU1.AN23 ; CPU1.AC6 v3(82.44,153.15) CPU1.AD6 ; CPU1.AC33 82.89,179.58 v3(82.44,180.04) 82.89,180.49 CPU1.AC34 82.89,180.5 v3(82.44,180.95) 82.89,181.41 CPU1.AC35 82.89,181.41 v3(82.44,181.87) 82.89,182.32 CPU1.AC36 v3(82.44,182.78) CPU1.AB37 ; CPU1.AR32 93.92,178.67 v4(94.38,179.12) ; CPU1.AM24 91.6,171.83 91.6,171.83 ; CPU1.AK6 87.95,152.26 v4(87.94,152.26) 87.47,151.79 CPU1.AJ5 ; CPU1.AR34 93.87,180.5 v4(94.32,180.96) ; CPU1.AH4 86.55,150.83 v4(86.1,150.38) 86.12,150.38 CPU1.AH3 ; CPU1.AT1 93.87,148.18 v4(94.29,148.61) ; v4(95.27,180.94) 95.69,180.52 CPU1.AU34 ; CPU1.AP4 92.06,150.86 v4(92.49,151.29) ; U29.AA17 136.01,73.03 v4(135.6,73.43) ; CPU1.AL5 88.85,152.22 v4(88.85,152.26) 88.38,151.79 CPU1.AK5 88.29,151.69 88.29,150.95 CPU1.AK4 ; v4(94.32,180.96) 93.87,181.41 CPU1.AR35 ; CPU1.AR31 93.87,177.74 v4(93.45,177.32) ; CPU1.AC7 v3(82.44,154.06) CPU1.AD7 ; v4(93.34,182.79) 93.33,182.78 93.33,182.7 CPU1.AP36 ; v3(158.62,100.19) 158.62,100.06 157.82,99.26 R213.2 ; CPU1.AM36 91.12,182.39 v4(90.71,182.81) 90.69,182.81 CPU1.AL36 ; v4(93.45,177.32) 92.96,176.84 CPU1.AP30 ; 91.6,171.83 92.04,171.4 CPU1.AN24 ; 91.6,171.83 v4(91.6,171.84) ; v4(94.38,179.12) 94.38,179.06 CPU1.AT32 ; v4(82.45,148.6) 82.45,148.56 CPU1.AD1 ; CPU1.AM33 v4(91.58,179.12) CPU1.AM32 ; CPU1.AC37 82.89,183.24 v3(82.44,183.7) 82.89,184.15 CPU1.AC38 ; v4(86.04,182.79) 86.51,182.32 CPU1.AG36 ; v4(86.04,182.79) 85.64,182.38 CPU1.AF36 ; v4(86.04,182.79) 86.06,182.79 86.51,183.24 CPU1.AG37 ; U29.M28 131.67,78.67 131.67,77.87 131.48,77.68 U29.M26 131.49,77.65 v4(132.03,77.1) ; v4(96.15,176.35) 96.15,176.38 CPU1.AU30 ; CPU1.AR37 93.87,183.17 v4(94.27,182.76) 94.29,182.76 94.73,182.32 CPU1.AT36 ; CPU1.AT25 CPU1.AT26 ; CPU1.T36 v3(76.04,182.78) ; v4(135.51,70.94) 135.49,70.81 U29.W12 ; CPU1.AJ36 88.38,182.31 v4(88.84,181.85) 89.29,182.31 CPU1.AK36 ; CPU1.AB34 CPU1.AA35 ; U29.H26 129.41,77.98 v4(129.75,78.32) 129.41,78.66 U29.H28 ; v3(68.26,147.48) CPU1.H1 ; CPU1.AH36 87.47,182.34 v4(87.92,182.79) ; CPU1.AR38 93.91,184.15 v4(94.32,184.56) ; U29.AH14 139.75,71.25 139.15,71.85 v4(139.04,71.85) 138.61,71.42 U29.AF14 ; CPU1.AF8 v4(85.18,154.98) CPU1.AG8 ; CPU1.AU38 95.68,184.15 v4(95.25,184.58) ; 95.19,176.39 95.19,176.42 94.82,176.8 ; v3(82.44,152.23) CPU1.AD5 ; U29.M18 131.54,73.63 131.48,73.69 131.48,74.53 U29.M20 ; v4(94.32,149.49) 93.87,149.94 CPU1.AT3 ; v4(97.86,149.41) 97.86,149.5 97.63,149.73 97.52,149.84 CPU1.AY3 ; CPU1.AC40 82.89,186.13 82.55,186.47 82.55,186.67 v3(82.54,186.67)
  TOP w0.406: U47.1 26.05,142.87 v3(26.52,142.4) 26.7,142.58 U47.2 ; Q9.1 64.27,216.32 64.27,215.18 v3(64.26,215.17) 64.72,214.72 Q11.1 ; CPU1.AT29 95.04,176.18 95.05,176.18 v4(95.23,176.36) 95.19,176.39 ; CPU1.AT28 94.77,175.01 v4(94.3,174.53) ; v3(53.82,27.24) 53.85,27.26 U27.3 U27.8 ; CPU1.AR20 93.87,167.67 v4(93.39,167.2) ; Q11.4 67.53,212.69 v3(67.64,212.58) ; v4(94.3,174.53) 94.73,174.09 CPU1.AT27 ; v4(94.3,174.53) 93.87,174.1 CPU1.AR27 ; U29.AW40 146.24,85.71 146.24,86.09 v4(145.98,86.35) ; U31.8 v3(42.11,27.03) ; CPU1.AP27 92.93,174.09 v4(92.52,173.68) 92.45,173.68 CPU1.AN27 ; R442.2 137.41,58.54 v3(136.75,57.88) ; Q45.4 171.72,81.28 172.21,81.77 172.21,81.99 v3(172.31,82.09) ; U46.2 21.49,146.86 21.53,146.9 R1157.2 21.65,147.18 22.91,147.18 v3(23.19,147.46) ; v3(66.29,217.84) 65.91,218.22 Q9.4 ; CPU1.R6 CPU1.P5 v3(73.29,152.23) ; CPU1.AT25 94.75,172.26 v4(94.29,171.81) ; v4(87.91,172.67) 87.91,172.71 CPU1.AJ26 ; CPU1.AL27 v4(90.67,173.64) CPU1.AM27 ; v4(88.89,172.73) 88.89,172.67 CPU1.AK25 ; v4(96.15,176.35) 96.61,176.81 CPU1.AV30 ; CPU1.AR21 93.87,168.68 93.98,168.8 93.98,169.34 93.87,169.45 CPU1.AR22 ; U10.8 v3(185.52,126.27) ; 94.82,176.8 CPU1.AT30
  TOP w0.508: C115.2 15.96,147.06 15.49,146.59 ; v3(167.84,79.23) 167.91,79.3 Q44.1 ; R452.2 v3(61.19,57.16) ; SSUSB2.11 195.62,99.77 ; SSUSB2.11 195.62,97.53 ; SSUSB2.11 193.75,98.65 ; SSUSB2.11 197.49,98.65 ; D5.1 25.35,150.09 25.88,149.55 v3(25.88,149.41) 25.83,149.36 25.72,149.36 24.8,148.45 R156.2 ; PC50.2 98.35,32.17 v3(98.78,31.73) ; v3(81.41,207.12) 80.63,206.35 C40.2 C39.2 79.57,206.8 v3(79.73,206.97) ; C109.2 146.35,149.46 v4(146.67,149.78) ; v5(144.27,122.84) 143.86,123.25 DIMM2.205 138.8,123.25 v5(138.39,122.84) ; v3(53.85,61.71) 53.85,61.92 Q56.S ; C49.2 R99.1 v3(178.82,187.33) ; PC35.2 112.33,67.97 v3(111.64,68.67) ; R432.2 149.86,60.79 v3(150.22,60.44) 150.22,60.18 150.42,59.98 C865.1 ; LED1.K 120.35,43.8 v3(120.65,44.1) ; v3(117.95,93.33) 117.45,93.33 117.06,92.95 C174.2 ; 5.17,141.55 ATX2.3 ; ATX2.3 7.55,141.55 ; ATX2.3 6.36,142.74 ; ATX2.3 6.36,140.36 ; C169.2 11.18,92.41 v3(11.3,92.29) 11.3,92.03 11.43,91.91 C177.2 10.85,90.08 C180.2 ; C310.1 45.48,29.38 v3(45.59,29.5) ; C309.2 23.83,32.71 23.2,32.71 v3(22.33,31.83) 22.33,31.51 22.45,31.38 Q127.E ; USB3.5 94.95,8.03 ; USB3.5 94.95,4.6 ; USB3.5 96.67,6.31 ; USB3.5 93.24,6.31 ; HDD1.8 7.62,64.78 ; HDD1.8 6.37,63.53 ; HDD1.8 7.62,62.28 ; HDD1.8 8.87,63.53 ; v3(162.81,99.81) 163.07,99.55 164.85,99.55 C157.2 ; v5(154.72,25.76) 154.34,25.38 C315.2 ; PC36.2 48.33,66.7 v3(48.03,66.4) 48.09,66.35 Q55.S ; v3(44.96,142.55) 45.01,142.6 45.16,142.6 45.23,142.68 PC12.2 ; v3(130.48,217.18) 130.48,216.75 131.97,215.26 Q129.S ; R214.2 161.04,99.3 v3(161.42,99.68) ; v3(17.2,24.95) 17.27,25.03 D13.A ; PC54.2 103.81,25.66 103.86,25.71 v3(104.01,25.71) R591.2 ; PSWD1.1 152.4,113.14 ; PSWD1.1 151.35,112.08 ; PSWD1.1 151.35,114.19 ; Q20.E 137.52,198.04 137.68,198.21 v3(137.74,198.21) ; 176.02,145.27 176.21,145.46 C832.2 ; Q79.S v3(162.24,22.53) ; C167.1 174.24,93.58 175.69,92.14 175.69,91.93 v3(175.62,91.86) ; v3(120.95,52.03) 120.95,52.5 120.45,53 C260.2 ; R95.2 174.62,195.94 v3(174.24,195.56) 174.88,194.93 C48.2 ; Q48.E 110.43,76.11 109.86,76.69 v3(109.86,76.95) 109.86,77.26 110.49,77.9 R356.2 ; U49.4 95.29,61.62 v3(95.89,62.21) ; C319.2 18.49,29.19 18.47,29.22 v3(18.44,29.22) ; X5.4 v4(97.45,95.46) ; C348.2 37.96,18.6 38.01,18.65 v3(38.66,18.65) 38.79,18.78 39.21,18.78 39.76,19.33 C350.2 ; CPU1.C40 64.61,186.35 v3(64.87,186.62) 64.88,186.62 CPU1.D40 ; v3(9.14,28.18) 9.51,27.81 C711.2 ; v3(42.93,54.31) 42.93,53.81 42.53,53.42 R478.2 C262.2 ; MEMCD1.3 185.4,150.81 185.04,150.45 v3(184.61,150.45) 184.12,150.45 183.84,150.73 183.83,150.73 C105.2 ; PC47.2 88.09,37.63 v3(87.93,37.78) ; R423.2 53.07,67.6 v3(53.77,67.6) 53.91,67.46 C239.2 ; C303.2 17.65,33.89 17.91,34.15 17.91,34.85 v3(18.1,35.04) 18.03,35.1 17.47,35.1 C297.2 ; C189.2 152.7,96.15 v3(152.2,96.66) ; PR2.2 v3(40.64,148.32) ; v3(154.15,102.22) 153.78,101.85 C154.2 R206.2 ; C258.2 150.22,51.36 Q63.S v3(151.14,51.36) ; 120.75,4.6 USB5.5 ; USB5.5 119.04,6.31 ; USB5.5 122.47,6.31 ; USB5.5 120.75,8.03 ; C36.2 131.13,206.55 v3(131.44,206.23) 131.44,205.93 C43.2 ; v3(36.75,44.48) 36.7,44.54 R497.2 ; RJ1.15 14.09,15.75 ; RJ1.15 12.74,14.4 ; RJ1.15 12.74,17.1 ; 157.1,112.38 158.15,112.38 ; 157.1,112.38 156.04,112.38 ; 157.1,112.38 157.1,113.43 ; v3(124.84,92.06) 124.76,92.06 124.44,92.38 R274.2 ; C305.2 32.98,31.23 34.16,30.04 v3(34.16,29.45) 34.04,29.32 C317.2 ; CPU1.D2 63.55,147.98 v3(63.22,147.98) ; v3(144.5,98.61) 143.98,98.09 R226.2 ; R349.2 119.95,79.48 v4(120.75,78.68) ; v3(103.63,39.35) 103.66,39.32 Q73.S ; Q22.E 178.03,192.78 v3(178.03,193.68) ; CPU1.B38 63.57,184.15 v3(62.72,185) 62.78,185.07 CPU1.B39 ; v3(18.44,29.22) 18.44,28.38 18.75,28.08 D12.A ; v3(18.44,29.22) 18.44,29.56 18.47,29.58 18.47,29.75 19.02,30.31 C863.2 ; v3(18.82,24.29) 18.49,24.62 C338.2 ; PR22.2 35.73,140.6 v3(35.43,140.6) ; v3(122.63,13.94) 122.63,14.19 123.27,14.83 C354.1 ; v3(76.58,140.95) 76.55,140.99 R145.2 ; v5(30.43,80.17) 30.18,80.43 U18.1 ; v5(30.43,80.17) v5(30.43,79.16) v5(29.39,79.16) ; v5(30.43,80.17) v5(29.39,80.17) ; v3(65.97,163.18) 65.52,163.63 CPU1.E18 CPU1.D17 ; C198.2 150.54,84.47 150.72,84.65 ; WEBCM1.9 176.6,227.55 v5(177.16,226.98) ; R560.1 61.47,31.86 v3(62.1,31.23) 62.48,31.61 R561.2 ; R321.2 151.51,82.41 151.46,82.46 151.24,82.46 v4(150.8,82.9) ; v3(39.93,23.83) 40.08,23.68 C344.2 R606.1 38.46,22.32 38.23,22.55 37.97,22.55 R609.1 ; 61.94,10.88 VGA1.17 ; VGA1.17 64.1,8.72 ; VGA1.17 66.25,10.88 ; VGA1.17 64.1,13.04 ; Q70.E 13.84,40.27 v3(13.84,39.55) ; 197,79.93 UHS1.8 198.42,80.95 ; C75.1 20.4,162.98 v3(21.29,162.98) ; R528.2 106.49,41.58 v3(105.83,42.24) 105.06,43.01 Q69.S ; C249.2 87.38,62.98 87.78,62.57 v3(88.24,62.57) ; R963.2 78.51,70.63 R1193.2 ; R280.2 143.38,91.29 143.64,91.55 v3(143.76,91.55) ; v3(71.88,207.25) 72.07,207.44 R58.1 C26.2 ; v3(119.38,227.31) 119.27,227.2 NGFF1.77 ; v3(33.75,66.53) 33.78,66.5 R430.2 ; PC55.2 84.2,22.21 v3(84.84,22.84) ; v3(139.7,19.54) 139.83,19.54 140.62,18.75 SPK1.8 ; PC48.2 v5(88.09,35.47) ; v4(133.1,55.48) 133.54,55.03 C257.2 ; C246.2 v5(28.44,64.63) ; UHS1.7 198,91.17 ; UHS1.7 196.58,90.15 ; UHS1.7 199.42,90.15 ; UHS1.7 198,89.13 ; Q14.E 138.4,209.88 v3(138.68,210.17) ; v3(156.26,90.88) 155.22,89.84 R314.2 154.9,89.82 C183.2 ; v3(150.9,47.99) 150.79,47.88 150.73,47.88 149.99,47.14 C263.2 ; R39.2 v3(18.85,219.06) ; v3(132.89,198.21) 132.11,198.21 Q19.E 132.95,197.09 133.99,197.09 134.33,196.75 R93.2 ; v3(122.2,209.46) C32.2 124.98,208.71 C33.2 ; R249.1 172.31,82.18 v3(172.31,82.09) ; R167.2 13.11,120.63 v3(12.98,120.51) ; v3(34.8,157.21) 35.21,157.62 Q122.S ; PR36.2 50.47,137.35 v3(50.98,136.84) 50.47,136.33 PR38.2 ; ODD1.9 7.62,72.81 ; ODD1.9 7.62,70.32 ; ODD1.9 6.37,71.57 ; ODD1.9 8.87,71.57 ; v3(42.19,132.19) 41.91,132.47 PC17.2 PC18.2 ; C288.2 23.04,39.52 22.19,39.52 v3(22.15,39.48) 22.15,40.12 22.48,40.45 D8.A ; 6.36,137.36 ATX2.2 ; ATX2.2 5.17,138.55 ; ATX2.2 7.55,138.55 ; ATX2.2 6.36,139.74 ; 27.15,15.75 RJ1.16 ; v5(155.45,26.4) 155.07,26.78 C314.2 ; C247.2 119.63,64.63 v3(119.38,64.37) ; C158.1 44.45,98.76 v3(44.32,98.64) ; R400.2 39.88,69.96 v3(39.88,69.9) ; 195.62,110.33 SSUSB2.10 ; SSUSB2.10 195.62,112.57 ; SSUSB2.10 197.49,111.45 ; v3(181.48,93.84) 181.48,94.12 180.91,94.69 C168.2 181.61,95.68 C164.2 ; Q59.E 42.68,60.82 43.05,61.2 v3(43.05,61.71) ; v4(153.38,81.08) 153.35,81.11 R343.2 R342.2 151.33,81.29 150.08,81.29 R335.2 ; D10.1 14.01,33.73 v3(14.1,33.64) ; R231.2 134.97,96.58 135.4,96.58 v3(135.63,96.35) 135.51,96.23 135.51,94.96 R255.2 ; v3(99.44,11.9) 99.44,11.92 99.62,12.1 D14.2 ; 7.62,49.32 HDD1.9 ; HDD1.9 6.37,50.57 ; HDD1.9 8.87,50.57 ; 33.17,23.28 32.84,22.95 32.82,22.95 32.44,22.56 R605.1 C343.2 ; 33.17,23.28 33.5,22.95 C346.2 ; 33.17,23.28 v3(33.17,23.4) ; v3(79.72,180.96) 79.71,180.97 79.68,180.97 CPU1.W35 ; R520.2 152.53,42.85 v3(154.15,44.47) ; C272.2 v3(66.32,45.32) ; 150.72,84.65 150.77,84.6 R307.1 ; 150.72,84.65 v4(150.77,84.65) ; v3(9.12,23.78) 9.65,23.78 10.01,24.14 C708.2 ; v3(29.44,77.96) 29.78,77.62 R362.2 ; PR31.2 50.47,139.38 v3(50.98,138.87) 50.47,138.36 PR33.2 ; v3(88.7,40.22) 88.7,39.66 89.2,39.15 PR85.2 ; C129.2 v3(11.35,107.04) ; PR24.2 50.47,141.41 v3(50.98,140.9) 50.47,140.4 PR26.2 ; v3(63.75,19.39) 63.35,19.79 R614.1 ; v3(18.99,205.41) 18.99,205.82 19.3,206.13 C37.2 ; C9.2 91.57,229.8 v3(91.44,229.93) 91.31,229.93 91.04,229.66 C8.2 ; C44.2 162.69,198.84 164.21,200.36 v3(164.62,200.36) ; v3(176.68,151.52) 176.3,151.14 R139.2 ; v3(114.05,9.13) 113.55,9.62 C357.2 112.33,9.62 C358.1 ; D15.2 v3(125.4,10.58) ; C753.2 93.19,68.82 v3(93.5,68.51) ; PC34.2 v3(148.92,98.02) ; v3(59.18,27.73) 59.31,27.86 C342.2 60.01,27.92 C335.1 ; SRCON1.4 v3(136.34,102.3) ; C321.2 105.51,28.69 v3(105.97,29.14) ; WEBCM1.8 163.25,224.65 v3(163.25,223.3) 162.71,223.3 162.19,223.82 PC2.1 ; 39.11,8.72 VGA1.16 ; VGA1.16 36.95,10.88 ; VGA1.16 39.11,13.04 ; VGA1.16 41.26,10.88 ; C398.2 105.28,245.98 v3(104.62,245.32) ; R218.2 125.26,99.56 125.43,99.73 v3(125.43,99.81) ; C259.2 v3(116.2,52.31) 117.18,51.34 X3.2 ; ODD1.8 8.87,84.53 ; ODD1.8 7.62,85.78 ; ODD1.8 6.37,84.53 ; SPK1.5 141.61,22.3 143.28,20.63 143.47,20.63 v5(143.98,20.13) 144.15,20.3 C326.2 C327.2 ; C793.2 C792.2 72.58,72.18 C788.2 v4(73.28,70.52) ; v3(152.79,30.39) 152.72,30.46 C240.2 150.5,30.46 C316.2 ; R475.2 142.18,45.69 v3(141.6,45.12) ; USB6.5 133.65,8.03 ; USB6.5 133.65,4.6 ; USB6.5 131.93,6.31 ; USB6.5 135.36,6.31 ; R424.2 149.22,32.75 149.99,31.99 v3(149.99,31.61) ; Q49.S v3(196.24,72.89) ; U1.1 135.94,217.97 v3(136.09,217.81) 136.09,217.26 135.53,216.7 U1.2 ; R18.2 97.4,229.99 v3(97.79,229.6) ; R1193.2 79.34,70.41 v4(79.53,70.6) ; R1193.2 R1185.2 ; C755.2 111.95,75.23 v3(111.63,74.91) ; C178.2 v3(4.72,90.53) 4.72,90.2 5.08,89.85 C182.2 ; C785.2 C789.2 69.66,72.18 C787.2 v4(68.96,70.49) ; R296.2 147.76,93.1 C188.2 147.02,92.78 v4(146.66,92.42) ; v3(138.24,217.08) 138.62,216.7 U1.7 ; v3(129.39,47.2) 129.51,47.2 129.9,46.81 C270.2 ; R471.1 150.69,45.51 v3(150.88,45.32) R474.2 ; R1190.2 R1191.2 100.71,89.01 v3(101.09,88.63) ; C130.2 159,104.3 v3(158.8,104.1) ; C19.2 143.29,216.75 145.01,216.75 U2.4 145.29,218.25 144.68,218.86 v3(144.68,219.54) ; v3(119.38,105.01) 119.38,105.33 119.98,105.93 121.19,105.93 PC25.2 ; R217.2 130.7,97.95 v3(131.5,97.95) 131.5,98.79 130.73,99.55 C160.2 ; R443.2 v3(138.45,58.15) ; v3(50.98,134.81) 50.47,135.32 PR40.2 ; v3(37.97,23.83) 37.9,23.75 R609.1 ; v3(151.64,21.04) 150.98,21.7 C313.2 ; U2.2 147.83,218.91 147.08,219.66 v3(147.08,220.05) ; R282.1 122.61,90.43 v3(123.55,90.43) ; C165.2 177.25,97.13 C161.2 176.45,97.33 174.76,97.33 v3(174.6,97.49) ; 155.3,194.51 DIMM1.205 ; v3(39.9,71.1) 39.9,70.98 C229.2 ; R458.2 53.04,56.44 v3(53.04,57.44) ; v3(145.59,157.44) 145.44,157.59 C95.2 ; v3(51.05,58.15) 50.45,58.15 Q60.S ; R455.2 46.74,56.33 47.37,56.96 v3(47.37,57.01) ; 107.85,4.6 USB4.5 ; USB4.5 107.85,8.03 ; USB4.5 109.56,6.31 ; USB4.5 106.13,6.31 ; C345.2 R609.1 ; v3(135.25,202.55) 134.52,201.81 134.52,201.79 R78.2 ; v3(96.6,239.51) 96.61,239.52 R1.2 ; v3(140.89,95.72) 140.89,95.54 140.87,95.52 140.87,94.9 141.13,94.63 R252.2 ; v3(185.06,93.94) 185.09,93.96 185.24,93.96 185.93,94.65 R245.2 ; C347.2 30.56,20.62 30.56,20.99 v3(30.15,21.4) ; v3(17.65,111.74) 17.4,112 16.7,112 R175.2 ; C364.2 106.82,246.17 v3(107.87,245.12) ; R254.2 133.68,94.34 133.02,93.68 133.02,93.58 v3(132.89,93.46) ; v5(137.39,189.34) v5(138.3,189.34) 138.79,188.85 DIMM2.206 ; C311.2 111,29.19 v3(111.51,28.69) 112.04,29.22 R575.2 ; C289.2 R544.2 37.85,37.22 v3(38.48,37.86) ; PR74.1 103.35,68.18 v3(103.35,68.19) PU5.1 ; C215.2 151.19,76 v3(151.25,76.06) ; SSUSB1.11 197.49,119.65 ; SSUSB1.10 197.49,132.45 ; SSUSB1.10 195.62,131.33 ; SSUSB1.10 195.62,133.57 ; v3(110.08,39.49) 109.91,39.32 Q71.S ; v3(36.7,69.5) 36.64,69.44 R412.2 ; v3(101.63,35.65) 101.27,35.29 PR88.2 ; C265.2 v3(127.38,47.9) ; v3(152.15,69.45) 152.25,69.55 153.28,69.55 153.49,69.77 R408.1 ; C304.2 R554.2 ; v4(93.62,93.61) 94.3,94.28 C752.2 ; X4.4 21.46,38.6 20.81,39.24 19.01,39.24 18.97,39.2 v5(18.9,39.2) 18.82,39.2 17.86,38.24 17.86,37.65 17.63,37.42 17.56,37.42 C290.1 ; C121.2 16.51,125.84 v3(17.4,124.95) 17.4,124.7 16.89,124.19 C122.1 ; C108.1 180.59,150.35 181.57,149.38 v3(182.54,149.38) 182.54,150.26 C106.1 ; C228.2 v3(32.26,72.91) ; v4(146.52,152.51) 146.46,152.57 C104.1 C103.2 ; 80.76,237.55 HS3.1 ; HS3.1 87.98,237.55 ; HS3.1 84.37,241.16 ; R555.1 23.42,33.83 C299.2 22.81,33.83 22.03,33.83 21.58,34.28 v3(21.56,34.28) 21.12,34.28 19.94,35.46 X4.2 ; R36.2 117.38,221.28 Q7.E v3(116.78,219.76) ; R519.2 101.22,44.56 102.23,45.58 v3(102.23,45.79) 102.23,45.99 C266.2 ; v3(102.46,50.36) 103.1,51.01 R489.2 ; C25.2 61.47,213.34 v3(61.44,213.32) ; v3(35.66,15.02) 35.46,15.02 35.36,15.12 34.81,15.12 34.62,15.31 C352.2 ; PR86.2 v3(101.83,37.32) ; v3(143.94,213.39) 143.76,213.22 C28.2 ; v3(97.92,213.47) 97.92,215.15 BT1.2 ; U2.7 v3(147.83,210.59) ; PC26.2 130.12,104.96 v3(130.12,104.74) 130.1,104.71 130.1,103.58 PR68.2 ; C351.2 33.62,19.44 C349.2 33.59,18.98 33.66,18.91 v3(33.66,18.58) ; v3(150.5,63.1) 150.37,63.23 150.37,63.86 150.01,64.22 C866.1 ; C127.2 145.73,109.97 v3(146.81,108.89) ; C232.2 121.32,71.17 122.05,71.9 v3(122.05,72.14) ; H1.1 54.15,126.4 ; H1.1 50.8,123.05 ; H1.1 57.5,123.05 ; v3(18.24,116.01) 17.96,116.29 16.71,116.29 Q38.E ; C226.2 v3(39.9,71.87) ; U21.4 158.01,64.91 v3(157.43,64.32) 156.69,64.32 156.55,64.18 C248.1 ; R51.2 C20.2 v3(60.83,215.61) ; PR7.2 v3(51,146.11) ; C50.2 181.99,186.42 v3(181.99,187.18) 182.53,187.18 183.01,187.66 R101.2 R102.2 ; C250.2 136.44,58.18 v3(136.75,57.88) ; v3(164.85,20.81) 164.15,20.11 Q83.S ; v3(10.54,30.57) D11.1 ; Q72.S v3(111.68,39.32) ; Q121.S 41.77,156.38 v3(41.78,156.37) ; CPU1.D15 64.59,160.92 v3(64.12,160.45) ; C113.2 27.81,154.59 v3(27.76,154.54) C735.2 ; v3(12.7,116.44) 13.21,116.95 C124.2 13.78,117.55 13.75,117.57 C123.2 ; R552.2 v3(136.06,33.59) 136.55,33.1 Q76.S ; 5.68,20.55 TOUCH1.2 ; v3(182.37,97.39) 182.94,96.82 C162.1 ; C307.2 v3(134.54,33.41) ; C756.2 94.04,96.31 v4(93.73,96.63) ; v3(146.81,208.34) 146.8,208.33 C31.2 ; 8.17,141.55 ATX2.7 ; ATX2.7 9.36,142.74 ; ATX2.7 10.55,141.55 ; X3.4 v3(119.59,48.75) ; v3(24.56,41.03) 24.59,41 C284.2 ; C291.2 104.98,35.85 105.13,35.7 C293.2 105.49,35.54 v3(106.22,34.81) ; R543.1 41.1,37.69 v3(41.1,38.16) ; R433.2 51.49,62.29 v3(52.07,61.71) ; v3(165.02,223.3) 165.75,224.02 WEBCM1.6 ; C312.2 15.86,29.65 15.86,28.89 16.35,28.41 v3(16.5,28.41) ; v3(63.1,149.36) 63.68,149.95 CPU1.C3 ; X5.2 v4(100.58,98.82) ; v3(36.78,150.35) 37.46,151.03 Q118.S ; Q62.1 144.65,50.88 v3(144.65,50.4) ; R233.2 117.01,97.18 117.01,97.22 v3(117.95,98.16) 118.53,97.58 R236.2 ; v3(94.08,233.85) 94.18,233.96 Q3.S ; Q68.E 15.78,44.91 v3(15.58,45.11) ; C264.2 141.17,50.49 141.17,50.4 v3(141.25,50.33) ; v3(24.1,24.29) 23.85,24.55 23.85,24.92 23.83,24.95 U28.2 ; R63.2 v3(68.14,210.74) R64.2 ; v3(123.57,95.74) 123.47,95.64 123.3,95.64 122.95,95.3 R243.2 ; v3(40.26,33.38) 40.82,32.83 Q74.4 ; v4(174.19,148.54) C110.2 ; v3(111.87,61.58) 112.34,62.05 PC38.1 ; C276.2 v3(102.38,43.65) ; R4.2 v3(96.65,236.36) ; C205.2 155.75,88.73 v3(156.34,88.15) ; v4(146.54,162.22) 146.41,162.35 C79.1 ; v3(149.66,219.14) 149.1,218.58 U2.1 ; Q36.E 22.84,150.15 v3(22.15,150.15) ; v3(26.52,142.4) 26.28,142.16 26.25,142.19 C732.2 ; R387.1 165.1,71.99 166.24,73.14 v3(166.24,74.53) ; v3(191.01,116.32) D6.2 ; v3(139.49,58.15) R444.2 ; C7.2 v3(89.61,231.72) ; PR84.2 v3(101.83,39.35) ; PR3.2 v3(43.71,148.21) ; R1149.2 v3(34.28,154.77) ; v3(194.54,73.94) 193.76,73.94 C219.2 ; PC32.2 v3(128.96,101.69) ; v3(71.73,141.56) 72.32,140.97 R146.2 R147.2 ; v3(63.25,28.56) 63.32,28.64 63.64,28.64 63.72,28.71 64.03,28.71 64.07,28.75 C322.2 ; 15.49,146.59 15.91,146.17 C116.2 ; 15.49,146.59 v3(14.3,146.59) ; C38.2 67.97,207.9 v3(67.63,208.24) ; v3(24.77,44.56) 24.77,44.33 25.07,44.03 C282.2 ; Q15.E 135.49,204 v3(135.25,204) ; C353.2 34.74,17.29 34.78,17.26 v3(35.33,17.26) ; Q119.S 32.1,150.55 v3(33.1,151.55) 33.85,150.8 Q120.S ; C172.2 129.49,92.5 129.4,92.59 v3(128.65,92.59) ; R871.2 155.69,84.03 155.1,84.03 154.61,84.52 154.61,84.71 v3(154.39,84.92) 154.2,85.11 C191.2 ; v4(131.19,80.4) 131.22,80.4 ; v3(133.02,92.62) 133.79,92.62 C173.2 ; Q67.E v3(14.01,45.07) ; R1137.2 v3(29.24,159.88) ; R509.1 v3(126.84,44.38) ; C308.2 63.28,31.95 63.28,31.39 v3(63.12,31.23) ; R163.2 v3(93.09,124.55) ; R1207.2 v3(74.3,68.56) ; Q85.3 v3(70.15,15.9) ; R1206.2 v3(75.31,68.44) ; C21.2 141.67,212.1 v3(141.88,212.1) ; C341.2 134.06,24.22 R601.2 134.44,23.83 v3(135.2,23.83)
  L3 w0.508: SSUSB1.11 197.49,119.65 ; SSUSB1.11 195.62,118.53 ; SSUSB1.11 195.62,120.77 ; 193.75,132.45 SSUSB1.10 ; SSUSB1.10 195.62,131.33 ; SSUSB1.10 195.62,133.57 ; SSUSB1.10 197.49,132.45 ; 198,89.13 UHS1.7 ; UHS1.7 199.42,90.15 ; UHS1.7 196.58,90.15 ; UHS1.7 198,91.17 ; 193.75,98.65 SSUSB2.11 ; SSUSB2.11 195.62,99.77 ; SSUSB2.11 197.49,98.65 ; SSUSB2.11 195.62,97.53 ; 195.62,110.33 SSUSB2.10 ; SSUSB2.10 195.62,112.57 ; SSUSB2.10 197.49,111.45
  L4 w0.127: 143.64,51.11 143.64,54.72 144.53,55.61 144.53,55.99 v3(144.2,56.32) ; v3(84.84,22.84) 84.92,22.76 85.79,22.76 88.61,25.57 98.56,25.57 101.32,28.33 107.74,28.33 111.98,32.57 117.99,32.57 122.27,36.85 134.32,36.85 135.4,37.94 135.4,41.38 135.4,41.38 135.4,44.7 135.88,45.18 135.88,48.89 136.53,49.54 136.53,57.66 v3(136.75,57.88) 137.02,58.15 v3(138.45,58.15) v3(139.49,58.15) 139.67,57.97 139.67,55.94 139.07,55.34 139.07,55.04 v3(139.08,55.04) 139.08,46.16 139.06,46.14 138.88,45.96 138.88,44.33 138.02,43.47 138.02,36.97 134.54,33.49 v3(134.54,33.41) 134.51,33.37 127.28,33.37 126.34,34.31 124.87,34.31 120.59,30.03 115.11,30.03 110.17,25.09 104.64,25.09 v3(104.01,25.71) 102.3,25.71 99.99,23.4 99.62,23.03 89.68,23.03 86.84,20.19 80.63,20.19 79.95,20.86 74.3,20.86 73.47,20.04 65.32,20.04 64.95,20.41 64.95,20.41 63.37,21.99 63.37,22.01 61.67,23.71 56.29,23.71 56.13,23.56 55.81,23.56 55.52,23.26 55.47,23.26 54.9,22.69 47.25,22.69 46.68,23.26 42.23,23.26 41.76,23.73 40.03,23.73 v3(39.93,23.83) 38.47,23.83 38.46,23.83 v3(37.97,23.83) 37.74,23.83 37.05,23.14 35.95,23.14 35.67,23.41 35.67,24.95 37.25,26.53 42.88,26.53 43.54,25.87 46.08,25.87 46.14,25.8 47.1,25.8 47.91,26.62 48.07,26.62 48.41,26.96 49.43,26.96 49.71,27.24 v3(53.82,27.24)
  L4 w0.508: H2.8 148.83,13.26 ; H2.8 148.04,12.47 ; H2.8 148.83,11.68 ; SSUSB2.11 197.49,98.65 ; SSUSB2.11 193.75,98.65 ; SSUSB2.11 195.62,99.77 ; SSUSB2.11 195.62,97.53 ; 196.58,90.15 UHS1.7 ; UHS1.7 198,89.13 ; UHS1.7 198,91.17 ; UHS1.7 199.42,90.15 ; H2.4 151.01,13.87 ; H2.4 150.22,14.66 ; H2.4 149.44,13.87 ; H2.7 151.01,8.28 ; H2.7 149.44,8.28 ; H2.7 150.22,7.49 ; 182.22,70.47 H11.5 181.43,71.26 ; 185.8,76.84 H11.7 185.02,77.63 ; 182.22,77.63 H11.2 181.43,76.84 ; 195.62,118.53 SSUSB1.11 ; SSUSB1.11 197.49,119.65 ; SSUSB1.11 195.62,120.77 ; SSUSB1.10 195.62,133.57 ; SSUSB1.10 195.62,131.33 ; SSUSB1.10 197.49,132.45 ; H2.5 153.02,14.66 ; H2.5 153.8,13.87 ; H2.5 152.23,13.87 ; 180.83,71.86 H11.6 180.04,72.65 ; H2.1 154.41,10.47 ; H2.1 155.2,9.68 ; H2.1 154.41,8.89 ; 180.83,76.23 H11.1 180.04,75.45 ; H2.2 153.8,8.28 ; H2.2 152.23,8.28 ; H2.2 153.02,7.49 ; 198.42,80.95 UHS1.8 197,79.93 ; 148.04,9.68 H2.3 ; H2.3 148.83,10.47 ; H2.3 148.83,8.89 ; 185.8,71.26 H11.4 185.02,70.47 ; 187.2,72.65 H11.8 186.41,71.86 ; H2.6 155.2,12.47 ; H2.6 154.41,13.26 ; H2.6 154.41,11.68 ; 195.62,110.33 SSUSB2.10 ; SSUSB2.10 195.62,112.57 ; SSUSB2.10 197.49,111.45 ; 186.41,76.23 H11.3 187.2,75.45
  BOTTOM w0.127: MEM2.M1 56.28,82.05 56.73,82.05 57.15,82.47 57.15,83.26 56.69,83.73 56.68,83.73 v4(56.67,83.73)
  BOTTOM w0.203: U37.6 131.9,206.69 v3(131.44,206.23) ; v3(58.63,74.66) 57.76,73.79 57.33,73.79 57.1,73.56 MEM4.A9 ; MEM4.B3 50.77,73.97 49.96,73.97 MEM2.B9
  BOTTOM w0.279: XDPC1.14 v3(60.36,241.66) ; v3(61.85,241.72) 61.86,241.71 XDPC1.8 ; XDPC1.13 v3(60.36,232.04) ; XDPC1.26 v3(57.36,241.66) ; XDPC1.59 v3(48.86,232.04) ; XDPC1.7 v3(61.86,232.04) ; XDPC1.1 v3(63.36,232.04) ; XDPC1.49 v3(51.36,232.04) ; XDPC1.38 v3(54.36,241.72) ; XDPC1.32 v3(55.86,241.74) ; XDPC1.37 v3(54.36,232.04) ; XDPC1.50 v3(51.36,242.05) ; XDPC1.19 v3(58.86,232.04) ; XDPC1.25 v3(57.36,232.04) ; XDPC1.20 v3(58.86,241.66) ; XDPC1.2 v3(63.36,241.66) ; XDPC1.31 v3(55.86,232.04)
  BOTTOM w0.305: MEM2.P1 56.44,83.96 v4(56.67,83.73) ; MEM1.T1 49.35,93.62 v4(49.08,93.88) ; U17.6 19.39,226.38 U17.9 ; v3(144.75,95.87) 145.24,96.35 QF1.1 ; U38.9 19.37,203.88 U38.6 ; v4(56.54,100.76) 56.48,100.82 MEM1.G9 ; MEM4.E1 49.51,76.76 49.16,76.41 v4(49.01,76.41) 49.45,75.96 MEM4.D1 ; MEM1.P1 49.44,95.22 v4(49.07,95.59) ; v4(49.96,83.56) 49.56,83.95 MEM2.P9 ; v4(49,96.78) 49.04,96.82 MEM1.M1 ; MEM3.D8 50.36,103.17 50.25,103.05 50.25,102.53 MEM1.E2 MEM3.F9 49.45,101.73 49.45,101.79 49.13,102.11 48.89,102.11 v4(48.63,102.38) ; v4(55.56,77.96) 55.16,78.35 MEM4.G8 ; v4(55.56,77.96) MEM2.G1 ; v4(55.56,77.96) 55.96,77.56 MEM4.F9 ; MEM2.J2 55.16,79.96 v4(54.77,79.56) ; v4(50.78,76.36) 50.39,76.76 MEM2.E8 ; v4(55.55,85.18) 55.56,85.18 55.94,85.56 MEM2.T1 56.71,85.56 57.96,86.82 58.8,86.82 59.22,86.39 C583.2 ; MEM2.G9 49.51,78.36 49.12,77.98 v4(49.07,77.98) ; MEM3.B3 54.36,104.85 53.82,105.4 v4(53.82,105.67) ; v4(49.16,73.94) 49.16,73.96 MEM2.B9 ; v4(48.97,82.47) 49.08,82.36 MEM2.M9 ; v4(48.57,100.84) 48.87,100.84 48.88,100.82 MEM1.G1 MEM3.G8 ; MEM3.E1 55.86,102.32 55.27,102.32 MEM1.E8 ; Q104.1 60.94,41 61.38,41 61.83,41.46 61.83,42.66 62.23,43.05 v3(62.64,43.05) ; MEM2.E2 55.16,76.75 v4(55.56,76.35) 55.17,75.96 MEM4.D8
  BOTTOM w0.356: MEM1.M9 56.61,96.82 v4(56.62,96.81) ; MEM2.T9 49.56,86.31 v4(49.61,86.36) ; MEM1.P9 55.57,95.62 v4(55.55,95.62) ; v4(56.96,74.52) 56.85,74.41 56.01,74.41 MEM2.B1 ; v4(49.96,99.63) 50.36,99.22 MEM1.J2 ; MEM3.E1 56.45,102.42 v4(56.65,102.63) 56.3,102.99 56.2,102.99 MEM3.D1 ; MEM1.B1 49.55,104.82 49.45,104.92 49.15,104.92 v4(49.05,105.02) ; v4(54.76,98.82) MEM1.J8 ; MEM2.J8 50.36,79.96 v4(50.76,80.36) ; v4(56.75,104.73) 56.66,104.82 MEM1.B9 ; v4(55.58,94.03) 55.58,94 MEM1.T9 55.97,93.62 57.28,92.31 57.28,91.61 C554.2 ; MEM3.A9 49.19,105.62 49.09,105.72 v4(49.01,105.72) ; v4(136.47,71.82) 136.46,71.83 C636.2
  BOTTOM w0.406: v3(176.39,158.2) 176.39,157.57 R827.1 ; C591.2 148.82,84.06 149.41,84.65 v4(150.77,84.65) ; v3(62.64,43.05) 62.81,42.87 Q104.4 ; Q86.4 5.99,243.93 v3(6.05,243.87) ; Q101.1 134.22,46.61 134.62,46.21 v3(134.62,46.08) ; Q87.1 4.51,241.62 v3(4.01,241.13) ; v3(53.42,37.75) 53.26,37.6 Q110.1 52.52,36.58 52.3,36.36 52.3,35.66 52,35.37 51.95,35.37 51.86,35.27 Q110.4
  BOTTOM w0.508: C781.2 C779.2 84.44,89.65 C819.2 83.76,89.89 v4(83.06,90.59) ; C699.2 33.66,33.59 v3(34.11,33.13) 34.67,33.69 R1070.2 34.73,34.02 C702.2 ; C831.2 165.44,186.66 v4(165.79,187) ; 27.15,15.75 RJ1.16 ; RJ1.16 28.49,17.1 ; RJ1.16 28.49,14.4 ; U43.2 36.73,22.06 36.13,21.46 36.13,21.29 33.83,19 33.83,18.91 33.66,18.73 v3(33.66,18.58) ; C666.2 141.8,45.32 v3(141.6,45.12) ; ODD1.1 8.12,82.77 ; ODD1.1 7.21,81.86 ; ODD1.1 9.04,81.86 ; 195.62,131.33 SSUSB1.10 ; SSUSB1.10 197.49,132.45 ; SSUSB1.10 195.62,133.57 ; R776.2 74.3,202.29 v3(74.17,202.42) 74.3,202.55 R754.2 ; C401.2 112.29,218.42 111.58,219.14 v3(111.48,219.14) ; v3(24.18,242.43) 24.16,242.45 R655.2 R657.2 ; C834.2 160.35,148.79 160.35,147.91 v4(160.4,147.86) R847.2 ; C696.2 58.66,35.91 58.66,35.86 57.51,34.71 v3(57.51,33.82) 56.09,33.82 Q113.S ; C695.1 48.72,37.63 v3(48.51,37.83) ; R734.2 76.33,206.99 v3(76.2,207.12) R721.2 ; 80.76,237.55 HS3.1 ; HS3.1 84.37,241.16 ; HS3.1 84.37,233.94 ; HS3.1 87.98,237.55 ; C870.2 144.64,73.91 v4(144.47,73.74) ; v5(115.32,35.29) 115.57,35.54 R1066.2 ; C723.2 33.75,22.57 33.17,23.15 v3(33.17,23.4) 32.11,23.4 31.62,22.92 C722.2 ; C646.2 137.31,66.15 136.83,65.67 v4(136.78,65.67) 136.32,65.21 C651.2 ; v3(158.41,62.57) 158.13,62.29 C660.2 ; R699.1 v3(49.07,227.03) ; C450.2 159.01,155.75 v4(159.2,155.94) ; v3(56.13,50.02) 56.13,51.04 55.74,51.43 C668.1 ; 119.04,6.31 USB5.5 ; USB5.5 120.75,4.6 ; USB5.5 120.75,8.03 ; USB5.5 122.47,6.31 ; v4(126.42,86.76) 126.67,86.76 127.12,87.2 R939.2 R938.2 ; C729.2 172.31,82.46 v3(172.31,82.09) 172.4,82 C584.2 ; C390.2 v3(10.92,231.1) ; v4(135.6,73.43) 135.6,73.4 134.63,72.43 134.52,72.43 134.33,72.24 C639.2 C632.2 ; 6.37,71.57 ODD1.9 ; ODD1.9 7.62,72.81 ; ODD1.9 8.87,71.57 ; ODD1.9 7.62,70.32 ; D20.1 14.92,34.46 v3(14.1,33.64) 14.03,33.58 D21.1 ; v4(140.59,69.2) 140.89,68.89 140.89,68.73 C868.1 ; C455.2 146.9,152.13 v4(146.52,152.51) ; C453.2 163.31,154.86 v3(162.6,155.57) 163.03,156 C448.2 ; R723.2 72.01,207.37 v3(71.88,207.25) 72.01,207.12 R736.2 ; C638.2 138.3,71.38 v4(137.72,70.81) ; R990.2 139.97,64.8 139.42,65.35 v4(139.42,65.68) 138.74,65 138.5,65 C650.2 ; R1205.2 80.14,77.39 79.44,78.09 v4(79.44,79.1) ; C365.2 20.57,246.66 v3(20.57,247.25) ; v4(128.14,82.94) 127.4,82.2 C599.2 127.06,82.22 C598.2 ; C704.2 131.83,33.47 131.83,34.4 v3(131.7,34.53) 131.42,34.25 130.48,33.31 R1079.2 ; U41.9 131.72,113.09 U41.2 ; v3(151.66,98.79) 151.84,98.79 C515.2 ; R977.2 123.34,74.54 v4(122.94,74.95) 123.57,75.58 R973.2 ; v3(15.82,184.21) 15.39,184.21 15.37,184.24 R804.2 14.68,184.3 C421.2 ; v5(18.9,39.2) 18.9,39.16 18.17,38.42 Q107.S 18.16,38 C692.2 C693.2 ; v3(182.54,149.38) 182.69,149.53 C461.2 ; VGA1.16 41.26,10.88 ; VGA1.16 36.95,10.88 ; VGA1.16 39.11,8.72 ; VGA1.16 39.11,13.04 ; Q91.S v3(116.78,217.79) ; HDD1.9 8.87,50.57 ; HDD1.9 6.37,50.57 ; HDD1.9 7.62,51.81 ; 93.24,6.31 USB3.5 ; USB3.5 96.67,6.31 ; USB3.5 94.95,4.6 ; USB3.5 94.95,8.03 ; C370.1 21.39,245.46 v3(21.69,245.77) ; v3(49.15,50.4) 48.92,50.63 C670.1 ; 7.21,74.24 ODD1.7 ; ODD1.7 8.12,73.32 ; ODD1.7 9.04,74.24 ; v3(127.76,93.96) 128.02,94.22 128.02,94.6 128.52,95.11 R892.2 R891.2 R890.2 R889.2 ; v4(79.53,70.6) 79.76,70.82 R304.2 ; C389.2 v3(25.53,232.77) ; v4(138.2,79.11) 137.59,79.11 137.11,78.63 C609.2 ; C471.2 150.69,126.6 v4(150.75,126.6) ; v3(25.78,24.67) 25.78,24.67 25.78,24.88 25.53,25.13 C709.2 ; R978.2 123.67,72.14 v3(122.05,72.14) 123.24,73.34 R980.2 ; R654.2 R660.2 106.18,240.97 v3(106.27,240.88) ; 131.93,6.31 USB6.5 ; USB6.5 133.65,4.6 ; USB6.5 135.36,6.31 ; USB6.5 133.65,8.03 ; C392.2 19.3,231.7 v3(19.3,230.87) ; v3(7.21,233.97) 7.21,234.17 7.23,234.18 Q89.E ; R760.2 130.96,201.91 v3(130.71,202.17) ; C600.2 153.16,81.08 v4(153.38,81.08) ; C703.2 21.98,33.87 v3(21.56,34.28) ; C694.2 11.62,36.12 v3(11.3,36.43) ; C560.2 176.56,91.56 C550.2 175.87,91.6 v3(175.62,91.86) ; v3(62.74,37.45) 62.04,37.45 C685.2 R1041.2 ; v3(103.63,39.35) 104.33,40.05 R1055.2 ; v3(135.25,202.55) 135.25,202.42 134.75,201.91 R759.1 ; C688.2 32.73,38.27 v3(32.11,38.9) ; R765.2 v3(85.07,200.26) ; USB4.5 107.85,8.03 ; USB4.5 107.85,4.6 ; USB4.5 109.56,6.31 ; USB4.5 106.13,6.31 ; Q98.S 34.04,66.82 v3(33.75,66.53) ; R1029.2 v3(44.42,43.33) 44.3,43.45 C678.1 ; C372.2 v3(13.77,242.71) ; C333.1 9.22,28.25 v3(9.14,28.18) ; C654.2 135.59,63.35 v4(135.58,63.36) ; R861.1 160.27,101.65 160.57,101.94 v3(160.91,101.94) ; v3(126.06,101.66) 125.9,101.5 R318.2 ; C446.2 188.11,157.72 v3(188.34,157.95) 187.69,158.61 C445.2 ; R858.2 137.08,113.47 137.59,112.96 v3(137.67,112.96) 137.16,112.46 C481.2 ; v3(23.69,245.81) 23.69,245.21 23.67,245.19 C369.2 ; R1042.2 40.88,40.54 40.13,41.28 v3(40.03,41.28) ; v4(132.03,77.1) 132.03,77.15 132.37,77.49 C613.2 ; 198,89.13 UHS1.7 ; UHS1.7 198,91.17 ; UHS1.7 196.58,90.15 ; UHS1.7 199.42,90.15 ; v3(125.43,215.83) 125.93,215.83 126.64,215.12 R713.2 ; R1075.2 51.88,33.69 51.53,34.05 51.53,34.07 v3(51.42,34.17) ; v3(62.23,200.09) 62.23,200.09 R768.2 ; 9.04,78.05 ODD1.4 7.21,78.05 ; v3(51.49,246.49) 51.63,246.49 R640.2 ; C172.2 129.49,92.5 129.4,92.59 v3(128.65,92.59) ; C671.1 46.52,50.24 v3(47.12,49.64) ; PC67.2 v3(100.63,45.4) ; v3(53.42,37.75) 53.11,37.75 52.51,38.35 R1052.2 ; C776.2 62.61,91.61 C559.2 R924.1 62.67,92.86 61.44,94.09 v4(60.63,94.09) ; C778.2 75.5,83.01 v4(75.42,83.09) ; C552.2 C551.2 145.89,91.74 146.43,92.29 146.53,92.29 v4(146.66,92.42) 147.01,92.77 147.08,92.77 C539.2 ; R119.2 C84.2 18.29,149.56 17.7,150.15 v3(17.32,150.15) 17.22,150.05 17.22,149.36 R822.2 ; v3(18.54,118.86) 18.36,118.68 C479.2 ; Q105.E v3(52.69,41.07) ; Q90.S 112.93,224.87 R700.2 110.3,223.57 v3(109.73,223) ; 195.62,97.53 SSUSB2.11 ; SSUSB2.11 197.49,98.65 ; SSUSB2.11 193.75,98.65 ; SSUSB2.11 195.62,99.77 ; 57.85,16.16 HDMI1.22 ; v3(138.45,58.15) 138.67,58.37 C662.2 138.58,59.19 138.28,59.19 137.46,60.01 C659.2 ; C810.2 76.33,91.52 76.58,91.77 76.58,91.97 C768.2 ; 64.1,8.72 VGA1.17 ; VGA1.17 61.94,10.88 ; VGA1.17 64.1,13.04 ; R987.2 128.01,67.1 v4(128,67.12) ; C602.2 44.84,81.76 v3(44.32,82.28) 44.74,82.7 R951.1 ; C705.2 42.34,32.57 42.77,32.14 v3(43.15,32.14) 43.57,32.14 C706.2 44.06,32.67 R1072.1 ; v3(53.63,246.47) 54.06,246.47 C367.2 ; v4(139.04,71.85) 139.12,71.85 139.76,72.48 C633.2 ; C767.2 74.4,79.8 v4(74.54,79.94) ; Q99.S 137.73,51.86 138.81,52.94 138.81,54.72 139.06,54.97 139.06,55.03 v3(139.08,55.04) 139,55.04 138.32,55.72 C665.2 ; R394.2 C227.1 v4(91.91,89.18) ; C454.2 159.01,154.54 v4(159.14,154.42) ; v3(50.52,246.48) 51.31,245.69 R641.2 ; C829.2 88.46,84.72 C827.2 88.57,83.82 v4(89.15,83.82) 89.59,84.26 R1210.1 C558.2 ; v4(78.26,88.86) 78.14,88.74 C808.2 78.14,87.17 v4(78.28,87.03) ; R1209.2 v3(115.82,243.44) ; v3(21.84,24.34) 21.84,24.94 C717.2 22.23,25.32 C716.2 ; v4(173.81,127.02) 173.27,127.02 C473.2 ; C384.2 v3(25.72,235.12) ; v3(48.47,246.5) 48.77,246.2 R643.1 ; v3(161.93,153.65) 162.75,152.83 C457.2 ; v3(151.43,93.06) 150.86,92.48 C545.2 ; v3(130.81,93.46) R915.2 ; R635.2 v3(24.75,246.31) ; v3(87.93,37.78) PC69.2 88.93,37.75 PC70.2 ; Q126.E 17.21,28.41 v3(16.5,28.41) ; v4(71.24,80.85) 71.19,80.81 C772.2 69.08,80.81 v4(68.64,81.24) ; C619.2 135.53,75.13 v4(135.62,75.04) 135.64,75.01 C628.2 ; C664.2 144.61,56.74 v3(144.2,56.32) ; v4(139.15,73.01) 138.8,73.36 C631.2 ; v4(91.82,91.8) 91.66,91.97 C593.1 R948.2 89.88,91.97 89.43,91.52 89.43,91.45 C780.2 ; v3(18.03,246.11) 18.03,245.6 18.16,245.47 C371.2 ; Q114.E 24.07,29.18 v4(23.85,29.4) ; ODD1.8 8.87,84.53 ; ODD1.8 7.62,83.28 ; ODD1.8 6.37,84.53 ; v3(8.97,241.77) 8.98,241.78 R653.2 ; C625.2 133.99,75.8 v4(133.94,75.85) ; C430.2 163.69,163.37 v4(162.79,162.47) 163.03,162.23 C436.1 ; v3(63.25,28.56) 63.56,28.88 C713.2 ; C768.2 76.72,92.11 C769.2 C770.2 ; C768.2 76.89,92.08 77.65,91.32 C803.2 78.23,91.13 78.23,91.01 78.25,90.99 v4(78.25,90.59) ; C774.2 71.44,87.76 v4(71.19,87.51) 70.68,87 C775.2 ; v3(44.4,42.48) 44.92,42.48 45.38,42.94 C680.2 ; v4(140.7,63.67) 140.42,63.67 139.6,62.85 139.6,62.34 139.7,62.24 139.7,61.17 C658.2 139.62,61.03 C663.2 ; v4(150.8,82.9) 150.2,82.3 R953.1 ; R802.2 163.77,184.77 164.82,184.77 v4(165.68,183.91) ; R828.2 R829.2 73.85,157.09 73.22,156.45 C452.2 73.22,154.19 v3(73.29,154.06) ; C714.1 54.86,26.46 v3(54.86,25.51) 54.78,25.59 53.08,25.59 52.4,24.92 52.4,23.94 52.79,23.54 C721.1 ; R728.2 67.33,207.95 v3(67.63,208.24) ; v3(27.92,24.64) 27.05,25.51 C712.2 ; v4(165.79,187) 165.79,187.8 R795.2 ; v4(165.79,187) 165.23,187 164.78,187.45 C419.2 ; R936.2 156.26,90.5 v3(156.26,90.88) ; v3(174.27,75.73) 174.5,75.96 D17.A ; v3(35.66,15.02) 35.16,15.52 C726.2 33.96,15.52 C727.2 ; SSUSB1.11 197.49,119.65 ; v3(185.06,93.94) 184.78,93.66 184.78,93.07 185,92.86 Q97.3 ; v3(152.15,69.45) 150.57,71.03 150.57,71.57 R986.2 R981.2 ; C385.2 v3(11.96,234.15) ; v3(59.87,45.96) 59.87,46.52 60.33,46.97 C677.1 60.64,47.16 61.53,48.05 C674.2 ; C606.2 148.52,80.13 v3(148.21,79.82) ; C403.1 v3(13.08,205.27) ; v3(86.36,204.33) 85.22,203.18 R758.2 ; C433.2 157.89,161.25 158.81,160.33 v4(158.81,160.26) 158.49,159.94 C442.2 ; C655.2 146.04,39.14 146.58,39.68 146.58,39.96 v3(146.61,39.99) ; C707.2 v3(132.97,34.53) ; v3(125.53,86.75) 125.53,86.72 125.48,86.67 C579.2 ; D19.A 51.03,46.69 v3(50.77,46.44) ; v4(155.2,185.34) 155.65,185.78 R800.2 157.54,187.82 C418.2 C833.2 ; R914.1 132.07,92.62 132.07,92.71 132.82,93.46 v3(132.89,93.46) ; 54.24,16.22 HDMI1.20 49,16.22 ; v3(15.58,45.11) 15.81,44.88 Q103.S ; C412.2 v3(88.14,202.03) ; R753.2 v3(77.72,202.29) ; C725.2 C724.2 v3(63.75,19.39) ; v3(187.07,114.49) 186.5,115.06 C480.2 R855.2 ; C773.2 71.82,90.05 v4(72.24,90.47) ; R893.2 124.48,95.74 v3(123.57,95.74) ; C394.2 v3(50.09,226.96) ; v4(93.34,88.76) 93.34,88.57 C758.2 C759.2 ; v4(159.13,181.97) 159.19,181.91 C423.2 ; C377.2 v3(8.08,240.39) ; v4(147.29,86.47) 147.29,86.17 147.87,85.59 C578.2 ; C691.1 v3(56.79,37.86) ; C379.2 24.16,238.01 v3(24.23,238.08) ; C823.2 C813.2 82.21,84.27 82.55,83.93 v4(83.12,83.93) ; C645.2 129.03,66.89 v4(128.8,67.12) ; C675.1 57.1,47.91 56.69,47.51 v3(55.83,47.51) 55.83,48.08 R1008.2 ; 7.21,53.24 HDD1.7 ; HDD1.7 9.04,53.24 ; HDD1.7 8.12,52.33 ; C784.2 89.03,87.99 v4(89.15,88.12) ; 132.34,51.8 Q100.S ; v4(76.43,84) 76.52,84.09 C777.2 C805.2 76.3,86.31 C816.2 ; U44.2 v3(41.22,17.99) ; v4(152.32,126.6) 152.32,126.39 152.62,126.09 C472.2 152.59,125.21 C474.2 ; C393.2 v3(21.34,230.74) ; R751.2 v3(81.41,202.42) R775.2 ; v4(116.35,232.8) 116.35,233.24 R1208.2 ; C656.2 147.19,40.27 146.91,39.99 v3(146.61,39.99) ; v3(50.5,50.45) 50.95,50.91 C669.1 ; R859.2 v3(187.02,107.81) ; v3(159.99,61.25) 159.75,61.01 C661.1 ; C402.2 112.01,217.1 111.68,216.77 v3(111.4,216.77) ; LED2.K v3(126.62,31.58) ; v3(110.21,219.44) 110.67,219.9 112,219.9 R708.2 ; R688.2 v3(12.06,231.15) ; v3(146.61,39.99) 146.53,39.99 145.03,41.49 C657.2 ; R752.2 79.63,202.55 v3(79.76,202.42) ; R1069.2 40.36,34.58 v3(40.23,34.71) ; R719.2 79.63,207.37 79.76,207.25 79.76,206.99 v3(79.73,206.97) 79.63,206.87 R732.2 ; R1064.2 v3(54.69,37.73) ; 197,79.93 UHS1.8 198.42,80.95 ; R777.2 72.39,202.24 v3(72.49,202.35) 72.39,202.45 R755.2 ; C441.1 187.9,159.69 v3(188.47,160.26) 188.47,160.38 188.09,160.77 C438.2 ; v3(24.82,31.68) 24.87,31.63 24.87,31.49 C710.2 ; v3(62.64,43.05) 61.91,43.77 R1025.2 ; v3(107.09,230.46) 107.01,230.46 106.3,229.75 C391.2 C399.2 ; 6.37,63.53 HDD1.8 ; HDD1.8 7.62,64.78 ; HDD1.8 8.87,63.53 ; C431.2 146.55,162.23 v4(146.54,162.22) ; C728.2 34.46,13.56 v3(34.85,13.17) ; SSUSB2.10 195.62,112.57 ; SSUSB2.10 195.62,110.33 ; SSUSB2.10 197.49,111.45 ; v3(145.59,157.44) 145.59,156.91 146.94,155.56 C449.2 ; R668.2 v3(7.94,238.96) ; R1058.2 41.1,37.38 v3(41.1,38.16) ; C830.2 87.88,80.17 v4(88.14,79.92) ; R722.2 v3(73.91,207.12) R735.2 ; C548.2 134.16,92.31 133.86,92.62 v3(133.02,92.62) ; C443.2 v4(162.69,160.13) ; 11.74,14.75 RJ1.15 ; C366.2 v3(12.09,246.85) ; C672.1 60.33,50.53 v3(59.69,49.89) 60.33,49.26 C676.1 ; R731.2 v3(81.41,207.12) R718.2 ; v3(17.2,24.95) 17.12,25.03 17.12,25.69 17.45,26.02 C719.1 18.17,26.03 C718.2 ; v4(145.98,86.35) 145.78,86.15 C581.2 ; C416.2 184.35,195.26 184.35,196.5 v3(183.26,197.6) ; Q108.E v3(110.08,39.49) ; v3(77.85,206.99) 77.72,206.87 R733.2 ; 44.37,16.16 HDMI1.21 ; C411.2 65.66,203.44 v3(65.79,203.56) ; R796.2 v3(160.53,189.72) ; C468.2 156.54,147.18 v4(155.85,147.86) 156.25,148.26 C467.2 157.01,148.29 C464.2 ; v4(71.2,92.59) 70.69,92.59 70.21,93.07 C771.2 69.05,93.07 v4(68.32,92.34) ; C395.1 v3(13.09,227.63) ; v4(173.93,182.03) C422.2 ; v4(131.19,70.12) C640.2 ; v4(79.5,75.73) 79.51,75.73 79.71,75.52 79.88,75.52 79.92,75.49 C762.2 ; R877.2 141.49,96.32 v3(140.89,95.72) ; v4(146.67,149.78) 146.74,149.72 C465.2 ; R662.2 v3(24.18,240.17) ; C681.2 v3(49.94,42.66) ; R748.2 v3(137.54,202.65) ; R666.2 v3(24.18,239.02) ; R695.2 v3(54.41,227.03)
  vias: v1(16.38,219.57) v1(23.5,101.84) v1(39.42,88.5) v1(42.85,76.84) v1(67.1,242.47) v1(102.64,58.78) v1(133.2,211.95) v1(134.54,147.74) v1(134.57,115.17) v1(134.67,163.31) v1(142.75,132.06) v1(146.05,116.95) v1(177.14,100.14) v1(180.12,222.18) v1(180.49,155.56) v1(188.21,135.7) v1(192.3,178.04) v2(4.14,67.32) v2(9.22,45.88) v2(11.91,68.13) v2(12.06,82.53) v2(29.62,6.97) v2(31.47,245.04) v2(36.73,235.75) v2(39.01,6.05) v2(43,100.01) v2(70.99,245.86) v2(71.4,26.35) v2(75.08,51.34) v2(81.92,176.39) v2(82.02,164.37) v2(82.78,38.29) v2(87.07,245.32) v2(87.5,7.02) v2(95.4,29.73) v2(98.48,54.85) v2(101.09,6.66) v2(104.85,248.22) v2(113.72,6.56) v2(126.31,6.31) v2(130.81,24.29) v2(134.24,106.69) v2(148.67,99.4) v2(159.74,125.94) v2(176.2,154.14) v2(190.5,70.7) v2(191.31,96.94) v2(193.52,178.27) v2(193.85,174.15) v2(195.5,153.88) v2(195.58,138.54) v2(195.76,115.38) v3(11.23,193.18) v3(11.3,192.39) v3(11.43,214.23) v3(11.43,213.47) v3(11.99,193.18) v3(12.06,192.39) v3(12.19,214.23) v3(12.19,213.47) v3(12.23,48.12) v3(12.23,47.23) v3(13.94,130.13) v3(14.93,198.17) v3(14.93,197.41) v3(14.93,196.01) v3(14.93,195.25) v3(15.11,219.82) v3(15.11,219.06) v3(15.11,217.66) v3(15.11,216.9) v3(15.24,180.07) v3(15.24,179.31) v3(15.31,177.6) v3(15.31,176.84) v3(15.31,175.82) v3(15.31,175.06) v3(16.66,239.1) v3(17.65,239.99) v3(17.65,239.12) v3(17.68,238.19) v3(18.69,239.15) v3(19.01,227.91) v3(19.18,224.9) v3(19.16,202.41) v3(19.77,227.91) v3(19.75,205.41) v3(20.83,207.5) v3(20.83,206.74) v3(22.1,169.02) v3(22.23,165.97) v3(22.86,169.02) v3(27.97,36.28) v3(28.8,131) v3(28.78,37.19) v3(28.78,36.28) v3(28.78,35.49) v3(29.54,131.71) v3(29.59,36.28) v3(30.68,18.22) v3(33.35,45.12) v3(33.55,46.97) v3(34.12,72.29) v3(34.14,27.03) v3(34.29,52.56) v3(34.29,50.91) v3(34.88,72.29) v3(35.64,72.29) v3(36.53,50.5) v3(36.78,42.15) v3(37.24,52.61) v3(38.61,41.42) v3(38.99,54.09) v3(39.88,30.69) v3(44.27,104.28) v3(44.27,103.51) v3(44.32,97.77) v3(44.32,86.6) v3(44.32,85.58) v3(44.27,77.75) v3(44.27,76.86) v3(44.27,75.92) v3(44.27,75.06) v3(44.45,93.57) v3(44.45,92.56) v3(44.45,91.46) v3(44.42,90.4) v3(44.46,94.74) v3(45.87,27.27) v3(47.79,166.9) v3(47.77,165.06) v3(47.77,163.34) v3(48.71,161.34) v3(48.92,158.02) v3(49.31,168.57) v3(50.42,158) v3(57.66,39.23) v3(58.04,162.66) v3(59.05,162.67) v3(59.31,161.69) v3(61.4,168.69) v3(62.33,168.69) v3(63.23,181.87) v3(63.25,168.72) v3(64.15,181.87) v3(64.16,168.69) v3(65.06,182.78) v3(65.06,181.87) v3(65.07,168.69) v3(65.07,167.78) v3(65.09,149.49) v3(65.98,181.87) v3(65.98,167.78) v3(65.98,166.86) v3(66.89,181.87) v3(66.89,166.86) v3(67.81,182.78) v3(67.81,181.87) v3(67.79,165.93) v3(68.72,181.87) v3(68.71,164.12) v3(69.63,181.87) v3(69.63,164.12) v3(69.63,163.21) v3(70.54,181.89) v3(70.55,163.21) v3(70.55,162.29) v3(70.55,161.38) v3(70.55,160.46) v3(70.55,159.55) v3(71.46,181.87) v3(71.46,158.63) v3(72.38,181.87) v3(72.38,180.95) v3(73.29,180.95) v3(73.29,180.04) v3(75.12,180.95) v3(76.95,179.12) v3(77.86,180.95) v3(77.86,180.04) v3(77.86,179.12) v3(78.78,179.12) v3(79.69,179.12) v3(79.83,157.41) v3(80.61,179.12) v3(80.89,147.75) v3(82.55,122.16) v3(83.27,118.47) v3(84.92,120.13) v3(85.85,118.73) v3(88.65,7.22) v3(88.86,175.46) v3(89.26,68.56) v3(95.89,127.75) v3(95.94,38.19) v3(96.65,17.64) v3(97.28,125.59) v3(97.66,236.08) v3(97.66,235.19) v3(97.79,129.78) v3(98.3,89.14) v3(98.32,88.2) v3(98.45,6.11) v3(98.55,126.86) v3(99.69,126.86) v3(99.69,124.32) v3(100.18,129.27) v3(100.33,213.47) v3(100.79,244.59) v3(100.79,243.7) v3(100.89,215.27) v3(101.09,129.27) v3(102.11,129.27) v3(102.46,215.33) v3(103.02,21.63) v3(103.43,244.31) v3(104.27,117.08) v3(104.9,216.9) v3(106.17,85.96) v3(108.34,115.68) v3(108.99,83.8) v3(108.97,83.04) v3(109.09,116.95) v3(109.47,217.53) v3(109.73,114.77) v3(109.73,112.12) v3(111,111.03) v3(111.25,117) v3(111.25,114.41) v3(111.89,206.71) v3(112.04,210.37) v3(112.01,207.48) v3(112.71,114.16) v3(113.28,110.73) v3(113.54,116.19) v3(113.92,204.58) v3(114.95,116.16) v3(115.06,204.61) v3(115.09,203.23) v3(115.19,252.41) v3(116.84,117) v3(116.87,202.5) v3(118.95,252.43) v3(118.95,251.11) v3(118.92,249.01) v3(120.95,199.35) v3(120.98,198.21) v3(121.79,17.76) v3(123.32,215.86) v3(123.34,203.44) v3(123.42,18.78) v3(124.36,215.88) v3(124.38,200.95) v3(124.49,199.07) v3(124.94,20.02) v3(125.15,89.06) v3(126.11,216.9) v3(127.3,20.02) v3(127.53,126.44) v3(127.54,125.2) v3(128.5,216.87) v3(130.02,27.8) v3(130.18,210.55) v3(130.78,27.8) v3(130.94,210.55) v3(131.7,212.2) v3(131.7,211.44) v3(131.7,210.55) v3(131.7,209.79) v3(131.7,209.03) v3(132.59,210.55) v3(132.66,219.59) v3(133.35,210.55) v3(134.65,219.57) v3(135.51,26.15) v3(136.14,7.91) v3(139.52,219.44) v3(140.61,219.44) v3(142.34,101.36) v3(142.35,100.59) v3(142.6,219.57) v3(142.94,38.7) v3(143.12,101.36) v3(143.13,100.59) v3(146.76,99.02) v3(147.68,100) v3(148.84,62.09) v3(151.08,216.9) v3(151.61,219.54) v3(153.52,219.44) v3(154.28,63.67) v3(154.31,61.83) v3(154.46,64.89) v3(155.45,15.35) v3(156.69,37.14) v3(157.99,34.65) v3(158.75,34.65) v3(159.51,36.18) v3(159.51,35.42) v3(159.51,34.65) v3(159.51,33.89) v3(159.51,33.13) v3(160.27,34.65) v3(160.91,102.85) v3(160.91,101.08) v3(161.04,34.65) v3(163.07,4.3) v3(163.17,228.71) v3(165.1,11.03) v3(166.12,31.1) v3(166.12,25.76) v3(166.12,22.08) v3(167.51,8.87) v3(167.64,13.57) v3(174.69,163.74) v3(175.03,160.77) v3(175.06,161.91) v3(175.26,98.28) v3(175.9,98.79) v3(176.68,152.33) v3(176.91,98.03) v3(177.67,98.28) v3(179.32,90.66) v3(179.32,89.77) v3(179.32,89.01) v3(180.21,122.16) v3(180.21,119.49) v3(180.21,89.01) v3(180.52,157.08) v3(180.72,165.21) v3(180.9,192.9) v3(181.1,170.06) v3(181.1,89.01) v3(181.48,158.05) v3(181.48,157.08) v3(181.48,156.12) v3(181.61,120.89) v3(181.74,192.9) v3(181.99,170.06) v3(181.99,168.92) v3(182.45,157.08) v3(182.37,118.6) v3(182.6,192.9) v3(182.65,164.53) v3(182.88,170.06) v3(183.59,168.92) v3(183.77,170.06) v3(183.77,123.05) v3(184.23,224.44) v3(184.26,225.22) v3(184.51,166) v3(185.42,121.65) v3(185.91,100.57) v3(187.71,123.94) v3(187.71,123.17) v3(188.34,98.66) v3(188.59,76.69) v3(191.26,76.06) v3(191.57,95.92) v3(192.02,76.62) v3(192.58,96.73) v3(192.77,95.92) v3(192.79,76.18) v3(193.86,95.36) v3(194.8,95.34) v3(195.45,76.31) v3(196.72,75.17) v3(197.49,76.18) v3(198.25,75.68) v4(67.31,102.98) v4(70.43,103.03) v4(76.6,175.65) v4(76.6,174.96) v4(76.6,173.62) v4(76.6,172.93) v4(76.6,171.58) v4(76.6,170.9) v4(76.6,169.55) v4(76.6,168.87) v4(76.6,167.52) v4(76.6,166.83) v4(76.6,165.49) v4(76.6,164.8) v4(76.6,163.46) v4(76.6,162.77) v4(76.6,161.42) v4(76.6,160.74) v4(76.6,159.39) v4(76.6,158.71) v4(78.23,140.95) v4(78.23,89.82) v4(78.23,83.83) v4(78.29,85.21) v4(78.99,138.92) v4(79.23,83.94) v4(80.02,88.85) v4(80.07,90.85) v4(80.18,175.65) v4(80.18,174.96) v4(80.18,173.61) v4(80.18,172.93) v4(80.19,171.58) v4(80.19,170.9) v4(80.18,169.55) v4(80.18,168.86) v4(80.18,167.51) v4(80.18,166.82) v4(80.18,165.49) v4(80.18,164.8) v4(80.18,163.45) v4(80.18,162.77) v4(80.18,161.42) v4(80.18,160.74) v4(80.19,87.03) v4(82.09,157.33) v4(83.37,179.04) v4(83.76,175.65) v4(83.76,174.96) v4(83.76,173.61) v4(83.76,172.93) v4(83.76,171.58) v4(83.76,170.9) v4(83.76,169.55) v4(83.76,168.86) v4(83.76,167.52) v4(83.76,166.83) v4(83.76,165.49) v4(83.76,164.8) v4(83.76,163.45) v4(83.76,162.77) v4(83.76,161.42) v4(83.76,160.74) v4(83.75,159.39) v4(83.75,158.7) v4(84.89,84.03) v4(85.09,85.43) v4(85.21,179) v4(87.01,179.12) v4(87.76,146.75) v4(87.89,178.21) v4(87.92,176.39) v4(88.84,176.38) v4(88.98,95.96) v4(89.19,96.56) v4(89.87,101.63) v4(91.49,101.43) v4(95.5,99.42) v4(96.65,102.22) v4(96.65,101.58) v4(96.65,100.95) v4(98.09,184.62) v4(101.85,93.84) v4(103.28,93.89) v4(118.75,76.82) v4(119.6,77.87) v4(120.65,74.91) v4(120.78,67.29) v4(122.05,65.39) v4(122.81,67.29) v4(122.86,69.33) v4(123.19,77.33) v4(126.77,78.82) v4(126.77,73.82) v4(126.8,68.67) v4(128.3,73.01) v4(129.54,70.6) v4(130.05,67.55) v4(130.56,55.74) v4(132.33,58.78) v4(133.1,56.93) v4(133.55,60.54) v4(148.34,70.47) v4(151.38,181.64) v4(151.54,158) v4(151.78,167.29) v4(152.22,172.81) v4(152.32,178.72) v4(152.32,138.62) v4(152.86,175.02) v4(152.91,140.88) v4(152.98,160.74) v4(152.96,158) v4(153.14,155.86) v4(153.16,150.83) v4(153.54,163.86) v4(153.47,161.83) v4(153.6,146.74) v4(153.62,130.97) v4(153.75,178.77) v4(153.7,136.92) v4(153.9,159.62) v4(153.97,176.89) v4(154.13,133.87) v4(154.41,174.56) v4(154.41,157.95) v4(154.41,147.86) v4(154.48,160.77) v4(154.89,175.7) v4(154.89,161.83) v4(154.99,150.91) v4(155.07,130.92) v4(155.32,159.62) v4(159.11,123.46) v4(159.64,123.94) v4(160.15,124.44) v4(161.63,125.96) v4(165.66,165.82) v4(166.45,154.19) v4(166.45,151.11) v4(166.62,130.18) v4(167.13,183.91) v4(167.11,137.02) v4(167.21,186.9) v4(167.26,182.18) v4(167.39,163) v4(167.46,147.71) v4(167.64,158.48) v4(167.94,176.34) v4(167.89,171.46) v4(167.94,154.19) v4(167.89,145.6) v4(167.92,133.66) v4(167.97,180.3) v4(167.96,178.34) v4(167.97,174.86) v4(167.97,156.4) v4(168,131.84) v4(168.2,135.47) v4(168.4,161.81) v4(168.48,161.1) v4(168.53,137.02) v4(168.61,128.69) v4(168.58,126.91) v4(168.66,169.99) v4(168.71,139.33) v4(168.76,182.15) v4(168.77,155.43) v4(168.94,163.94) v4(168.91,147.68) v4(169.32,160.18) v4(169.27,140.93) v4(169.44,183.83) v4(169.44,178.37) v4(169.37,176.31) v4(169.42,171.51) v4(169.47,180.22) v4(169.47,157.49) v4(169.47,131.78) v4(169.49,130.18) v4(170.13,187) v4(170.18,143.24) v4(174.04,159.75) v4(174.09,156.41) v4(174.1,155.22) v4(174.13,154.4) v4(174.13,153.57) v5(1.12,245.72) v5(1.12,241.91) v5(1.12,238.1) v5(1.12,234.29) v5(1.12,230.48) v5(1.12,226.67) v5(1.12,222.86) v5(1.12,219.05) v5(1.12,215.24) v5(1.12,207.62) v5(1.12,203.81) v5(1.12,200) v5(1.12,196.19) v5(1.12,192.38) v5(1.12,188.57) v5(1.12,184.76) v5(1.12,180.95) v5(1.12,177.14) v5(1.12,173.33) v5(1.12,169.52) v5(1.12,165.71) v5(1.12,161.9) v5(1.12,158.09) v5(1.12,154.28) v5(1.12,150.47) v5(1.12,146.66) v5(1.12,142.85) v5(1.12,139.04) v5(1.12,135.23) v5(1.12,131.42) v5(1.12,127.61) v5(1.12,123.8) v5(1.12,119.99) v5(1.12,116.18) v5(1.12,112.37) v5(1.12,108.56) v5(1.12,104.75) v5(1.12,100.94) v5(1.12,97.13) v5(1.12,93.32) v5(1.12,89.51) v5(1.12,85.7) v5(1.12,81.89) v5(1.12,78.08) v5(1.12,74.27) v5(1.12,70.46) v5(1.12,66.65) v5(1.12,62.84) v5(1.12,59.03) v5(1.12,55.22) v5(1.12,51.41) v5(1.12,47.6) v5(1.12,43.79) v5(1.12,39.98) v5(1.12,36.17) v5(1.12,32.36) v5(1.12,28.55) v5(1.12,24.74) v5(1.12,20.93) v5(1.12,17.12) v5(1.12,13.31) v5(1.12,3.81) v5(1.36,1.23) v5(4.66,252.37) v5(5.17,1.23) v5(8.47,252.37) v5(8.98,1.23) v5(12.28,252.37) v5(12.79,1.23) v5(14.12,252.37) v5(14.67,1.23) v5(16.09,252.37) v5(16.6,1.23) v5(19.9,252.37) v5(20.41,1.23) v5(23.71,252.37) v5(24.22,1.23) v5(25.15,101.84) v5(25.15,100.82) v5(25.17,99.73) v5(26.04,74.28) v5(26.42,127.85) v5(26.42,126.91) v5(26.42,100.72) v5(26.42,99.7) v5(26.67,123.99) v5(26.67,123.05) v5(26.86,163.49) v5(26.97,74.2) v5(27.37,162.48) v5(27.43,127.85) v5(27.43,126.91) v5(27.52,252.37) v5(27.69,123.99) v5(27.69,123.05) v5(27.69,100.69) v5(27.69,99.68) v5(28,163.49) v5(28.03,1.23) v5(28.22,229.6) v5(28.51,162.48) v5(28.6,206.61) v5(28.85,230.62) v5(28.96,100.69) v5(28.96,99.68) v5(29.14,163.49) v5(29.24,207.63) v5(29.36,229.6) v5(29.74,206.61) v5(29.65,162.48) v5(29.91,1.23) v5(30,230.62) v5(30.2,100.69) v5(30.2,99.68) v5(30.29,163.49) v5(30.38,207.63) v5(30.51,229.6) v5(30.79,162.48) v5(30.89,206.61) v5(31.14,230.62) v5(31.33,252.37) v5(31.52,207.63) v5(31.47,100.72) v5(31.47,99.7) v5(31.65,229.6) v5(31.71,163.24) v5(31.84,1.23) v5(32.03,206.61) v5(32.28,230.62) v5(32.46,162.34) v5(32.64,229.73) v5(32.66,207.63) v5(32.77,100.72) v5(32.77,99.7) v5(33.27,230.62) v5(33.33,163.21) v5(33.53,207.12) v5(33.91,229.73) v5(34.04,100.69) v5(34.04,99.68) v5(34.22,162.35) v5(34.42,230.62) v5(34.42,207.76) v5(34.86,163.36) v5(35.14,252.37) v5(35.05,229.6) v5(35.18,206.74) v5(35.31,100.69) v5(35.31,99.68) v5(35.37,162.35) v5(35.65,1.23) v5(35.81,230.62) v5(36,163.36) v5(36.09,207.5) v5(36.22,229.47) v5(36.51,162.35) v5(36.6,206.49) v5(36.86,230.49) v5(37.14,163.36) v5(37.24,207.5) v5(37.36,229.47) v5(37.74,206.49) v5(37.65,162.35) v5(38,230.49) v5(38.29,163.36) v5(38.38,207.5) v5(38.51,229.47) v5(38.89,206.49) v5(38.95,252.37) v5(39.14,230.49) v5(39.52,207.5) v5(39.46,1.23) v5(39.88,85.35) v5(39.88,84.24) v5(40.03,206.49) v5(41.91,9.25) v5(42.76,252.37) v5(43.27,1.23) v5(45.15,1.23) v5(46.57,252.37) v5(47.08,1.23) v5(50.38,252.37) v5(50.89,1.23) v5(52.07,128) v5(53.98,129.27) v5(54.19,252.37) v5(54.7,1.23) v5(55.88,130.54) v5(55.88,127.36) v5(58,252.37) v5(58.42,125.46) v5(58.51,1.23) v5(59.05,128) v5(60.39,1.23) v5(60.96,130.54) v5(60.96,125.46) v5(61.81,252.37) v5(62.23,127.36) v5(62.32,1.23) v5(62.87,14.33) v5(65.62,252.37) v5(66.13,1.23) v5(68.81,26.6) v5(69.34,25.56) v5(69.43,252.37) v5(69.82,27.59) v5(69.8,26.6) v5(70.08,24.98) v5(73.14,48.65) v5(73.13,27.06) v5(73.13,26.07) v5(73.24,252.37) v5(73.18,49.67) v5(73.15,28.13) v5(76.4,50.94) v5(76.4,49.87) v5(76.94,49.06) v5(77.05,252.37) v5(77.47,50.94) v5(77.47,49.87) v5(80.86,252.37) v5(81.79,40.62) v5(81.79,39.61) v5(81.86,36.86) v5(81.86,35.8) v5(82.93,40.62) v5(82.93,39.61) v5(83.03,36.86) v5(83.06,35.8) v5(84.67,252.37) v5(88.48,252.37) v5(92.29,252.37) v5(92.86,31.33) v5(92.86,30.31) v5(92.86,29.3) v5(92.86,28.28) v5(93.88,31.28) v5(93.88,30.26) v5(93.88,29.24) v5(93.88,28.23) v5(95.33,53.98) v5(95.83,54.82) v5(96.1,252.37) v5(96.29,53.98) v5(96.89,54.84) v5(97.21,53.98) v5(97.82,56.98) v5(99.03,56.98) v5(99.91,252.37) v5(99.9,53.93) v5(100.18,56.98) v5(100.23,54.79) v5(100.91,53.93) v5(101.42,54.82) v5(101.83,53.93) v5(103.72,252.37) v5(107.53,252.37) v5(111.34,252.37) v5(114.3,35.16) v5(118.49,102.35) v5(130.18,53.9) v5(131.19,53.9) v5(132.21,53.96) v5(137.92,118.09) v5(138.56,117.33) v5(139.19,107.3) v5(139.19,106.28) v5(139.32,118.09) v5(143.13,117.33) v5(143.64,118.09) v5(143.89,30.59) v5(144.05,25.51) v5(159.51,220.61) v5(160.78,220.61) v5(163.55,220.89) v5(163.73,229.88) v5(164.69,220.91) v5(165.66,229.88) v5(167.54,229.88) v5(171.35,229.88) v5(173.99,112.89) v5(173.99,111.87) v5(173.99,110.85) v5(175.01,112.89) v5(175.01,111.87) v5(175.01,110.85) v5(175.16,229.88) v5(177.16,226.07) v5(178.13,226.96) v5(178.1,225.43) v5(178.97,229.88) v5(179.73,221.32) v5(179.76,219.74) v5(179.76,218.47) v5(179.76,217.2) v5(179.76,216.06) v5(179.91,67.32) v5(180.9,229.88) v5(182.25,210.55) v5(182.25,209.53) v5(182.25,208.52) v5(182.25,207.5) v5(182.25,206.49) v5(182.25,204.71) v5(182.25,203.56) v5(182.25,202.42) v5(182.25,201.41) v5(182.25,200.39) v5(182.25,199.37) v5(182.78,229.88) v5(183.13,67.29) v5(183.16,136.51) v5(183.26,210.55) v5(183.26,209.53) v5(183.26,208.52) v5(183.26,207.5) v5(183.26,206.49) v5(183.26,204.71) v5(183.26,203.56) v5(183.26,202.42) v5(183.26,201.41) v5(183.26,200.39) v5(183.26,199.37) v5(184.15,136.51) v5(185.88,67.32) v5(186.59,229.88) v5(186.72,134.22) v5(186.88,226.36) v5(186.88,222.55) v5(186.88,218.74) v5(186.88,214.93) v5(186.88,211.12) v5(186.88,207.31) v5(186.88,203.5) v5(186.88,199.69) v5(186.88,195.88) v5(186.88,192.07) v5(186.88,188.26) v5(186.88,184.45) v5(187.71,134.22) v5(187.84,107.63) v5(187.94,67.28) v5(188.39,189.09) v5(188.47,108.44) v5(189.23,176.26) v5(189.23,173.72) v5(189.82,67.28) v5(189.87,181.34) v5(190.27,184.03) v5(190.55,186.95) v5(191.75,67.28) v5(192.41,185.12) v5(193.04,180.07) v5(193.04,176.26) v5(193.04,172.45) v5(193.04,168.64) v5(193.04,164.83) v5(193.04,161.02) v5(193.04,157.21) v5(193.04,153.4) v5(193.04,149.59) v5(193.04,145.78) v5(193.04,138.16) v5(193.09,143.11) v5(194.59,182.89) v5(194.94,117.2) v5(194.94,113.39) v5(195.58,181.34) v5(195.58,177.53) v5(195.58,173.72) v5(195.58,169.91) v5(195.58,163.56) v5(195.58,159.75) v5(195.58,155.94) v5(195.58,152.13) v5(195.58,148.32) v5(195.58,144.51) v5(195.58,136.89) v5(195.56,67.28) v5(196.22,128.63) v5(196.22,124.82) v5(196.85,94.98) v5(196.85,92.31) v5(198.12,176.26) v5(198.12,172.45) v5(198.12,168.64) v5(198.12,164.83) v5(198.12,161.02) v5(198.12,157.21) v5(198.12,153.4) v5(198.12,149.59) v5(198.12,145.78) v5(198.12,141.97) v5(198.12,138.16) v5(198.12,130.54) v5(198.12,126.73) v5(198.12,122.92) v5(198.12,119.11) v5(198.12,115.3) v5(198.12,111.49) v5(198.12,107.68) v5(198.12,103.87) v5(198.35,101.63) v5(198.63,178.93) v5(198.75,100.06) v5(198.75,96.25) v5(199.39,94.09) v5(199.37,67.28) v5(199.75,108.95) v5(199.77,130.03) v5(199.95,139.1) v5(199.87,128) v5(199.92,124.24) v5(199.87,105.14) v5(200,169.27) v5(200.53,100.54) v5(200.63,114.46) v5(200.66,173.72) v5(200.66,166.1) v5(200.66,162.29) v5(200.66,158.48) v5(200.66,154.67) v5(200.66,150.86) v5(200.66,147.05) v5(200.66,143.24) v5(200.66,135.62) v5(200.66,131.81) v5(200.66,120.38) v5(200.66,116.57) v5(200.66,112.76) v5(200.66,98.15) v5(200.91,118.37) v5(201.17,176.39) v5(201.29,91.8) v5(201.4,134.12) v5(201.83,111.24) v5(201.93,94.22) v5(202.31,130.92) v5(202.31,67.29) v5(202.56,171.81) v5(202.56,164.19) v5(202.56,161.02) v5(202.56,157.21) v5(202.56,153.4) v5(202.56,149.59) v5(202.56,145.78) v5(202.56,141.97) v5(202.56,100.06) v5(202.56,96.25) v5(202.72,113.17) v5(203.07,174.48) v5(203.33,98.03) v5(203.38,121.12) v5(203.43,76.34) v5(203.43,73.02) v5(203.43,71.09) v5(203.43,69.21) v5(203.43,67.45) v5(203.48,135.87) v5(203.51,131.44) v5(203.54,118.63) v5(203.54,116.7) v5(203.54,114.82) v5(203.54,111.01) v5(203.58,101.2) v5(203.58,94.6) v5(203.58,93.2) v5(203.58,91.8) v5(204.47,170.98) v5(204.88,164.35) v5(204.88,162.42) v5(204.88,160.54) v5(204.88,156.73) v5(204.88,152.92) v5(204.88,149.11) v5(204.88,147.18) v5(204.88,145.3) v5(204.88,141.49)
