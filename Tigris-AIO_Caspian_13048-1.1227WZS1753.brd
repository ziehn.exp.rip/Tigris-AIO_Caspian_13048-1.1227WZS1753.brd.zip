# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_MAA_A0: length 85.5
  TOP w0.216: CPU1.AU13 95.74,161.29 v4(96.14,161.7) ; v4(168.73,157.51) 170.05,156.2 DIMM1.98
  L3 w0.102: v4(96.14,161.7) 95.73,162.12 95.73,162.78 96.17,163.22 96.33,163.22 96.58,163.47 96.58,163.67 96.91,163.99 98.18,163.99 99.11,164.92 99.63,164.92 99.85,164.7 100.15,164.7
  L3 w0.292: 100.15,164.7 106.53,164.7 107.98,163.26 137.03,163.26 143.78,156.51 160.89,156.51 161.79,157.41 163.68,157.41 164.3,158.04 165.87,158.04 165.97,157.93 167.28,157.93 167.69,157.51 v4(168.73,157.51)
  BOTTOM w0.216: v2(169.29,158.35) 168.73,157.79 v4(168.73,157.51)
M_MAA_A1: length 85.2
  TOP w0.216: DIMM1.97 165.13,156.5 165.39,156.76 165.98,156.76 166.23,157.01 167.35,157.01 167.84,157.5 167.84,157.87 v4(168.4,158.43) ; v4(96.15,163.65) 96.54,164.03 CPU1.AV16
  L3 w0.102: v4(96.15,163.65) 96.28,163.65 97.51,164.88 98.35,164.88 99.24,165.77 99.82,165.77
  L3 w0.292: v4(168.4,158.43) 168.33,158.51 168.33,158.54 167.44,159.43 164.41,159.43 163.31,158.33 161.45,158.33 160.52,157.39 148.28,157.39 147.21,158.47 143.08,158.47 137.31,164.23 115.33,164.23 113.79,165.77 99.82,165.77
  BOTTOM w0.216: v2(168.41,159.89) 168.4,159.88 v4(168.4,158.43)
M_MAA_A2: length 87.4
  TOP w0.216: CPU1.AU16 95.68,164.03 v4(95.21,163.56) ; DIMM1.96 170.84,156.8 170.2,157.44 v4(170.2,157.46)
  L3 w0.102: 100.06,166.22 99.4,166.22 98.99,165.81 97.83,165.81 97.58,165.56 97.58,165.25 96.46,164.13 95.78,164.13 v4(95.21,163.56)
  L3 w0.292: 100.06,166.22 113.98,166.22 115.52,164.68 137.5,164.68 143.26,158.91 147.39,158.91 147.65,158.65 161.07,158.65 161.94,159.52 163.83,159.52 164.19,159.87 167.71,159.87 169.05,158.53 170.32,158.53 170.61,158.24 170.61,157.88 v4(170.2,157.46)
  BOTTOM w0.216: v4(170.2,157.46) 171.37,158.64 v2(172.02,158.64)
M_MAA_A3: length 84.3
  TOP w0.216: v4(98,164.45) 97.52,164.92 CPU1.AW17 ; DIMM1.95 165.21,157.1 165.23,157.13 165.56,157.13 166.88,158.45 v4(166.9,158.45)
  L3 w0.102: v4(98,164.45) 98.25,164.45 99.02,165.21 100.06,165.21
  L3 w0.292: v4(166.9,158.45) 166.88,158.48 166.88,158.51 166.41,158.98 164.59,158.98 163.49,157.88 161.63,157.88 160.7,156.95 148.04,156.95 146.96,158.02 142.89,158.02 137.13,163.79 113.57,163.79 113.28,164.08 113.28,164.92 112.99,165.21 112.4,165.21 112.11,164.92 112.11,164.08 111.82,163.79 111.23,163.79 110.94,164.08 110.94,164.92 110.65,165.21 110.07,165.21 109.77,164.92 109.77,164.08 109.48,163.79 108.9,163.79 108.6,164.08 108.6,164.92 108.31,165.21 100.06,165.21
  BOTTOM w0.216: v4(166.9,158.45) 166.9,159.15 166.61,159.45 v2(165.94,159.45)
M_MAA_A4: length 85.8
  TOP w0.216: DIMM1.92 169.85,158 167.77,160.08 v4(167.77,161.09) ; v4(95.27,164.49) 95.69,164.91 CPU1.AU17
  L3 w0.102: 99.47,167.11 98.74,167.11 97.98,166.34 97.7,166.34 97.18,165.83 96.01,165.83 95.76,165.57 95.76,164.97 v4(95.27,164.49)
  L3 w0.292: 99.47,167.11 114.34,167.11 115.88,165.57 137.86,165.57 142.58,160.85 150.11,160.85 151.41,159.55 152.25,159.55 152.91,160.21 156.46,160.21 157.36,161.1 167.75,161.1 v4(167.77,161.09)
  BOTTOM w0.216: v4(167.77,161.09) 167.01,161.09 v2(166.85,160.92)
M_MAA_A5: length 83.7
  TOP w0.216: v4(97.12,166.38) 97.15,166.35 97.15,166.31 97.52,165.93 CPU1.AW18 ; v4(167.87,162.32) 167.16,161.6 167.16,160.31 165.15,158.3 DIMM1.91
  L3 w0.102: 99.49,167.55 98.9,167.55 97.9,166.55 97.29,166.55 v4(97.12,166.38)
  L3 w0.292: v4(167.87,162.32) 167.4,161.84 157.41,161.84 156.87,161.29 146.29,161.29 146,161.59 146,162.18 145.71,162.47 145.07,162.47 144.78,162.18 144.78,161.59 144.49,161.29 142.77,161.29 138.05,166.01 116.19,166.01 114.65,167.55 99.49,167.55
  BOTTOM w0.216: v4(167.87,162.32) 167.93,162.32 v2(168.61,162.99)
M_MAA_A6: length 84.5
  TOP w0.216: CPU1.AV17 96.66,164.95 v4(97.07,165.36) ; v4(170.18,159.19) 170.77,158.6 DIMM1.90
  L3 w0.102: v4(97.07,165.36) 97.86,166.14 98.07,166.14 98.73,166.81 99.09,166.81 99.23,166.66 99.52,166.66
  L3 w0.292: 99.52,166.66 114.16,166.66 115.7,165.12 137.68,165.12 143.08,159.72 147.22,159.72 147.85,159.1 148.65,159.1 148.94,159.39 148.94,159.86 149.23,160.16 149.82,160.16 150.11,159.86 150.11,159.39 150.4,159.1 159.87,159.1 161.44,160.66 166.22,160.66 166.57,160.32 168.17,160.32 169.29,159.19 v4(170.18,159.19)
  BOTTOM w0.216: v2(171.49,160.28) 171.27,160.28 v4(170.18,159.19)
M_MAA_A7: length 87.3
  TOP w0.216: v4(94.31,166.26) 94.71,165.86 CPU1.AT18 ; DIMM1.86 170.54,159.8 v4(170.1,160.23)
  L3 w0.102: v4(94.31,166.26) 94.83,166.77 96.32,166.77 96.77,167.22 97.65,167.22 99.1,168.66 99.72,168.66 100,168.95 100.4,168.95
  L3 w0.292: 100.4,168.95 115.27,168.95 116.82,167.4 130.11,167.4 130.4,167.69 130.4,168.4 130.7,168.69 137.25,168.69 138.55,167.4 138.55,167.4 141.95,163.99 147.65,163.99 148.32,163.32 156.84,163.32 157.61,164.09 163.7,164.09 163.85,163.93 167.2,163.93 169.52,161.61 169.52,160.82 v4(170.1,160.23)
  BOTTOM w0.216: v4(170.1,160.23) 169.32,161.02 v2(169.29,161.02)
M_MAA_A8: length 85.3
  TOP w0.216: CPU1.AU18 95.69,165.84 v4(95.27,165.41) ; v4(166.96,162.37) 166.7,162.1 166.7,160.54 165.06,158.9 DIMM1.89
  L3 w0.102: 99.59,168 99.03,168 97.85,166.81 96.94,166.81 96.16,166.03 95.88,166.03 v4(95.27,165.41)
  L3 w0.292: v4(166.96,162.37) 164.16,162.37 163.33,163.2 158.3,163.2 157.51,162.41 157.31,162.41 149.77,162.41 149.35,161.99 147.93,161.99 146.91,163 144.5,163 144.16,162.66 144.16,162 143.92,161.76 143.23,161.76 142.99,162 142.99,162.66 142.65,163 141.69,163 138.18,166.51 116.33,166.51 114.84,168 99.59,168
  BOTTOM w0.216: v2(165.35,162.37) v4(166.96,162.37)
M_MAA_A9: length 87.1
  TOP w0.216: v4(95.23,166.3) 95.23,166.55 95.01,166.78 CPU1.AT19 ; DIMM1.85 164.98,160.1 166.29,161.41 166.29,162.73 v4(166.61,163.05)
  L3 w0.102: v4(95.23,166.3) 95.49,166.57 96.41,166.57 96.86,167.01 97.74,167.01 99.16,168.44 100.05,168.44
  L3 w0.292: v4(166.61,163.05) 166.16,163.49 163.67,163.49 163.52,163.64 158.12,163.64 157.32,162.85 153.66,162.85 153.46,162.85 152.66,162.85 152.66,162.85 148.08,162.85 147.38,163.55 141.77,163.55 138.37,166.95 137.49,166.95 137.2,167.24 137.2,167.92 136.9,168.21 136.32,168.21 136.03,167.92 136.03,167.24 135.73,166.95 135.15,166.95 134.86,167.24 134.86,167.92 134.57,168.21 133.98,168.21 133.69,167.92 133.69,167.24 133.4,166.95 132.81,166.95 132.52,167.24 132.52,167.92 132.23,168.21 131.65,168.21 131.35,167.92 131.35,167.24 131.06,166.95 116.51,166.95 115.02,168.44 100.05,168.44
  BOTTOM w0.216: v2(167.26,164.07) 166.61,163.41 v4(166.61,163.05)
M_MAA_A10: length 83.6
  TOP w0.216: v4(97.99,159.89) 97.99,159.82 97.64,159.46 CPU1.AW11 ; v4(165.69,154.2) 165,153.5 DIMM1.107
  L3 w0.102: v4(97.99,159.89) 98.48,160.38 100.33,160.38
  L3 w0.292: v4(165.69,154.2) 164.07,154.2 161.8,151.93 157.1,151.93 156.71,151.54 150.49,151.54 150.2,151.25 150.2,150.11 149.9,149.82 149.32,149.82 149.03,150.11 149.03,151.25 148.74,151.54 148.15,151.54 147.86,151.25 147.86,150.6 147.57,150.31 146.98,150.31 146.69,150.6 146.69,151.25 146.4,151.54 145.56,151.54 145.27,151.25 145.27,150.16 144.98,149.87 144.39,149.87 144.1,150.16 144.1,151.25 143.81,151.54 142.14,151.54 134.3,159.38 101.33,159.38 100.33,160.38
  BOTTOM w0.216: v2(165.23,153.15) 165.69,153.61 v4(165.69,154.2)
M_MAA_A11: length 84.4
  TOP w0.216: v4(170.15,161.02) 170.77,160.4 DIMM1.84 ; CPU1.AV19 97.38,167.55 v4(97.38,167.65)
  L3 w0.102: v4(97.38,167.65) 97.38,168.16 98.1,168.88 99.38,168.88 99.89,169.39 100.15,169.39
  L3 w0.292: 100.15,169.39 115.45,169.39 117,167.84 129.34,167.84 129.63,168.13 129.63,168.98 129.93,169.27 137.3,169.27 138.73,167.84 138.73,167.84 142.04,164.53 163.88,164.53 164.04,164.38 167.38,164.38 170.15,161.61 v4(170.15,161.02)
  BOTTOM w0.216: v2(170.43,162.29) 170.43,161.3 v4(170.15,161.02)
M_MAA_A12: length 87.2
  TOP w0.216: v4(167.54,165.06) 167.54,164.81 165.91,163.18 165.91,161.71 164.9,160.7 DIMM1.83 ; v4(96.15,167.2) 96.12,167.2 CPU1.AU19
  L3 w0.102: 100.13,169.91 99.82,169.91 99,169.09 98.02,169.09 96.15,167.22 v4(96.15,167.2)
  L3 w0.292: 100.13,169.91 115.57,169.91 117.2,168.28 126.07,168.28 126.37,168.58 126.37,169.57 126.66,169.86 127.24,169.86 127.53,169.57 127.53,168.58 127.83,168.28 128.41,168.28 128.7,168.58 128.7,169.57 128.99,169.86 137.34,169.86 138.92,168.28 138.92,168.28 141.43,165.77 156.51,165.77 157.27,165.02 164.03,165.02 164.22,164.82 167.3,164.82 v4(167.54,165.06)
  BOTTOM w0.216: v4(167.54,165.06) 168.28,165.8 v2(168.28,166.1)
M_MAA_A13: length 82
  TOP w0.216: DIMM1.119 166.75,149.9 v4(167.34,149.31) ; v4(98.16,155.99) 97.88,155.99 CPU1.AY10
  L3 w0.292: v4(167.34,149.31) 166.82,149.83 164.3,149.83 158.34,143.87 144.41,143.87 132.28,155.99 v4(98.16,155.99)
  BOTTOM w0.216: v2(167.13,148.45) 167.13,149.11 v4(167.34,149.31)
M_MAA_A14: length 85.7
  TOP w0.216: v4(169.67,163.99) 169.67,163 171.07,161.6 DIMM1.80 ; CPU1.AT20 94.78,167.71 v4(95.23,168.16)
  L3 w0.102: v4(95.23,168.16) 95.9,168.16 96.86,169.11 96.86,170.37 97.9,171.42 98.31,171.42 98.5,171.61 98.88,171.61
  L3 w0.292: v4(169.67,163.99) 167.3,166.36 157.83,166.36 156.37,167.82 141.33,167.82 137.54,171.61 98.88,171.61
  BOTTOM w0.216: v2(169.42,164.83) 169.42,164.25 v4(169.67,163.99)
M_MAA_A15: length 86.2
  TOP w0.216: v4(170.41,163.94) 170.38,163.92 170.38,162.95 171.13,162.2 DIMM1.78 ; CPU1.AU21 95.69,168.62 95.3,169.01 v4(95.23,169.01)
  L3 w0.102: v4(95.23,169.01) 96.15,169.93 96.15,170.31 97.25,171.42 97.25,171.76 98.09,172.6 98.68,172.6
  L3 w0.292: 98.68,172.6 99.34,172.6 99.53,172.79 100.32,172.79 101.05,172.06 137.73,172.06 141.51,168.27 156.55,168.27 158.01,166.81 167.6,166.81 170.41,164 v4(170.41,163.94)
  BOTTOM w0.216: v4(170.41,163.94) 171.58,163.94 v2(171.7,163.81)
M_MAA_B0: length 77.7
  TOP w0.216: v4(153.67,157.97) 154.38,157.26 155.09,157.26 156.15,156.2 DIMM2.98 ; v4(89.78,167.26) 90.21,166.83 CPU1.AL19
  L4 w0.102: v4(89.78,167.26) 89.78,168.02 90.42,168.67 90.88,168.67 91.24,169.02 92.68,169.02 93.16,169.5 94.52,169.5 95.04,170.02 98.31,170.02 99.54,168.79 101.1,168.79
  L4 w0.292: 101.1,168.79 101.22,168.67 109.09,168.67 120.12,157.64 144.61,157.64 145.36,156.89 147.65,156.89 148.22,157.46 153.17,157.46 153.67,157.96 v4(153.67,157.97)
  BOTTOM w0.216: v4(153.67,157.97) 153.67,157.23 v2(153.97,156.93)
M_MAA_B1: length 77.7
  TOP w0.216: CPU1.AK23 89.29,170.43 v4(89.78,169.94) ; v4(152.25,158) 150.75,156.5 DIMM2.97
  L4 w0.102: 99.76,169.98 99.11,169.98 98.66,170.43 94.73,170.43 94.59,170.57 93.66,170.57 92.62,169.53 91.44,169.53 91.11,169.86 91.11,170.21 90.86,170.47 90.31,170.47 v4(89.78,169.94)
  L4 w0.292: 99.76,169.98 100.07,169.68 110.01,169.68 119.81,159.88 130.1,159.88 130.61,159.37 130.61,158.99 130.76,158.84 131.75,158.84 131.9,158.99 131.9,159.57 132.05,159.72 132.97,159.72 133.12,159.57 133.12,158.96 133.27,158.81 134.09,158.81 134.24,158.96 134.24,159.62 134.4,159.78 135.26,159.78 135.41,159.62 135.41,159.08 135.84,158.65 151.63,158.65 152.25,158.03 v4(152.25,158)
  BOTTOM w0.216: v2(152.65,156.96) 152.25,157.36 v4(152.25,158)
M_MAA_B2: length 81.1
  TOP w0.216: v4(155.12,157.92) 156.24,156.8 DIMM2.96 ; CPU1.AM22 91.18,169.52 v4(91.62,169.96)
  L4 w0.102: 99.71,170.65 99,171.36 93.22,171.36 92.97,171.1 92.97,170.69 92.71,170.42 92.08,170.42 v4(91.62,169.96)
  L4 w0.292: v4(155.12,157.92) 155.12,158.12 154.71,158.53 152.76,158.53 152.18,159.1 143.52,159.1 143.23,159.39 143.23,160.07 142.93,160.36 142.35,160.36 142.06,160.07 142.06,159.39 141.77,159.1 141.32,159.1 141.03,159.39 141.03,160.25 140.74,160.54 140.15,160.54 139.86,160.25 139.86,159.39 139.57,159.1 138.98,159.1 138.69,159.39 138.69,160.25 138.4,160.54 137.82,160.54 137.52,160.25 137.52,159.39 137.23,159.1 136.68,159.1 136.35,159.43 136.35,160.35 136.04,160.65 119.9,160.65 110.39,170.16 100.2,170.16 99.71,170.65
  BOTTOM w0.216: v2(155.47,158.66) 155.12,158.3 v4(155.12,157.92)
M_MAA_B3: length 77.5
  TOP w0.216: DIMM2.95 150.41,157.1 150.83,157.51 v4(150.83,158) ; v4(90.68,170.03) 91.08,170.44 CPU1.AM23
  L4 w0.102: v4(90.68,170.03) 90.68,170 91.35,169.33 92.7,169.33 93.75,170.37 94.5,170.37 94.64,170.23 98.58,170.23 99.25,169.55 99.59,169.55
  L4 w0.292: 99.59,169.55 99.94,169.2 109.55,169.2 120.57,158.18 121.02,158.18 121.31,158.47 121.31,159.14 121.6,159.43 122.19,159.43 122.48,159.14 122.48,158.47 122.77,158.18 123.36,158.18 123.65,158.47 123.65,159.14 123.94,159.43 124.52,159.43 124.82,159.14 124.82,158.47 125.11,158.18 125.69,158.18 125.98,158.47 125.98,159.14 126.28,159.43 126.86,159.43 127.15,159.14 127.15,158.47 127.44,158.18 128.03,158.18 128.32,158.47 128.32,159.14 128.61,159.43 129.2,159.43 129.49,159.14 129.49,158.47 129.83,158.12 150.7,158.12 v4(150.83,158)
  BOTTOM w0.216: v2(150.88,159.24) 150.88,158.3 150.83,158.25 v4(150.83,158)
M_MAA_B4: length 79.1
  TOP w0.216: v4(154.61,159.62) 155.42,158.81 155.68,158.81 156.49,158 DIMM2.92 ; v4(92.53,170.85) 92.56,170.82 92.57,170.82 92.95,170.44 CPU1.AP23
  L4 w0.102: v4(92.53,170.85) 92.53,170.95 93.84,172.26 95.49,172.26 95.87,171.88 97.37,171.88 97.77,172.28 98.56,172.28 99.8,171.04 100.04,171.04
  L4 w0.292: v4(154.61,159.62) 154.61,159.59 154.12,159.1 152.9,159.1 152.45,159.55 144.25,159.55 143.92,159.88 143.92,160.77 143.59,161.1 129.5,161.1 129.21,161.39 129.21,161.76 128.92,162.05 128.33,162.05 128.04,161.76 128.04,161.39 127.75,161.1 127.17,161.1 126.87,161.39 126.87,161.76 126.58,162.05 126,162.05 125.7,161.76 125.7,161.39 125.41,161.1 124.83,161.1 124.54,161.39 124.54,161.76 124.24,162.05 123.66,162.05 123.37,161.76 123.37,161.39 123.08,161.1 122.49,161.1 122.2,161.39 122.2,161.76 121.91,162.05 121.32,162.05 121.03,161.76 121.03,161.39 120.74,161.1 120.29,161.1 110.77,170.62 100.46,170.62 100.04,171.04
  BOTTOM w0.216: v4(154.61,159.62) 154.61,159.29 v2(154.18,158.86)
M_MAA_B5: length 75.2
  TOP w0.216: v4(90.66,170.91) 90.21,170.46 CPU1.AL23 ; v4(153.17,159.64) 152.23,158.7 150.81,158.7 150.42,158.3 DIMM2.91
  L4 w0.102: 100.34,171.45 99.68,171.45 98.65,172.49 97.67,172.49 97.27,172.09 95.96,172.09 95.58,172.47 91.62,172.47 90.66,171.51 v4(90.66,170.91)
  L4 w0.292: v4(153.17,159.64) 152.82,159.99 146.53,159.99 144.87,161.65 130.61,161.65 129.77,162.49 119.56,162.49 110.92,171.13 100.66,171.13 100.34,171.45
  BOTTOM w0.216: v2(152.4,159.36) 152.67,159.64 v4(153.17,159.64)
M_MAA_B6: length 73.9
  TOP w0.216: CPU1.AY24 98.8,171.35 v4(99.74,172.29) ; DIMM2.90 156.55,158.6 155.81,159.34 155.81,159.83 155.52,160.11 154.35,160.11 v4(153.7,160.77)
  L4 w0.292: v4(153.7,160.77) 153.7,160.77 153.2,161.27 152.55,161.27 152.29,161.52 146.31,161.52 144.46,163.37 144.41,163.37 144.4,163.38 120.08,163.38 118.08,165.38 118.08,165.8 118.41,166.13 118.41,166.54 118,166.96 117.58,166.96 117.25,166.62 116.84,166.62 116.42,167.04 116.42,167.45 116.76,167.78 116.76,168.2 116.34,168.61 115.93,168.61 115.6,168.28 115.18,168.28 114.77,168.69 114.77,169.1 115.1,169.44 115.1,169.85 114.69,170.26 114.28,170.26 113.94,169.93 113.53,169.93 113.12,170.34 113.12,170.75 113.45,171.09 113.45,171.5 113.04,171.91 112.63,171.91 112.29,171.58 111.88,171.58 111.24,172.22 99.81,172.22 v4(99.74,172.29)
  BOTTOM w0.216: v2(156.21,160) 155.96,160.26 154.2,160.26 v4(153.7,160.77)
M_MAA_B7: length 75.4
  TOP w0.216: DIMM2.86 156.36,159.8 155.39,160.77 v4(155.27,160.77) ; CPU1.AV25 96.61,172.33 v4(96.2,172.75)
  L4 w0.102: v4(96.2,172.75) 96.2,173.31 96.93,174.04 99.26,174.04 99.66,173.64 100.6,173.64
  L4 w0.292: 100.6,173.64 100.66,173.69 113.87,173.69 121.26,166.3 132.18,166.3 132.66,165.82 132.66,165.19 132.99,164.86 133.56,164.86 133.85,165.15 133.85,165.96 134.14,166.25 134.73,166.25 135.02,165.96 135.02,165.15 135.31,164.86 135.89,164.86 136.19,165.15 136.19,165.96 136.48,166.25 137.06,166.25 137.35,165.96 137.35,165.15 137.65,164.86 146.1,164.86 148.08,162.88 154.71,162.88 155.57,162.01 155.57,161.07 v4(155.27,160.77)
  BOTTOM w0.216: v2(156.08,161.27) 155.57,160.77 v4(155.27,160.77)
M_MAA_B8: length 74.5
  TOP w0.216: CPU1.AU26 95.64,173.18 v4(95.21,173.61) ; v4(152.24,160.62) 152.21,160.62 150.5,158.9 DIMM2.89
  L4 w0.102: v4(95.21,173.61) 95.21,173.13 96.04,172.29 97.19,172.29 97.59,172.69 98.73,172.69 99.56,171.86 100.79,171.86 101.09,171.56
  L4 w0.292: 101.09,171.56 101.1,171.57 111.11,171.57 119.74,162.94 131.74,162.94 132.03,162.65 132.03,162.39 132.32,162.1 132.91,162.1 133.2,162.39 133.2,162.65 133.49,162.94 134.08,162.94 134.37,162.65 134.37,162.39 134.66,162.1 135.25,162.1 135.54,162.39 135.54,162.65 135.83,162.94 136.41,162.94 136.71,162.65 136.71,162.39 137,162.1 137.58,162.1 137.87,162.39 137.87,162.65 138.17,162.94 138.75,162.94 139.04,162.65 139.04,162.39 139.33,162.1 139.92,162.1 140.21,162.39 140.21,162.65 140.5,162.94 141.09,162.94 141.38,162.65 141.38,162.39 141.67,162.1 142.26,162.1 142.55,162.39 142.55,162.65 142.84,162.94 144.21,162.94 146.07,161.08 146.72,161.08 147.01,160.79 147.01,160.73 147.3,160.44 147.89,160.44 148.18,160.73 148.18,160.79 148.47,161.08 149.05,161.08 149.35,160.79 149.35,160.73 149.64,160.44 150.22,160.44 150.51,160.73 150.51,160.79 150.81,161.08 151.78,161.08 v4(152.24,160.62)
  BOTTOM w0.216: v2(151.76,161.27) 152.24,160.8 v4(152.24,160.62)
M_MAA_B9: length 73.7
  TOP w0.216: DIMM2.85 150.2,160.1 151.37,161.27 153.61,161.27 v4(154.18,161.84) ; v4(99.08,173.6) 99.08,173.17 98.65,172.74 98,172.74 CPU1.AW25
  L4 w0.292: v4(99.08,173.6) 99.44,173.25 104.62,173.25 104.62,173.25 113.58,173.25 120.98,165.85 127.43,165.85 127.76,165.52 127.76,164.65 128,164.41 128.51,164.41 128.81,164.7 128.81,165.44 128.96,165.59 129.82,165.59 129.97,165.44 129.97,164.7 130.27,164.41 130.71,164.41 131,164.7 131,165.3 131.3,165.59 131.88,165.59 132.17,165.3 132.17,164.7 132.46,164.41 145.8,164.41 147.8,162.41 153.63,162.41 154.18,161.87 v4(154.18,161.84)
  BOTTOM w0.216: v4(154.18,161.84) 155.01,162.67 v2(155.45,162.67)
M_MAA_B10: length 80.1
  TOP w0.216: DIMM2.107 150.83,153.5 v4(150.88,153.45) ; CPU1.AP18 92.98,165.86 v4(93.41,166.29)
  L4 w0.102: v4(93.41,166.29) 93.45,166.29 94.05,166.89 95.27,166.89 95.8,166.36 96.53,166.36 96.94,165.95 97.3,165.95 97.37,166.01 98.58,166.01 98.68,165.92 99.62,165.92 100.14,165.39
  L4 w0.292: 100.14,165.39 100.43,165.1 107.03,165.1 118.98,153.15 130.19,153.15 130.48,153.44 130.48,153.79 130.75,154.06 131.44,154.06 131.73,153.77 131.73,152.64 131.88,152.49 132.75,152.49 132.9,152.64 132.9,153.77 133.19,154.06 133.77,154.06 134.07,153.77 134.07,152.61 134.22,152.46 135.08,152.46 135.24,152.61 135.24,153.77 135.53,154.06 136.11,154.06 136.4,153.77 136.4,152.59 136.56,152.43 137.42,152.43 137.57,152.59 137.57,153.77 137.86,154.06 138.45,154.06 138.74,153.77 138.74,152.66 138.89,152.51 139.76,152.51 139.91,152.66 139.91,153.77 140.2,154.06 140.75,154.06 141.05,153.77 141.05,152.72 141.34,152.43 142.18,152.43 142.54,152.79 143.45,152.79 143.81,152.43 145.33,152.43 146.05,153.15 148.88,153.15 149.19,153.45 v4(150.88,153.45)
  BOTTOM w0.216: v2(149.99,153.91) 150.42,153.91 v4(150.88,153.45)
M_MAA_B11: length 71.1
  TOP w0.216: CPU1.AY25 98.8,172.26 99.84,173.3 v4(99.84,174.07) ; DIMM2.84 156.46,160.4 155.85,161.01 155.85,161.57 154.16,163.26 153.34,163.26 152.84,163.75 v4(152.84,163.99)
  L4 w0.292: v4(152.84,163.99) 152.84,163.88 152.35,163.39 148.2,163.39 146.27,165.31 142.77,165.31 142.48,165.6 142.48,166.01 142.19,166.3 141.6,166.3 141.31,166.01 141.31,165.6 141.02,165.31 140.44,165.31 140.14,165.6 140.14,166.01 139.85,166.3 139.27,166.3 138.97,166.01 138.97,165.6 138.68,165.31 138.23,165.31 138,165.54 138,166.3 137.44,166.86 121.49,166.86 114.21,174.14 100.69,174.14 100.64,174.09 100.49,174.09 100.46,174.06 99.85,174.06 v4(99.84,174.07)
  BOTTOM w0.216: v4(152.84,163.99) 152.84,163.19 v2(153.06,162.98)
M_MAA_B12: length 74
  TOP w0.216: CPU1.AV26 97.01,172.78 v4(97.01,172.72) ; v4(152.74,161.82) 151.4,161.82 150.28,160.7 DIMM2.83
  L4 w0.102: v4(97.01,172.72) 97.18,172.89 99,172.89 99.09,172.81
  L4 w0.292: 99.09,172.81 99.1,172.82 99.96,172.82 99.97,172.81 112.78,172.81 119.79,165.8 119.79,164.45 120.27,163.97 120.98,163.97 121.28,164.26 121.28,165.11 121.57,165.4 122.15,165.4 122.44,165.11 122.44,164.26 122.74,163.97 123.32,163.97 123.61,164.26 123.61,165.11 123.9,165.4 124.49,165.4 124.78,165.11 124.78,164.26 125.07,163.97 125.66,163.97 125.95,164.26 125.95,165.11 126.24,165.4 126.83,165.4 127.12,165.11 127.12,164.26 127.41,163.97 145.62,163.97 147.62,161.97 152.59,161.97 v4(152.74,161.82)
  BOTTOM w0.216: v2(151.38,162.54) 152.02,162.54 v4(152.74,161.82)
M_MAA_B13: length 77.4
  TOP w0.216: DIMM2.119 151.66,149.9 152.45,150.69 v4(152.45,150.86) ; v4(93.38,162.62) 93.87,163.11 CPU1.AR15
  L4 w0.102: 98.9,162 98.17,161.27 95.74,161.27 95.1,161.91 93.52,161.91 93.38,162.05 v4(93.38,162.62)
  L4 w0.292: 98.9,162 104.4,162 107.37,159.04 108.59,159.04 118.91,148.71 138.5,148.71 138.5,148.72 139.32,148.72 139.61,149.01 139.61,149.48 139.9,149.78 140.49,149.78 140.78,149.48 140.78,148.78 140.93,148.62 141.8,148.62 141.95,148.78 141.95,149.48 142.24,149.78 142.82,149.78 143.12,149.48 143.12,148.78 143.27,148.62 143.99,148.62 144.15,148.78 144.15,149.42 144.44,149.72 145.02,149.72 145.31,149.42 145.31,149.01 145.61,148.72 147.25,148.72 148.23,149.69 148.23,149.71 148.47,149.95 148.47,149.96 148.88,150.37 152.13,150.37 152.43,150.67 152.43,150.83 v4(152.45,150.86)
  BOTTOM w0.216: v4(152.45,150.86) 152.45,151.19 v2(151.76,151.88)
M_MAA_B14: length 72.5
  TOP w0.216: v4(152.26,165.08) 152.84,164.5 153.62,164.5 156.52,161.6 DIMM2.80 ; v4(97.11,174.52) 96.68,174.09 CPU1.AV27
  L4 w0.102: 101.1,175.02 97.6,175.02 v4(97.11,174.52)
  L4 w0.292: v4(152.26,165.08) 152.25,165.07 152.25,165.03 151.77,164.55 148.36,164.55 145.49,167.42 140.4,167.42 139.76,168.06 136.46,168.06 136.17,168.35 136.17,169.08 135.88,169.38 135.29,169.38 135,169.08 135,168.35 134.71,168.06 134.13,168.06 133.83,168.35 133.83,169.08 133.54,169.38 132.96,169.38 132.67,169.08 132.67,168.35 132.37,168.06 131.42,168.06 131.27,168.21 131.27,169.07 130.89,169.45 120.36,169.45 114.79,175.03 101.12,175.03 101.1,175.02
  BOTTOM w0.216: v4(152.26,165.08) v2(152.26,165.97)
M_MAA_B15: length 70.6
  TOP w0.216: v4(153.87,165.13) 153.87,164.78 156.45,162.2 DIMM2.78 ; v4(100.28,175.98) 100.28,175.55 99.74,175.01 CPU1.AY28
  L4 w0.292: v4(100.28,175.98) 115.29,175.98 119.84,171.43 132.31,171.43 132.61,171.14 132.61,170.7 132.9,170.41 133.48,170.41 133.78,170.7 133.78,171.14 134.07,171.43 134.65,171.43 134.94,171.14 134.94,170.7 135.24,170.41 135.82,170.41 136.11,170.7 136.11,171.14 136.4,171.43 137.38,171.43 137.67,171.14 137.67,169.72 137.96,169.43 139.78,169.43 140.64,168.56 146.05,168.56 148.97,165.64 153.37,165.64 v4(153.87,165.13)
  BOTTOM w0.216: v2(154.81,163.98) 153.87,164.91 v4(153.87,165.13)
M_ODT_A0: length 88
  TOP w0.165: v4(169.98,150.28) 170.5,150.8 DIMM1.116 ; v4(97.05,155.92) 96.62,156.35 CPU1.AW10
  L3 w0.229: v4(97.05,155.92) 97.62,156.49 132.43,156.49 143.65,145.26 159.03,145.26 159.47,145.7 159.47,146.02 158.76,146.73 158.76,147.11 159.03,147.38 159.4,147.38 160.12,146.67 160.44,146.67 164.05,150.28 168.65,150.28 168.83,150.1 168.83,149.55 169.13,149.26 169.68,149.26 169.98,149.55 v4(169.98,150.28)
  BOTTOM w0.165: v4(169.98,150.28) 170.18,150.48 v2(170.18,151.04)
M_ODT_A1: length 86.1
  TOP w0.165: CPU1.AY8 98.01,154.52 v4(98.43,154.1) ; v4(170.21,148.73) 171.08,149.6 DIMM1.120
  L3 w0.229: v4(170.21,148.73) 170.31,148.62 170.31,148.18 170.01,147.89 169.41,147.89 168.57,148.73 164.43,148.73 157.97,142.26 144.09,142.26 131.89,154.46 122.85,154.46 122.62,154.69 122.62,154.89 122.4,155.12 121.94,155.12 121.71,154.89 121.71,154.69 121.48,154.46 98.79,154.46 v4(98.43,154.1)
  BOTTOM w0.165: v2(170.48,147.99) 170.21,148.27 v4(170.21,148.73)
M_ODT_B0: length 80.5
  TOP w0.165: CPU1.AM17 v4(90.67,164.49) ; DIMM2.116 155.76,150.8 v4(155.75,150.8)
  L4 w0.102: 98.66,163.48 98.35,163.48 97.55,164.28 95.89,164.28 95.66,164.06 95.09,164.06 94.82,164.32 94.82,164.66 94.55,164.93 94.19,164.93 93.76,164.49 v4(90.67,164.49)
  L4 w0.229: 98.66,163.48 98.9,163.24 99.71,163.24 99.75,163.27 105.42,163.27 108.19,160.5 109.45,160.5 118.83,151.12 147.26,151.12 147.93,151.79 149.56,151.79 149.82,152.05 152.45,152.05 152.63,151.87 154.06,151.87 154.51,151.42 157.05,151.42 157.25,151.22 157.25,150.14 157,149.89 155.91,149.89 155.75,150.05 v4(155.75,150.8)
  BOTTOM w0.165: v4(155.75,150.8) 156.06,151.11 v2(156.72,151.11)
M_ODT_B1: length 78.9
  TOP w0.165: CPU1.AL16 90.21,164.02 v4(89.78,163.59) ; v4(154.31,149.94) 154.73,149.52 156.21,149.52 156.29,149.6 DIMM2.120
  L4 w0.102: v4(89.78,163.59) 91.14,162.22 91.14,161.58 91.4,161.33 91.75,161.33 91.89,161.47 94.56,161.47 95.16,160.86 98.39,160.86 98.85,161.32 99.44,161.32 99.62,161.15 99.95,161.15
  L4 w0.229: 99.95,161.15 103.58,161.15 112.29,152.43 112.33,152.4 113,152.4 113.24,152.63 113.76,152.63 118.66,147.73 147.64,147.73 149.21,149.31 154.23,149.31 154.46,149.54 154.46,149.79 v4(154.31,149.94)
  BOTTOM w0.165: v2(155.57,149.34) 154.92,149.34 v4(154.31,149.94)
M_RAS_A_N: length 86.6
  TOP w0.216: v4(168.66,151.14) 168.66,151.49 169.76,152.6 DIMM1.110 ; CPU1.AU12 95.69,160.37 v4(96.14,159.92)
  L3 w0.292: v4(168.66,151.14) 168.66,151.17 167.72,152.11 163.89,152.11 162.31,150.54 159.44,150.54 156.22,147.31 144.42,147.31 133.71,158.02 97.31,158.02 96.14,159.18 v4(96.14,159.92)
  BOTTOM w0.216: v4(168.66,151.14) v2(168.66,150.35)
M_RAS_B_N: length 81.8
  TOP w0.216: CPU1.AM18 91.12,165.81 v4(91.52,165.41) ; DIMM2.110 156.32,152.6 156.09,152.36 154.99,152.36 v4(154.77,152.58)
  L4 w0.102: v4(91.52,165.41) 91.91,165.41 93.27,166.76 93.57,166.76 93.9,167.09 95.35,167.09 95.88,166.57 96.44,166.57 96.68,166.81 99.37,166.81 99.96,166.23
  L4 w0.292: 99.96,166.23 100.64,165.54 107.22,165.54 119.17,153.59 129.65,153.59 130.56,154.5 142.13,154.5 143.04,153.59 148.7,153.59 149.08,153.98 152.43,153.98 153.09,154.64 154.25,154.64 154.41,154.49 154.41,153.73 154.79,153.35 156.16,153.35 156.51,152.99 156.51,152.33 156.16,151.98 154.92,151.98 154.77,152.13 v4(154.77,152.58)
  BOTTOM w0.216: v4(154.77,152.58) 155.51,152.58 v2(156.01,153.08)
M_SBS_A0: length 85.3
  TOP w0.216: CPU1.AV12 96.61,160.31 v4(97.03,159.9) ; DIMM1.109 165.49,152.9 165.64,153.05 166.05,153.05 v4(167.22,154.22)
  L3 w0.292: v4(167.22,154.22) 166.72,154.73 163.97,154.73 161.62,152.37 156.72,152.37 156.33,151.98 144.16,151.98 143.29,152.85 142.88,152.85 142.43,152.4 142.02,152.4 141.6,152.81 141.6,153.22 142.05,153.67 142.05,154.09 141.64,154.5 141.23,154.5 140.78,154.05 140.36,154.05 139.95,154.46 139.95,154.88 140.4,155.33 140.4,155.74 139.99,156.15 139.58,156.15 139.12,155.7 138.71,155.7 133.83,160.58 101.97,160.58 101.22,161.33 98.47,161.33 v4(97.03,159.9)
  BOTTOM w0.216: v2(167.77,155.18) 167.77,154.77 v4(167.22,154.22)
M_SBS_A1: length 81.7
  TOP w0.216: CPU1.AY11 98.52,159.46 98.98,159.92 v4(99.04,159.92) ; v4(170.18,153.81) 170.79,153.2 DIMM1.108
  L3 w0.292: v4(99.04,159.92) 99.22,159.74 99.22,159.71 100,158.92 134.12,158.92 143.79,149.25 155.87,149.25 158.1,151.48 161.99,151.48 163.65,153.15 169.52,153.15 v4(170.18,153.81)
  BOTTOM w0.216: v2(169.67,154.54) 169.67,154.31 v4(170.18,153.81)
M_SBS_A2: length 87.9
  TOP w0.216: v4(166.4,165.82) 166.4,164.19 165.54,163.34 165.54,162.12 165.32,161.9 DIMM1.79 ; CPU1.AT21 94.75,168.61 v4(94.3,168.16)
  L3 w0.102: v4(94.3,168.16) 94.74,167.73 96.04,167.73 97.77,169.46 97.77,169.7 98.13,170.06 98.48,170.06
  L3 w0.292: 98.48,170.06 99.16,170.06 99.45,170.35 115.75,170.35 117.38,168.73 122.82,168.73 123.11,169.02 123.11,170.02 123.41,170.32 124.04,170.32 124.33,170.02 124.33,169.11 124.63,168.82 125.29,168.82 125.58,169.11 125.58,170.04 126.01,170.47 137.36,170.47 139.1,168.73 139.1,168.73 141.61,166.22 156.69,166.22 157.45,165.46 164.21,165.46 164.41,165.27 165.85,165.27 166.4,165.81 v4(166.4,165.82)
  BOTTOM w0.216: v4(166.4,165.82) 166.4,165.39 v2(165.62,164.61)
M_SBS_B0: length 78
  TOP w0.216: v4(152.32,153.43) 151.8,152.9 DIMM2.109 ; CPU1.AK17 v4(88.84,164.49)
  L4 w0.102: 99.88,165.04 99.52,165.4 98.59,165.4 98.19,165.81 97.83,165.81 97.58,165.56 97.58,165.25 97.25,164.92 96.89,164.92 96.64,165.18 96.64,165.55 96.32,165.87 95.05,165.87 94.75,166.18 94.75,166.43 94.49,166.69 94.14,166.69 93.88,166.43 93.88,166.15 93.59,165.86 93.14,165.86 92.25,164.97 89.32,164.97 v4(88.84,164.49)
  L4 w0.292: v4(152.32,153.43) 152.32,153.38 151.87,152.92 149.46,152.92 149.2,152.66 147.57,152.66 146.9,151.99 130.95,151.99 130.35,152.59 118.59,152.59 106.91,164.27 100.65,164.27 99.88,165.04
  BOTTOM w0.216: v4(152.32,153.43) 152.32,154.45 v2(152.59,154.72)
M_SBS_B1: length 78.2
  TOP w0.216: v4(90.7,166.31) 90.26,165.86 CPU1.AL18 ; v4(155.1,154) 155.9,153.2 DIMM2.108
  L4 w0.102: 99.68,167.06 96.61,167.06 96.32,166.77 95.97,166.77 95.43,167.31 93.89,167.31 93.57,167.63 93.16,167.63 92.29,166.76 91.16,166.76 v4(90.7,166.31)
  L4 w0.292: v4(155.1,154) 155.17,154 155.63,154.46 155.63,154.95 155.47,155.1 152.77,155.1 152.1,154.43 148.91,154.43 148.51,154.03 143.23,154.03 142.31,154.95 130.38,154.95 129.46,154.03 119.35,154.03 107.4,165.99 100.75,165.99 99.68,167.06
  BOTTOM w0.216: v2(155.57,154.85) 155.57,154.83 155.1,154.36 v4(155.1,154)
M_SBS_B2: length 72.5
  TOP w0.216: v4(151.42,163.93) 151.42,163.23 150.09,161.9 DIMM2.79 ; CPU1.AW28 97.95,174.58 v4(100.39,174.58)
  L4 w0.292: v4(151.42,163.93) 151.41,163.93 151.34,163.85 148.36,163.85 145.34,166.87 144.68,166.87 144.38,166.58 144.38,166.19 144.09,165.9 143.51,165.9 143.22,166.19 143.22,166.58 142.92,166.87 140.32,166.87 139.77,167.42 130.98,167.42 130.68,167.71 130.68,168.47 130.39,168.77 129.81,168.77 129.51,168.47 129.51,167.71 129.22,167.42 128.64,167.42 128.35,167.71 128.35,168.47 128.05,168.77 127.47,168.77 127.18,168.47 127.18,167.71 126.89,167.42 126.3,167.42 126.01,167.71 126.01,168.47 125.72,168.77 125.13,168.77 124.84,168.47 124.84,167.71 124.55,167.42 123.96,167.42 123.67,167.71 123.67,168.47 123.38,168.77 122.8,168.77 122.5,168.47 122.5,167.71 122.21,167.42 121.77,167.42 114.6,174.58 100.39,174.58 v4(100.39,174.58)
  BOTTOM w0.216: v4(151.42,163.93) 150.32,163.93 v2(150.25,163.86)
M_SCKE_A0: length 87.8
  TOP w0.165: v4(97.29,169.59) 97.22,169.52 CPU1.AV22 ; DIMM1.73 165.21,163.7 165.48,163.97 165.48,165.19 v4(164.87,165.8)
  L3 w0.102: v4(97.29,169.59) 98.16,170.46 98.16,170.46 98.88,171.18 99.54,171.18 99.8,170.93 100.43,170.93
  L3 w0.229: v4(164.87,165.8) 164.76,165.91 157.64,165.91 156.88,166.67 150.18,166.67 149.95,166.9 149.95,167.14 149.72,167.37 149.26,167.37 149.04,167.14 149.04,166.9 148.81,166.67 148.35,166.67 148.12,166.9 148.12,167.14 147.89,167.37 147.44,167.37 147.21,167.14 147.21,166.9 146.98,166.67 146.52,166.67 146.29,166.9 146.29,167.14 146.06,167.37 145.61,167.37 145.38,167.14 145.38,166.9 145.15,166.67 144.69,166.67 144.46,166.9 144.46,167.14 144.24,167.37 143.78,167.37 143.55,167.14 143.55,166.9 143.32,166.67 141.8,166.67 139.29,169.18 139.29,169.18 137.54,170.93 122.57,170.93 122.34,170.7 122.34,169.47 122.07,169.2 121.69,169.2 121.42,169.47 121.42,170.7 121.19,170.93 120.74,170.93 120.51,170.7 120.51,169.42 120.27,169.18 119.83,169.18 119.59,169.42 119.59,170.7 119.37,170.93 118.91,170.93 118.68,170.7 118.68,169.47 118.41,169.2 118.03,169.2 117.77,169.47 117.77,170.7 117.54,170.93 100.43,170.93
  BOTTOM w0.165: v4(164.87,165.8) 164.81,165.73 v2(163.95,165.73)
M_SCKE_A1: length 91.3
  TOP w0.165: CPU1.AT23 94.78,170.44 v4(95.24,170.9) ; DIMM1.74 171.31,163.4 171.07,163.64 v4(171.07,165.06)
  L3 w0.229: v4(95.24,170.9) 96.57,172.22 97.21,172.22 98.12,173.13 99.28,173.13 99.4,173.26 100.77,173.26 101.52,172.51 137.97,172.51 141.66,168.81 145.56,168.81 145.79,169.04 145.79,169.62 146.06,169.88 146.44,169.88 146.71,169.62 146.71,169.04 146.93,168.81 147.44,168.81 147.67,169.04 147.67,169.64 147.94,169.91 148.32,169.91 148.59,169.64 148.59,169.04 148.82,168.81 149.27,168.81 149.5,169.04 149.5,169.64 149.77,169.91 150.15,169.91 150.42,169.64 150.42,169.04 150.65,168.81 151.1,168.81 151.33,169.04 151.33,169.4 151.56,169.63 152.02,169.63 152.25,169.4 152.25,169.04 152.47,168.81 156.64,168.81 158.2,167.26 168.87,167.26 v4(171.07,165.06)
  BOTTOM w0.165: v2(172.44,165.92) 171.93,165.92 v4(171.07,165.06)
M_SCKE_B0: length 70.8
  TOP w0.165: DIMM2.73 150.18,163.7 150.46,163.98 150.46,164.75 v4(150.8,165.09) ; CPU1.AW29 v4(97.97,175.47)
  L4 w0.102: 100.66,175.47 v4(97.97,175.47)
  L4 w0.203: 100.66,175.47 100.66,175.47
  L4 w0.229: 100.66,175.47 100.67,175.48 115.11,175.48 120.62,169.96 121.04,169.96 121.27,170.19 121.27,170.72 121.5,170.95 121.96,170.95 122.19,170.72 122.19,170.19 122.42,169.96 122.87,169.96 123.1,170.19 123.1,170.75 123.33,170.98 123.79,170.98 124.02,170.75 124.02,170.19 124.24,169.96 124.7,169.96 124.93,170.19 124.93,170.72 125.16,170.95 125.62,170.95 125.84,170.72 125.84,170.19 126.07,169.96 126.56,169.96 126.79,170.19 126.79,170.75 127.02,170.98 127.48,170.98 127.7,170.75 127.7,170.19 127.93,169.96 128.39,169.96 128.62,170.19 128.62,170.75 128.85,170.98 129.3,170.98 129.53,170.75 129.53,170.19 129.76,169.96 130.48,169.96 130.71,170.19 130.71,170.72 130.94,170.95 131.32,170.95 131.55,170.72 131.55,170.19 131.78,169.96 136.42,169.96 137.68,168.7 139.87,168.7 140.49,168.08 145.82,168.08 148.77,165.13 150.72,165.13 150.77,165.09 v4(150.8,165.09)
  BOTTOM w0.165: v4(150.8,165.09) 150.3,165.59 v2(149.48,165.59)
M_SCKE_B1: length 69.5
  TOP w0.165: v4(155.5,165.16) 155.5,164.35 156.45,163.4 DIMM2.74 ; CPU1.AY29 99.31,175.92 v4(99.76,176.38)
  L4 w0.229: v4(155.5,165.16) 155.5,165.52 155.73,165.74 155.93,165.74 156.16,165.97 156.16,166.38 155.93,166.61 154.74,166.61 154.23,166.09 149.16,166.09 146.24,169.01 140.95,169.01 140.08,169.88 138.61,169.88 138.43,170.06 138.43,171.17 137.72,171.88 120.06,171.88 115.47,176.47 99.86,176.47 v4(99.76,176.38)
  BOTTOM w0.165: v4(155.5,165.16) 155.99,164.67 156.35,164.67 v2(156.74,164.29)
M_SCS_A_N0: length 87.7
  TOP w0.165: DIMM1.114 170.74,151.4 v4(170.14,152) ; CPU1.AU14 95.77,162.21 v4(96.16,162.6)
  L3 w0.102: v4(96.16,162.6) 96.6,162.17 96.6,159.72 96.89,159.42 97.48,159.42 97.66,159.24
  L3 w0.229: v4(170.14,152) 170.13,151.99 170.13,151.7 169.96,151.53 169.23,151.53 168.2,152.56 163.7,152.56 162.13,150.99 158.5,150.99 156.31,148.8 143.56,148.8 133.89,158.47 98.43,158.47 97.66,159.24
  BOTTOM w0.165: v4(170.14,152) 169.42,152.72 v2(169.42,152.76)
M_SCS_A_N1: length 88.8
  TOP w0.165: v4(96.16,155.91) 95.69,155.45 CPU1.AV9 ; DIMM1.121 v4(165.83,149.3)
  L3 w0.229: v4(96.16,155.91) 96.16,155.58 96.45,155.29 97.27,155.29 97.4,155.42 98.84,155.42 98.96,155.54 123.62,155.54 123.84,155.31 123.84,155.11 124.07,154.88 124.53,154.88 124.76,155.11 124.76,155.31 124.99,155.54 125.45,155.54 125.67,155.31 125.67,155.11 125.9,154.88 126.36,154.88 126.59,155.11 126.59,155.31 126.82,155.54 127.27,155.54 127.5,155.31 127.5,155.11 127.73,154.88 128.19,154.88 128.42,155.11 128.42,155.31 128.65,155.54 129.1,155.54 129.33,155.31 129.33,155.11 129.56,154.88 130.02,154.88 130.25,155.11 130.25,155.31 130.47,155.54 131.64,155.54 143.76,143.42 145.17,143.42 145.4,143.19 145.4,142.91 145.62,142.68 146.08,142.68 146.31,142.91 146.31,143.19 146.54,143.42 147,143.42 147.22,143.19 147.22,142.91 147.45,142.68 147.91,142.68 148.14,142.91 148.14,143.19 148.37,143.42 148.82,143.42 149.05,143.19 149.05,142.91 149.28,142.68 149.74,142.68 149.97,142.91 149.97,143.19 150.2,143.42 150.65,143.42 150.88,143.19 150.88,142.91 151.11,142.68 151.57,142.68 151.8,142.91 151.8,143.19 152.03,143.42 156.37,143.42 156.6,143.19 156.6,142.97 156.87,142.71 157.25,142.71 157.51,142.97 157.51,143.19 157.74,143.42 158.53,143.42 164.41,149.3 v4(165.83,149.3)
  BOTTOM w0.165: v2(166.24,150.22) 166.24,149.72 v4(165.83,149.3)
M_SCS_B_N0: length 79.5
  TOP w0.165: DIMM2.114 154.37,151.4 v4(153.25,152.53) ; CPU1.AP17 92.99,164.95 v3(93.41,165.38)
  L4 w0.102: 100.07,164.3 100.07,164.33 99.48,164.92 97.53,164.92 97.33,164.72 95.84,164.72 95.61,164.95 95.12,164.95 94.82,165.25 94.82,165.53 94.54,165.81 93.85,165.81 v3(93.41,165.38)
  L4 w0.229: 100.07,164.3 100.63,163.74 106.8,163.74 107.1,163.44 107.1,163.12 106.82,162.83 106.82,162.51 107.14,162.19 107.46,162.19 107.75,162.47 108.07,162.47 108.37,162.17 108.37,161.85 108.08,161.57 108.08,161.24 108.41,160.92 108.73,160.92 109.02,161.2 109.34,161.2 119.01,151.53 119.42,151.53 119.64,151.76 119.64,151.91 119.87,152.14 120.33,152.14 120.56,151.91 120.56,151.76 120.79,151.53 121.24,151.53 121.47,151.76 121.47,151.91 121.7,152.14 122.16,152.14 122.39,151.91 122.39,151.76 122.62,151.53 123.07,151.53 123.3,151.76 123.3,151.91 123.53,152.14 123.99,152.14 124.22,151.91 124.22,151.76 124.45,151.53 124.9,151.53 125.13,151.76 125.13,151.91 125.36,152.14 125.82,152.14 126.05,151.91 126.05,151.76 126.27,151.53 126.95,151.53 127.17,151.76 127.17,151.85 127.4,152.08 127.87,152.08 128.1,151.85 128.1,151.76 128.33,151.53 129.03,151.53 129.26,151.76 129.26,151.85 129.49,152.08 130.22,152.08 130.77,151.53 147.08,151.53 147.76,152.21 149.39,152.21 149.65,152.47 152.06,152.47 152.35,152.76 153.01,152.76 v4(153.25,152.53)
  BOTTOM w0.165: v2(154.05,153.42) 154.05,153.42 154.05,153.33 v4(153.25,152.53)
M_SCS_B_N1: length 81.8
  TOP w0.165: CPU1.AN15 92.04,163.05 v4(91.6,162.61) ; v4(152.77,149.93) 152.14,149.3 DIMM2.121
  L4 w0.102: v4(91.6,162.61) 92.54,161.68 94.63,161.68 95.25,161.07 98.28,161.07 98.77,161.55 99.74,161.55
  L4 w0.229: v4(152.77,149.93) 152.66,149.82 149.13,149.82 147.46,148.15 118.84,148.15 113.66,153.33 113.34,153.33 112.83,152.82 112.5,152.82 112.47,152.85 112.16,153.16 112.16,153.45 112.69,153.98 112.69,154.3 112.37,154.62 112.04,154.62 111.48,154.06 111.27,154.06 110.83,154.49 110.83,154.7 111.4,155.27 111.4,155.59 111.09,155.9 110.77,155.9 110.26,155.4 109.94,155.4 109.62,155.72 109.62,156.04 110.15,156.57 110.15,156.84 109.77,157.22 109.5,157.22 108.96,156.68 108.64,156.68 108.31,157.01 108.31,157.32 108.85,157.86 108.85,158.14 108.47,158.52 108.19,158.52 107.66,157.99 107.35,157.99 103.79,161.55 99.74,161.55
  BOTTOM w0.165: v4(152.77,149.93) 152.35,149.93 151.89,149.47 v2(151.89,149.46)
M_WE_A_N: length 85.3
  TOP w0.216: v4(167.18,151.19) 166.67,151.7 DIMM1.113 ; CPU1.AU11 95.34,159.81 95.29,159.81 v4(95.25,159.86)
  L3 w0.292: v4(167.18,151.19) 166.71,151.67 164.07,151.67 161.87,149.46 159.14,149.46 155.83,146.16 144.78,146.16 133.48,157.46 97.31,157.46 95.25,159.53 v4(95.25,159.86)
  BOTTOM w0.216: v2(167.26,152.38) 167.26,151.27 v4(167.18,151.19)
M_WE_B_N: length 79.3
  TOP w0.216: DIMM2.113 153.45,151.7 v4(154.23,150.92) ; v4(89.73,164.45) 89.31,164.03 CPU1.AK16
  L4 w0.102: 99.12,162.82 98.74,162.82 98.43,163.13 96.91,163.13 96.58,163.45 96.58,163.83 96.33,164.08 95.97,164.08 95.72,163.83 95.72,163.46 95.38,163.13 95.03,163.13 94.77,163.38 94.77,163.72 94.5,164 90.17,164 v4(89.73,164.45)
  L4 w0.292: v4(154.23,150.92) 153.73,151.42 152.44,151.42 152.26,151.6 150.01,151.6 149.75,151.34 148.12,151.34 147.44,150.66 118.65,150.66 109.26,160.05 108.01,160.05 105.23,162.82 99.12,162.82
  BOTTOM w0.216: v4(154.23,150.92) 154.23,151.11 153.71,151.62 153.59,151.62 v2(153.56,151.66)
MAA0: length 57.7
  TOP w0.102: MEM2.N3 54.13,82.93 53.84,82.93 53.73,83.03 v4(53.73,83.31) ; v4(52.76,96.3) 52.55,96.51 51.8,96.51 51.64,96.35 51.64,96.12 51.55,96.02 51.36,96.02 51.35,96.02 MEM1.N3 ; v1(58.19,90.6) 57.44,90.6 v4(57.35,90.51) ; U13.K17 75.29,88.54 75.41,88.41 75.41,88.09 75.29,87.97 v4(75.14,87.97)
  L3 w0.127: v4(75.14,87.97) 75.14,88.09 74.8,88.43 73.94,88.43 73.81,88.55 73.36,88.55 73.23,88.43 72.62,88.43 72.39,88.66 71.98,88.66 71.86,88.78 71.53,88.78 71.4,88.66 70.97,88.66 70.65,88.97 70.65,89.34 70.52,89.47 70.27,89.47 70.14,89.34 70.14,88.97 70,88.83 68.75,88.83 68.53,89.05 65.87,89.05 65.46,89.47 63.84,89.47 63.71,89.34 63.71,88.93 63.58,88.81 63.33,88.81 63.2,88.93 63.2,89.54 63.07,89.67 62.82,89.67 62.69,89.54 62.69,88.93 62.57,88.81 62.31,88.81 62.19,88.93 62.19,89.52 62.06,89.65 61.8,89.65 61.68,89.52 61.68,88.93 61.55,88.81 61.3,88.81 61.17,88.93 61.17,89.49 61.04,89.62 60.79,89.62 60.66,89.49 60.66,88.93 60.53,88.81 60.28,88.81 60.15,88.93 60.15,89.5 60.03,89.63 59.87,89.63 59.74,89.5 59.34,89.5 59.2,89.63 58.99,89.63 58.72,89.9 58.72,90.46 58.6,90.59 58.24,90.59 58.12,90.46 58.12,90.08 57.99,89.95 57.35,89.95 57.23,90.08 57.23,90.38 v4(57.35,90.51)
  L4 w0.127: v4(53.73,83.31) 53.52,83.31 53.39,83.44 53.39,83.63 53.93,84.17 53.93,84.17 54.81,85.05 54.81,85.94 57.09,88.21 57.4,88.21 57.51,88.31 57.51,88.76 57.4,88.86 57.23,88.86 57.12,88.96 57.12,89.29 57.23,89.39 57.47,89.39 57.57,89.49 57.57,90.29 v4(57.35,90.51) 57.53,90.51 57.66,90.64 57.66,91.15 57.53,91.27 57.38,91.27 57.25,91.4 57.25,91.58 57.38,91.71 57.53,91.71 57.66,91.83 57.66,92.01 57.53,92.14 57.38,92.14 57.25,92.26 57.25,92.44 57.48,92.67 57.48,92.95 56.82,93.61 55.41,93.61 55.16,93.86 55.16,94.69 53.82,96.03 53.78,96.03 53.53,96.28 53.53,96.53 53.4,96.66 52.86,96.66 52.76,96.56 v4(52.76,96.3)
  BOTTOM w0.102: MEM3.N3 54.13,95.79 53.91,95.79 53.25,96.45 52.91,96.45 v4(52.76,96.3) ; v4(53.73,83.31) 53.48,83.56 51.68,83.56 51.28,83.16 MEM4.N3
MAA1: length 55.6
  TOP w0.102: v4(52.48,84.89) 52.27,84.89 51.35,83.96 MEM2.P7 ; MEM1.P7 53.47,95.22 53.09,94.84 v4(53.09,94.34) ; v4(72.9,91.45) 73.3,91.45 73.34,91.41 73.35,91.41 73.82,90.94 U13.J20
  L3 w0.127: v4(72.9,91.45) 72.45,91.89 71.7,91.89 71.66,91.93 71.02,91.93 71.02,91.94 68.51,91.94 68.49,91.92 68.14,91.92 68.13,91.93 67.99,91.93 67.88,92.05 67.88,92.06 67.75,92.19 61.99,92.19 61.77,91.97 56.81,91.97 56.21,91.37 54.36,91.37 54,91.73 52.71,91.73 52.15,91.18 51.57,91.18 51.31,90.92 51.31,90.5 51.03,90.22 50.09,90.22 49.02,91.28 49.02,92.41 49.15,92.54 50.34,92.54 50.47,92.41 50.47,91.41 50.34,91.28 v3(50.01,91.28)
  L4 w0.127: v4(52.48,84.89) 50.32,87.05 50.32,90.37 50.01,90.68 v3(50.01,91.28) 49.59,91.7 49.59,93.27 50.2,93.88 50.2,94.26 50.81,94.87 51.22,94.87 51.32,94.97 51.32,95.25 51.42,95.35 51.77,95.35 51.87,95.25 51.87,95.01 52.12,94.77 52.36,94.77 52.79,94.34 v4(53.09,94.34)
  BOTTOM w0.102: v4(53.09,94.34) 52.95,94.34 52.53,94.76 52.23,94.76 52.23,94.76 52.12,94.76 51.66,95.22 MEM3.P7 ; v3(50.01,91.28) 49.34,91.28 v2(49.19,91.44) ; v4(52.48,84.89) 52.84,84.52 53.57,84.52 54.13,83.96 MEM4.P7
MAA2: length 54.6
  TOP w0.102: U13.H23 73.63,92.86 v4(73.63,92.67) ; v4(53.19,84.97) 52.97,84.76 52.97,84.61 53.06,84.52 53.39,84.52 53.78,84.12 54.2,84.12 MEM2.P3 ; v4(52.29,95.18) 52.11,95.37 51.82,95.37 51.73,95.27 51.73,95.09 51.62,94.99 51.4,94.99 MEM1.P3
  L3 w0.127: v4(55.04,91.79) 55.04,91.73 55.17,91.6 55.91,91.6 56.54,92.24 56.54,92.63 56.67,92.76 56.97,92.76 57.1,92.63 57.1,92.39 57.23,92.26 57.48,92.26 57.61,92.39 57.61,92.63 57.73,92.76 57.99,92.76 58.12,92.63 58.12,92.4 58.24,92.27 58.58,92.27 58.67,92.36 58.67,92.64 58.79,92.76 59.02,92.76 59.15,92.63 59.39,92.39 61.28,92.39 61.28,92.39 61.62,92.39 62.3,93.07 62.64,93.07 62.84,92.87 62.84,92.69 62.94,92.59 63.37,92.59 63.47,92.69 63.47,92.95 63.6,93.07 64.16,93.07 64.29,92.95 64.29,92.72 64.41,92.59 64.95,92.59 65.07,92.72 65.07,92.95 65.2,93.07 65.61,93.07 65.74,92.95 65.74,92.72 65.86,92.59 66.66,92.59 66.84,92.78 68.71,92.78 68.83,92.65 68.83,92.39 68.96,92.26 69.49,92.26 69.62,92.39 69.62,92.65 69.75,92.78 70.41,92.78 70.54,92.65 70.54,92.29 70.66,92.17 71.62,92.17 71.63,92.16 71.76,92.16 71.8,92.12 72.77,92.12 72.96,91.93 73.45,91.93 73.76,92.25 73.76,92.54 v4(73.63,92.67)
  L4 w0.127: v4(53.19,84.97) 53.19,85.29 53.29,85.39 53.88,85.39 53.97,85.48 53.97,86.37 55.89,88.3 55.89,90.4 55.79,90.5 55.67,90.5 55.55,90.62 55.55,90.79 55.67,90.9 55.81,90.9 55.92,91.01 55.92,91.21 55.81,91.31 55.14,91.31 55.04,91.41 v4(55.04,91.79) 55.51,91.79 55.55,91.75 55.93,91.75 56.06,91.88 56.06,92.01 55.86,92.21 55.41,92.21 55.31,92.31 55.31,92.56 55.2,92.66 54.93,92.66 54.82,92.56 54.82,92.28 54.74,92.2 54.32,92.2 54.06,92.45 53.64,92.45 53.52,92.58 53.52,92.72 53.79,92.99 53.92,92.99 54.28,93.34 54.28,93.52 54.13,93.67 53.95,93.67 53.79,93.51 53.65,93.51 53.37,93.79 53.37,93.94 53.62,94.19 53.62,94.64 53.49,94.76 52.72,94.76 v4(52.29,95.18)
  BOTTOM w0.102: MEM4.P3 51.96,84.76 51.96,84.97 52.3,85.31 52.85,85.31 v4(53.19,84.97) ; v4(52.29,95.18) 52.41,95.18 52.83,94.77 53.82,94.77 54.27,95.22 MEM3.P3 ; v4(55.04,91.79) 55.56,91.79 v2(55.79,91.56)
MAA3: length 59.4
  TOP w0.102: U13.G23 72.2,92.79 v4(72.15,92.79) ; MEM1.N2 50.54,96.02 50.67,96.15 50.67,96.37 50.57,96.47 50.53,96.49 50.23,96.49 50.22,96.49 50.02,96.49 49.9,96.37 49.9,95.7 50.02,95.57 51.72,95.57 51.78,95.63 52.57,95.63 v4(52.92,95.28) ; v4(52.5,83.99) 53.01,83.62 53.34,83.62 53.67,83.73 53.92,83.73 MEM2.N2
  L3 w0.127: v4(55.77,92.63) 55.22,92.63 55.09,92.75 55.09,93 54.97,93.13 53.9,93.13 53.77,93.25 53.77,94.17 53.9,94.29 55.03,94.29 55.16,94.17 55.16,93.86 55.41,93.61 56.69,93.61 56.79,93.71 57.12,93.71 57.33,93.51 57.71,93.51 57.91,93.71 58.29,93.71 58.47,93.53 58.8,93.53 58.98,93.71 59.23,93.71 59.36,93.58 59.36,93.57 59.72,93.21 61.28,93.21 61.65,93.57 61.65,93.77 61.77,93.89 64.7,93.89 65.1,94.29 65.54,94.29 65.89,93.94 66.16,93.94 66.53,93.57 66.72,93.57 66.96,93.33 69.06,93.33 69.11,93.28 71.66,93.28 v4(72.15,92.79)
  L4 w0.127: v4(52.5,83.99) 52.99,84.48 53.28,84.48 53.97,85.16 53.98,85.16 54.2,85.38 54.2,86.28 54.51,86.59 54.6,86.59 56.39,88.38 56.39,92 v4(55.77,92.63) 56.12,92.63 56.22,92.73 56.22,93.01 56.09,93.14 55.57,93.14 55.45,93.01 55.45,93.01 55.32,92.89 54.83,92.89 54.47,92.52 54.32,92.52 54.16,92.68 54.16,92.83 54.61,93.28 54.76,93.43 54.76,93.62 54.62,93.75 54.45,93.75 54.34,93.86 54.34,94 54.56,94.22 54.56,94.38 54.44,94.5 54.27,94.5 54.26,94.49 54,94.49 53.87,94.62 53.87,94.8 53.92,94.85 53.92,95.03 53.76,95.18 53.59,95.18 53.4,94.99 53.21,94.99 52.92,95.28 v4(52.92,95.28)
  BOTTOM w0.102: v4(52.92,95.28) 52.92,95.1 53.05,94.97 53.68,94.97 53.78,95.07 53.78,95.43 53.91,95.55 54.61,95.55 54.73,95.68 54.73,95.83 54.71,95.86 54.71,96.2 54.99,96.49 55.3,96.49 55.43,96.62 55.68,96.62 55.78,96.52 55.78,96.3 55.63,96.16 55.63,96.15 55.51,96.02 55.39,96.02 55.38,96.02 MEM3.N2 ; v4(52.5,83.99) 51.75,83.99 51.35,83.58 50.79,83.58 MEM4.N2
MAA4: length 58.6
  TOP w0.102: v4(52.8,85.84) 52.78,85.84 51.32,84.39 51.05,84.39 50.63,83.96 MEM2.P8 ; U13.G24 72.16,93.55 72.16,93.5 v4(72.15,93.49) ; MEM1.P8 55.31,95.08 55.31,94.89 55.2,94.79 54.19,94.79 53.98,95 53.79,95 53.59,94.8 53.59,94.66 53.88,94.36 53.88,94.24 53.53,93.88 53.23,93.88 53.11,93.76 53.11,93.62 53.11,93.62 53.11,93.29 53.24,93.15 v4(53.36,93.15)
  L3 w0.127: v4(72.15,93.49) 72.03,93.61 71.39,93.61 71.32,93.54 70.97,93.54 70.91,93.61 67.08,93.61 66.34,94.35 66.06,94.35 65.2,95.2 64.79,95.2 64.66,95.08 64.66,94.68 64.66,94.43 64.54,94.3 61.35,94.3 61.24,94.19 61.24,93.74 61.11,93.61 59.89,93.61 59.77,93.74 59.77,93.9 59.64,94.02 59.55,94.12 57.07,94.12 56.95,94.24 56.95,94.4 56.82,94.52 53.64,94.52 53.52,94.4 53.52,93.99 53.39,93.86 52.46,93.86 52.45,93.85 51.06,93.85 50.93,93.72 v3(50.93,91.71)
  L4 w0.127: v4(53.36,93.15) 53.2,93.15 53.1,93.25 53.1,93.82 53,93.93 52.53,93.93 52.3,93.7 51.95,93.7 51.85,93.8 51.85,94.08 51.75,94.18 51.5,94.18 51.39,94.08 51.39,93.93 51.29,93.83 51.03,93.83 50.93,93.72 v3(50.93,91.71) 51.04,91.6 51.04,90.98 51.21,90.81 51.21,88.53 50.91,88.22 50.91,87.29 52.06,86.15 52.49,86.15 v4(52.8,85.84)
  BOTTOM w0.102: v4(72.15,93.49) 72.15,93.53 71.31,94.37 71.27,94.37 70.43,94.37 v2(70.28,94.22) ; v4(53.36,93.15) 53.2,92.99 52.53,92.99 52.29,93.24 51.88,93.24 51.78,93.34 51.78,93.55 51.9,93.67 51.9,94.02 51.78,94.15 51.78,94.67 51.67,94.77 50.47,94.77 50.36,94.87 MEM3.P8 ; v4(52.8,85.84) 52.92,85.84 53.69,85.08 53.69,84.94 54.27,84.37 54.76,84.37 MEM4.P8
MAA5: length 57.1
  TOP w0.102: MEM1.P2 50.12,94.98 50.12,94.87 50.22,94.77 52.09,94.77 52.27,94.58 v4(52.27,94.26) ; U13.H24 72.94,93.53 v4(72.92,93.53) ; v4(50.8,90.64) 51.39,90.05 v1(51.39,90.05) ; MEM2.P2 55.16,84.25 55,84.41 53.9,84.41 53.7,84.61 53.7,85.29 53.55,85.44 v4(53.55,85.87)
  L3 w0.127: v4(50.8,90.64) 50.8,90.95 51.5,91.65 51.5,91.71 51.84,92.05 53.01,92.05 53.13,92.17 53.13,92.57 53.26,92.69 54.83,92.69 55.32,92.21 55.94,92.21 56.19,92.45 56.19,93.02 56.39,93.23 59.13,93.23 59.56,92.8 61.45,92.8 62.14,93.49 64.87,93.49 65.02,93.63 65.62,93.63 66.09,93.17 66.72,93.17 66.88,93.01 71.38,93.01 71.62,92.76 71.62,92.72 71.98,92.37 72.32,92.37 72.57,92.61 72.57,93.18 v4(72.92,93.53)
  L4 w0.127: v4(52.27,94.26) 52.08,94.46 51.01,94.46 50.6,94.04 50.6,93.34 50.47,93.22 50.05,93.22 49.92,93.09 49.92,92.86 50.05,92.73 50.47,92.73 50.6,92.61 50.6,92.4 50.47,92.28 50.05,92.28 49.92,92.15 49.92,91.95 50.05,91.82 50.35,91.82 50.47,91.69 50.47,90.76 50.6,90.64 v4(50.8,90.64) 50.8,88.53 50.66,88.39 50.66,87.22 52.48,85.4 52.94,85.4 53.42,85.87 v4(53.55,85.87)
  BOTTOM w0.102: MEM3.P2 54.75,94.8 54.19,94.8 53.31,93.92 52.62,93.92 v4(52.27,94.26) ; v4(53.55,85.87) 53.46,85.87 53.06,86.27 52.62,86.27 51.83,85.48 51.83,85.28 51.66,85.11 51.66,84.76 51.28,84.39 50.79,84.39 MEM4.P2
MAA6: length 72.3
  TOP w0.102: v4(74.27,90.32) 74.49,90.32 74.62,90.2 74.62,89.77 74.49,89.65 74.24,89.65 U13.J19 ; MEM2.R8 50.68,84.76 50.79,84.86 50.79,85.81 50.89,85.91 51.33,85.91 51.46,86.04 51.46,86.31 51.35,86.41 50.89,86.41 50.79,86.51 50.79,86.79 50.89,86.89 51.31,86.89 51.41,86.99 51.41,87.17 51.51,87.27 51.92,87.27 52.19,87 52.65,87 52.74,86.9 52.74,86.41 52.84,86.31 53.23,86.31 53.33,86.41 53.33,86.96 53.58,87.21 53.69,87.32 53.69,87.46 53.45,87.71 53.31,87.71 v4(53.11,87.51) ; v4(51.98,91.59) 52.29,91.9 54.44,91.9 54.54,91.8 v1(54.54,91.09) 54.54,91.02 54.67,90.89 55.75,90.89 55.88,91.02 55.88,92.07 55.75,92.2 54.93,92.2 54.74,92.39 54.74,92.52 54.66,92.59 54.33,92.59 54.25,92.67 54.25,93 54.33,93.07 54.58,93.07 54.74,93.23 54.74,93.99 MEM1.R8
  L3 w0.127: v4(53.22,89.86) 53.09,89.86 52.96,89.99 52.96,90.38 53.09,90.51 53.9,90.51 54.18,90.79 56.57,90.79 57,91.22 58.7,91.22 58.76,91.16 58.94,91.16 59.48,90.61 59.72,90.61 59.87,90.76 59.87,91.04 59.98,91.16 60.4,91.16 60.52,91.04 60.52,90.8 60.83,90.48 62.47,90.48 62.91,90.92 63.18,90.92 63.63,90.47 64.48,90.47 64.64,90.31 70.61,90.31 70.89,90.03 71.3,90.03 71.45,90.18 71.81,90.18 71.96,90.03 74.04,90.03 74.27,90.26 v4(74.27,90.32)
  L4 w0.127: v4(53.11,87.51) 53.11,87.75 53.01,87.86 52.22,87.86 52.12,87.96 52.12,88.95 52.22,89.05 52.72,89.05 52.9,89.24 52.9,89.77 53,89.86 v4(53.22,89.86) 53.22,90.22 53.32,90.32 53.57,90.32 53.66,90.42 53.66,90.69 53.41,90.95 53.24,90.95 52.98,90.69 52.63,90.69 52.38,90.94 51.93,90.94 51.83,91.04 51.83,91.44 v4(51.98,91.59)
  BOTTOM w0.102: MEM4.R8 54.82,84.76 54.72,84.86 54.72,85.81 54.62,85.91 54.31,85.91 54.21,86 54.21,86.28 54.32,86.38 55.17,86.38 55.3,86.51 55.3,86.71 55.17,86.84 54.37,86.84 54.24,86.97 54.24,87.15 54.37,87.27 55.22,87.27 55.35,87.4 55.35,87.84 55.22,87.97 53.83,87.97 53.71,87.84 53.71,87.37 53.6,87.27 53.35,87.27 v4(53.11,87.51) ; v4(51.98,91.59) 51.5,91.59 51.39,91.49 51.39,90.37 51.24,90.21 51.24,90.19 50.49,90.19 50.36,90.32 50.36,90.83 50.62,91.08 50.62,91.38 50.02,91.99 50.02,92.46 49.88,92.6 49,92.6 48.87,92.73 48.87,93.03 49,93.16 49.87,93.16 49.97,93.26 49.97,94.32 50.07,94.42 MEM3.R8
