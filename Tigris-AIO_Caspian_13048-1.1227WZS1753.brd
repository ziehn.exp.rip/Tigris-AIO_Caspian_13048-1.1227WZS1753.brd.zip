# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SLP_S4_N_G: length 10.3
  TOP w0.102: R536.2 114.11,39.04 v3(113.54,38.46) 112.79,37.72 Q72.G
  BOTTOM w0.102: R1045.2 107.95,38.51 Q108.C 112.16,38.51 R1048.2 113.09,38.91 v2(113.54,39.35) v3(113.54,38.46)
SLP_S4_N_R: length 4.3
  TOP w0.102: C50.1 181.74,185.15 v1(180.97,185.15) 180.42,185.15 180.23,184.96 R107.2 179.64,185.15 U4.2
SLP_S4_SIO: length 32.3
  TOP w0.102: v3(58.55,33.89) 58.55,33.77 59.16,33.16 R564.1 R563.1 58.04,33.09 58.04,34.58 57.56,35.06 57.56,35.39 57.27,35.68 U24.122 ; U24.69 46.58,48.78 46.86,48.5 48.96,48.5 49.16,48.29 50.26,48.29 50.34,48.37 53.84,48.37 54.73,47.48 54.97,47.48 v3(55.08,47.37)
  L3 w0.127: v3(55.08,47.37) 54.99,47.29 54.99,45.7 55.44,45.26 55.44,44.75 54.86,44.18 54.86,41.64 55.92,40.59 55.92,37.36 58.55,34.73 v3(58.55,33.89)
  BOTTOM w0.102: v2(58.55,33.08) v3(58.55,33.89)
SLP_S5_N: length 204.8
  TOP w0.102: v3(59.18,31.23) 59.16,31.25 R564.2 ; v4(136.6,82.01) 136.56,82.01 136.09,82.47 U29.AA35
  L4 w0.127: v3(60.88,13.65) 61.26,13.27 65.1,13.27 65.68,12.68 71.22,12.68 73.76,10.14 74.75,10.14 74.76,10.13 77.91,10.13 79.82,12.05 80.77,12.05 80.77,12.05 85.9,12.05 86.93,11.02 119.36,11.02 120.03,11.68 127.53,11.68 128.19,11.02 132.62,11.02 139.11,17.51 140.91,17.51 142.75,19.34 142.75,21.15 146.69,25.09 146.69,26.32 149.7,29.33 149.7,29.42 149.76,29.48 149.76,30.82 149.52,31.06 149.52,32.41 152.3,35.19 152.3,42.92 149.77,45.45 149.77,47.45 149.63,47.59 149.63,52.88 150.67,53.92 150.67,54.07 150.67,54.08 150.67,54.39 150.67,54.39 150.67,58.65 151.4,59.37 151.4,61.34 152.03,61.97 152.03,66.09 153.39,67.45 153.39,70.21 152.43,71.17 152.43,71.45 149.38,74.51 149.38,82.08 148.68,82.78 144.26,82.78 142.18,84.86 139.2,84.86 138.95,84.61 138.95,84.36 v4(136.6,82.01)
  BOTTOM w0.102: v3(59.18,31.23) 59.46,31.51 60.03,31.51 60.77,30.77 64.8,30.77 v2(65.96,29.61) 67.21,28.36 67.21,22.61 66.86,22.26 66.86,17.57 65.28,15.99 62.86,15.99 60.96,14.09 60.96,13.73 v3(60.88,13.65)
SLP_SUSB: length 213.4
  TOP w0.102: U29.AK38 140.83,84.39 140.52,84.7 140.52,86.34 140.84,86.66 v1(140.84,88.17) v4(140.84,89.01) ; v3(59.16,47.51) 56.73,47.51 55.94,46.72 54.98,46.72 53.68,48.02 50.48,48.02 50.41,47.94 49.02,47.94 48.86,48.09 46.85,48.09 46.74,47.98 U24.71
  L3 w0.127: v3(151,47.22) 150.41,46.63 150.41,44.33 150.62,44.11 150.62,39.16 149.8,38.34 149.67,38.34 146.92,35.59 146.44,35.59 140.75,29.9 140.75,28.18 134.96,22.39 131.91,22.39 129.48,19.96 128.59,19.96 127.81,19.17 123.84,19.17 122.02,21 119.27,21 117.96,19.69 109.93,19.69 108.62,21 105.47,21 103.56,19.08 97.32,19.08 95.75,17.52 94.15,17.52 93.14,18.53 90.19,18.53 89.15,17.48 80.91,17.48 80.54,17.12 80.54,16.84 79,15.3 78.25,15.3 74.47,15.3 70.37,19.4 67.89,19.4 62.05,25.24 62.05,28.64 61.63,29.06 61.63,32.03 63.08,33.48 63.08,35.71 62.81,35.99 61.3,35.99 60.62,36.67 60.54,36.74 60.54,46.12 v3(59.16,47.51)
  L4 w0.127: v4(140.84,89.01) 141.12,89.01 142.96,87.17 143.19,87.17 143.45,86.91 143.45,86.69 145.98,84.16 148.36,84.16 151,81.52 151,79.32 153.4,76.93 153.4,71.59 155.4,69.59 155.4,66.25 154.83,65.69 153.37,65.69 152.74,65.06 152.74,59.65 151.4,58.31 151.4,54.07 151.4,53.64 150.34,52.59 150.34,47.88 v3(151,47.22)
SLP_WLAN_N: length 243.9
  TOP w0.102: R283.1 153.36,91.99 v3(154.33,91.99) ; R11.1 96.87,234.59 96.39,235.06 v3(95.89,235.06) ; U29.AL39 141.92,84.53 v4(142.03,84.41)
  L3 w0.127: v3(95.89,235.06) 96.44,234.5 99.36,234.5 100.13,235.26 102.28,235.26 102.94,234.6 103.55,234.6 103.75,234.81 104.07,234.81 107.54,234.81 111.58,230.77 112.44,230.77 113.2,230.01 113.57,230.01 115.44,228.14 115.44,225.13 118.34,222.23 119.06,222.23 119.37,222.23 119.38,222.23 153.76,222.23 155.51,220.49 155.51,217.35 154.86,216.7 154.86,206.76 168.42,193.2 171.2,193.2 173.48,190.92 173.48,190.23 173.97,189.75 174.45,189.75 175.44,188.76 175.44,164.83 175.16,164.55 175.16,163.36 174.18,162.39 174.18,160.24 174.64,159.78 174.64,147.06 174.38,146.81 174.38,144.75 174.71,144.42 174.71,123.38 170.52,119.19 169.11,119.19 165.71,119.19 160.14,113.61 157.07,113.61 156.21,112.75 156.21,108.67 156.52,108.35 156.52,98.53 153.99,95.99 153.99,92.33 v3(154.33,91.99)
  BOTTOM w0.102: v4(142.03,84.41) 142.03,87.29 142.99,88.25 146.78,88.25 147.24,88.71 149.22,88.71 149.91,89.39 151,89.39 v2(151.76,90.15) 152.83,91.22 153.52,91.22 154.29,91.99 v3(154.33,91.99)
SMB_ALERT_N: length 237.2
  TOP w0.102: U29.AG31 139.51,80.34 139.88,80.71 v4(139.93,80.71) ; R16.1 104.2,229.91 102.51,231.59 102.51,233.28 v3(102.92,233.69)
  L3 w0.127: v3(102.92,233.69) 105.2,233.69 106.28,232.61 107.78,232.61 111.18,229.22 113.28,229.22 114.68,227.82 114.68,224.81 118.14,221.35 153.57,221.35 154.75,220.17 154.75,217.66 154.1,217.02 154.1,206.44 168.1,192.44 170.88,192.44 172.72,190.6 172.72,189.92 173.65,188.99 174.13,188.99 174.68,188.45 174.68,165.14 173.22,163.68 173.22,144.84 173.33,144.73 173.33,123.07 170.21,119.95 168.8,119.95 165.4,119.95 159.82,114.37 156.76,114.37 155.45,113.06 155.45,108.35 155.76,108.04 155.76,99 150.96,94.21 150.96,92.92 v4(148.79,90.75)
  BOTTOM w0.102: v4(139.93,80.71) 139.93,80.87 140.37,81.31 140.37,81.79 140.74,82.16 140.74,83.36 141.22,83.84 141.22,87.34 142.8,88.92 145.39,88.92 145.95,89.49 146.2,89.49 v2(146.48,89.77) 146.8,90.09 148.13,90.09 v4(148.79,90.75) R922.1
SMB_CLK_MAIN: length 436.5
  TOP w0.102: v3(40.06,44.05) 40.07,44.05 40.07,43.43 40.34,43.16 40.34,43.16 40.49,43.02 41.22,43.02 41.51,42.73 42.07,42.73 R521.1 43.73,43.29 44.42,43.98 U24.81 ; DIMM2.202 161.34,125 163.6,122.74 166.24,122.74 168.5,125 DIMM1.202 174.12,125 v3(174.24,124.88) ; v3(138.33,102.93) 138.12,102.93 136.58,101.39 132.65,101.39 132.56,101.48 132.21,101.48 132.11,101.58 131.65,101.58 131.32,101.26 131.32,101.11 130.34,100.14 128.98,100.14 128.15,99.3 126.89,99.3 126.71,99.48 125.9,100.29 123.9,100.29 123.25,100.94 120.68,100.94 120.04,100.29 118.78,100.29 114.3,95.81 114.3,91.86 113.48,91.04 v3(109.09,91.04) ; v3(106.17,86.72) 106.98,87.54 Q123.6
  L3 w0.127: v3(109.09,91.04) 109.56,91.51 109.56,92 109.29,92.27 108.9,92.27 107.7,91.07 107.7,88.25 v3(106.17,86.72) 105.88,86.43 104.84,86.43 100.84,82.43 100.84,80.41 96.65,76.21 96.65,68.86 88.87,61.08 87.17,61.08 84.13,64.12 77.22,64.12 75.41,64.12 71.58,60.28 66.08,60.28 62.49,56.69 51.54,56.69 50.75,57.48 47.18,57.48 39.51,49.81 39.51,44.64 40.06,44.09 v3(40.06,44.05) ; v3(112.04,211.97) 111.47,211.97 104.63,218.8 100.91,218.8 100.03,219.69 98.08,219.69 93.73,224.05 85.61,224.05 77.15,232.51 50.56,232.51 v3(50.11,232.06)
  L4 w0.127: v3(138.33,102.93) 138.53,102.73 139.61,102.73 144.4,107.52 144.4,110.85 145.8,112.25 147.94,112.25 148.46,112.77 148.46,113.59 148.88,114.01 148.88,114.62 151.53,117.27 163.06,117.27 164.58,118.79 168.96,118.79 174.07,123.9 174.07,124.7 v3(174.24,124.88) 174.98,125.61 174.98,141.64 176.11,142.77 176.11,156.52 175.92,156.71 175.92,173.27 175.77,173.42 175.77,187.35 173.17,189.95 171.94,189.95 164.98,196.91 153.51,196.91 146.37,204.05 139.62,204.05 136.78,206.89 136.78,207.63 136.25,208.16 136.25,210.53 134.01,212.77 128.65,212.77 128.45,212.98 121.49,212.98 119.7,211.18 113.76,211.18 112.98,211.97 v3(112.04,211.97)
  BOTTOM w0.102: Q93.S 114.66,212.89 v2(113.18,212.89) 112.96,212.89 v3(112.04,211.97) ; XDPC1.53 50.36,232.21 50.22,232.06 v3(50.11,232.06)
SMB_CLK_RESUME: length 447.3
  TOP w0.102: U29.AG36 139.65,83.19 140.09,82.75 v4(140.13,82.75) ; R14.1 103.89,230.87 v3(103,231.76) ; U24.80 44.01,44.38 v1(43.7,44.07) 43,44.07 R513.2 42.8,44.43 43.26,44.89 v3(43.43,44.89)
  L3 w0.127: v3(103,231.76) 104.14,231.76 104.39,232.01 105.64,232.01 106.38,231.28 107.62,231.28 108.64,230.26 108.64,229.78 117.83,220.59 118.42,220.59 153.26,220.59 153.99,219.85 153.99,217.98 153.34,217.33 153.34,201.75 157.11,197.98 161.47,197.98 167.77,191.68 168.93,191.68 172.63,187.98 172.63,164.18 172.45,164 172.45,123.28 169.88,120.71 165.08,120.71 159.5,115.13 156.44,115.13 154.69,113.38 154.69,108.03 155,107.72 155,100.11 154.26,99.37 154.22,99.37 148.23,93.38 148.23,93.23 v4(146.69,91.68) ; v3(49.2,43.4) 49.43,43.17 50.09,43.17 50.41,42.85 50.41,40.44 50.13,40.17 50.13,36.78 49.87,36.52 49.87,34.58 51.09,33.36 52.04,33.36 54.43,30.96 54.43,30.32 58.97,25.78 58.97,24.91 65.07,18.81 65.07,17.21 70.13,12.15 71.22,12.15 72.12,11.25 72.12,10.71 73.1,9.74 78.27,9.74 80.96,12.43 88.24,12.43 88.95,13.14 91.76,13.14 91.88,13.02 92.6,13.02 92.72,13.14 101.06,13.14 103.05,15.14 106.56,15.14 107.06,15.63 115.61,15.63 116.1,15.14 119.06,15.14 119.43,14.77 120.9,14.77 121.53,14.77 121.53,14.77 126.3,14.77 129.15,17.62 132.12,17.62 132.23,17.52 134.45,17.52 140.84,23.91 140.84,25.13 152.53,36.81 152.53,43.85 155.75,47.08 155.75,48.73 v3(157.89,50.86)
  L4 w0.127: v4(146.69,91.68) 149.1,91.68 150.06,90.72 150.06,90.32 150.74,89.63 151.11,89.63 151.29,89.81 154.35,89.81 154.56,90.03 156.73,90.03 159.06,87.7 159.06,73.62 162.04,70.63 162.04,67.03 161.52,66.51 161.52,64.91 161.71,64.72 161.71,55.99 159.97,54.25 159.97,53.34 157.89,51.26 v3(157.89,50.86) ; v3(43.43,44.89) 43.73,44.59 46.29,44.59 46.83,44.05 48.55,44.05 v3(49.2,43.4)
  BOTTOM w0.102: v4(146.69,91.68) 145.86,90.85 C551.1 145.54,90.03 145.53,90.03 144.83,89.33 144.47,89.33 144.22,89.58 144.22,89.64 143.85,90.01 143.32,90.01 140.81,87.51 140.81,84 140.13,83.33 v4(140.13,82.75)
SMB_DATA_MAIN: length 428.6
  TOP w0.102: v3(40.84,46.47) 41.02,46.29 41.98,46.29 42.03,46.34 42.16,46.34 42.63,45.87 R505.1 43.41,45.7 44.34,44.78 U24.79 ; v3(138.23,103.83) 138.19,103.79 138.1,103.79 136.91,102.6 136.91,102.23 136.43,101.75 132.8,101.75 132.71,101.84 132.36,101.84 132.26,101.94 131.5,101.94 130.96,101.4 130.96,101.26 130.19,100.49 129.13,100.49 128.84,100.49 128,99.65 127.04,99.65 126.05,100.64 124.05,100.64 123.4,101.29 120.54,101.29 119.89,100.64 118.63,100.64 113.94,95.96 113.94,92.01 113.74,91.8 v3(109.09,91.8) ; DIMM2.200 161.25,125.6 163.75,123.1 166.07,123.1 168.57,125.6 DIMM1.200 174.16,125.6 v3(174.24,125.69) ; v3(109.07,84.62) 109.07,84.72 108.73,85.06 Q123.3
  L3 w0.127: v3(40.84,46.47) 41.91,47.53 41.91,51.03 47.19,56.31 62.64,56.31 66.09,59.75 71.91,59.75 75.9,63.74 77.06,63.74 83.98,63.74 87.01,60.7 89.03,60.7 97.03,68.7 97.03,75.07 106.65,84.69 108.99,84.69 v3(109.07,84.62) 109.09,84.64 109.09,86.85 108.36,87.58 108.36,91.08 v3(109.09,91.8) ; v3(50.73,231.44) 50.75,231.43 77.67,231.43 85.45,223.66 93.58,223.66 98.88,218.36 101.82,218.36 101.88,218.42 104.47,218.42 111.69,211.2 v3(112.04,211.2)
  L4 w0.127: v3(138.23,103.83) 138.34,103.83 139.06,103.11 139.45,103.11 144.02,107.68 144.02,112.73 148.94,117.65 162.9,117.65 164.43,119.17 168.8,119.17 173.69,124.06 173.69,125.13 v3(174.24,125.69) 174.6,126.04 174.6,141.8 175.73,142.93 175.73,156.37 175.54,156.56 175.54,173.11 175.39,173.26 175.39,185.76 164.62,196.53 153.35,196.53 146.21,203.67 137.74,203.67 133.62,207.79 129.76,207.79 129.43,208.12 128.32,208.12 127.76,207.57 116.84,207.57 113.58,210.83 113.2,211.2 v3(112.04,211.2)
  BOTTOM w0.102: v3(50.73,231.44) 50.86,231.57 XDPC1.51 ; Q92.S 116.53,212.17 115.72,211.36 v2(113.59,211.36) 112.22,211.36 112.06,211.2 v3(112.04,211.2)
SMB_DATA_RESUME: length 448.8
  TOP w0.102: U24.78 44.44,45.18 43.23,46.39 43.09,46.39 R501.2 43.01,47.22 v3(43.43,47.22) ; v3(103.1,235.11) 103.1,234.16 103.38,233.88 103.38,233.42 102.92,232.96 102.92,232.59 103.62,231.89 R12.1 ; U29.AG32 139.27,81.05 139.11,80.89 139.11,80.87 v4(138.89,80.66)
  L3 w0.127: v3(103.1,235.11) 103.52,235.11 103.59,235.19 104.22,235.19 107.7,235.19 108.23,235.19 108.24,235.18 109.23,235.18 112.67,231.73 112.67,231.07 112.96,230.78 113.34,230.78 115.82,228.3 115.82,225.28 118.49,222.61 153.92,222.61 155.89,220.64 155.89,217.19 155.24,216.54 155.24,206.91 168.58,193.58 171.36,193.58 173.96,190.98 174.77,190.98 175.82,189.93 175.82,164.67 175.54,164.39 175.54,163.21 174.56,162.23 174.56,160.4 175.02,159.94 175.02,146.71 174.76,146.45 174.76,145.09 175.09,144.76 175.09,123.22 170.68,118.81 169.27,118.81 165.87,118.81 159.38,112.32 159.38,110 156.91,107.52 156.91,98.38 154.62,96.09 154.62,93.62 154.93,93.31 154.93,91.11 v3(151.94,88.12) ; v3(52.4,44.68) 53.16,43.93 53.16,38.9 53.89,38.17 53.89,37.61 57.02,34.47 57.02,31.64 61.29,27.37 61.29,24.93 67.58,18.64 70.06,18.64 74.16,14.54 77.93,14.54 79.31,14.54 79.32,14.54 79.65,14.54 80.11,14.08 80.42,14.08 81.56,14.08 86.82,14.08 90.51,17.76 92.83,17.76 93.83,16.76 93.94,16.76 93.97,16.73 94.69,16.73 101.23,16.73 102.64,18.13 106.15,18.13 106.76,17.52 115.15,17.52 115.83,18.2 118.92,18.2 120.42,16.7 126.41,16.7 128.91,19.2 129.8,19.2 132.22,21.62 135.28,21.62 141.6,27.95 141.6,29.68 144.5,32.57 145.16,32.57 147.95,35.37 147.95,35.55 149.98,37.58 150.12,37.58 151.38,38.84 151.38,44.51 152.86,45.99 v3(152.86,46.95)
  L4 w0.127: v3(52.4,44.68) 51.73,45.36 49.85,45.36 48.92,44.43 46.99,44.43 44.22,47.21 43.58,47.21 43.56,47.22 v3(43.43,47.22) ; v3(152.86,46.95) 152.86,47 153.4,47.54 153.4,47.74 153.97,48.31 153.97,49.68 154.49,50.2 154.49,50.58 154.66,50.75 154.66,50.97 154.94,51.24 154.94,51.35 156.31,52.73 156.31,58.16 156.74,58.59 156.74,59.28 157.91,60.44 157.91,62.9 158.93,63.92 158.93,70.52 156.58,72.87 156.58,84.44 152.9,88.12 v3(151.94,88.12) 146.29,88.12 v3(144.65,89.76)
  BOTTOM w0.102: v4(138.89,80.66) 138.89,80.85 139.3,81.25 139.3,81.54 139.67,81.92 139.67,83.27 140.61,84.2 140.61,87.59 142.93,89.91 142.93,90.28 v2(143.41,90.76) 143.5,90.85 C552.1 v3(144.65,89.76)
SMBUS_ISP: length 160.7
  TOP w0.102: v3(126.4,90.23) 126.4,89.72 129.52,86.6 129.56,86.6 130.16,86 130.16,85.72 130.35,85.54 130.35,85.23 130.31,85.19 130.31,84.5 U29.L38 ; v3(123.8,123.58) 123.8,191.73 125.63,193.56 125.63,201.86 124.84,202.65 124.84,203.57 123.45,204.96 121.81,204.96 v3(120.35,206.42)
  L4 w0.127: v3(123.8,123.58) 124.33,123.05 124.33,120.8 132.5,112.63 132.5,109.03 131.36,107.9 131.29,107.9 128.47,105.08 128.47,101.5 124.72,97.74 124.72,93.07 126.4,91.39 v3(126.4,90.23)
  BOTTOM w0.102: v3(120.35,206.42) Q94.G 120.49,205.34 120.66,205.34 120.95,205.04 120.95,203.99 119.51,202.55 118.48,202.55 117.31,203.71 116.21,203.71 115.73,204.2 Q95.G 114.34,206.42 113.84,206.92 v2(113.84,210.04) 114,210.2 Q93.G 115.38,210.46 116.66,211.74 118.16,211.74 119.19,210.72 Q92.G
SMLICLK_PCH: length 218.4
  TOP w0.102: v4(141.24,83.2) 140.91,82.87 U29.AK36 ; R481.1 65.47,50.75 v3(66.28,49.93)
  L3 w0.127: v3(66.28,49.93) 64.26,47.91 62.6,47.91 61.73,47.05 61.73,37.6 63.46,35.87 63.46,33.09 62.65,32.28 62.65,25.21 68.08,19.78 70.53,19.78 74.63,15.68 78.84,15.68 80.16,17 80.16,17.28 80.75,17.87 88.99,17.87 90.03,18.91 93.3,18.91 94.31,17.9 95.59,17.9 97.16,19.47 103.28,19.47 105.2,21.38 108.78,21.38 110.09,20.07 116.91,20.07 118.22,21.38 122.18,21.38 124,19.55 127.65,19.55 128.44,20.34 129.32,20.34 131.78,22.79 134.83,22.79 140.37,28.34 140.37,30.06 146.29,35.98 146.77,35.98 149.51,38.72 149.65,38.72 150.24,39.31 150.24,43.8 150.03,44.01 150.03,47.78 150.71,48.46 151.1,48.46 151.12,48.43 154.09,48.43 v3(154.48,48.83)
  L4 w0.127: v3(154.48,48.83) 154.48,49.65 155.04,50.2 155.04,50.78 158.88,54.62 158.88,54.7 159.14,54.96 159.14,61.56 159.65,62.06 159.65,62.6 160.43,63.38 160.43,66.96 160.95,67.48 160.95,70.18 157.96,73.17 157.96,73.38 157.96,83.6 153.13,88.43 152.86,88.43 152.66,88.64 146.42,88.64 v4(146.05,89.01)
  BOTTOM w0.102: C545.1 149.94,91.48 R921.1 149.86,91.19 v2(148.18,89.52) 147.78,89.11 146.15,89.11 v4(146.05,89.01) 145.76,88.72 142.89,88.72 141.42,87.25 141.42,83.38 v4(141.24,83.2)
SMLIDATA_PCH: length 232.8
  TOP w0.102: U29.AK33 140.58,81.27 v4(140.58,80.79) ; R496.1 v3(66.29,47.61)
  L3 w0.127: v3(50.91,47.56) 51.24,47.22 51.24,45.51 51.05,45.32 51.05,40.55 50.51,40.01 50.51,37.84 54.17,34.19 54.86,34.19 55.24,33.8 55.24,30.58 59.73,26.1 59.73,25.23 67.21,17.75 69.2,17.75 71.82,15.13 71.82,13.28 72.89,12.21 72.89,11.03 73.41,10.5 77.95,10.5 80.64,13.19 81.62,13.19 81.93,13.19 87.19,13.19 87.83,13.83 88.15,13.83 88.41,14.09 88.41,14.09 89.57,15.25 93.04,15.25 93.25,15.46 101.22,15.46 101.6,15.84 101.6,15.84 102.12,16.36 103,17.24 105.69,17.24 106.3,16.63 115.52,16.63 116.17,17.28 118.55,17.28 120.27,15.56 121.19,15.56 121.22,15.53 125.78,15.53 129.07,18.82 129.96,18.82 132.38,21.24 135.46,21.24 145.67,31.45 145.67,31.82 145.67,32.46 148.34,35.12 148.34,35.39 150.14,37.19 150.28,37.19 151.76,38.68 151.76,44.36 154.95,47.54 154.95,49.02 153.27,50.71 v3(153.26,50.71)
  L4 w0.127: v3(153.26,50.71) 153.24,50.73 153.24,51.29 155.17,53.22 155.17,58.64 155.6,59.07 155.6,59.75 156.77,60.92 156.77,64.4 157.78,65.41 157.78,70.01 155.38,72.41 155.38,79.92 154.57,80.73 154.57,81.07 154.1,81.54 153.04,81.54 149.79,84.79 149.48,84.79 148.88,85.39 148.88,86.01 v4(147.37,87.52) ; v3(66.29,47.61) 66.42,47.74 66.45,47.74 66.86,48.14 66.86,48.62 66.52,48.95 63.12,48.95 62.27,49.81 60.59,49.81 60.03,50.36 57.87,50.36 56.39,48.88 54.61,48.88 53.48,47.75 52.61,47.75 52.42,47.56 v3(50.91,47.56)
  BOTTOM w0.102: v4(140.58,80.79) 140.58,81.4 141.23,82.05 141.41,82.05 141.85,82.48 141.85,83.65 142.44,84.25 142.44,85.15 v2(143.13,85.84) 143.13,86.02 144.64,87.52 v4(147.37,87.52) R933.1 148.14,86.54 C578.1
SMLINK0_CLK: length 17
  TOP w0.102: v4(138.89,81.42) 138.52,81.05 U29.AE32
  BOTTOM w0.102: v4(138.89,81.42) 139.44,81.97 139.44,83.49 139.52,83.56 140.08,84.13 140.08,85.2 v2(140.08,85.2) 140.41,85.53 140.41,87.67 142.72,89.99 142.72,91.12 144.17,92.57 145.54,92.57 146.37,93.39 R909.1
SMLINK0_DATA: length 16.1
  TOP w0.102: v4(138.83,82.05) 138.41,82.47 U29.AE35
  BOTTOM w0.102: R910.1 145.18,93.39 144.56,92.77 144.08,92.77 142.52,91.2 142.52,90.24 142.28,90 141.51,90 141.2,89.69 141.2,89.23 141.25,89.18 141.25,88.81 140.2,87.76 140.2,86.8 v2(139.87,86.47) 139.54,86.14 139.54,84.84 139.78,84.61 139.78,84.23 139.24,83.69 139.24,82.46 v4(138.83,82.05)
SP_CTS_N: length 4.2
  TOP w0.254: RN7.4 49.3,33.5 v1(48.93,33.88) 48.87,33.94 U24.101
SP_DCD_N: length 8.5
  TOP w0.254: U24.96 45.72,37.58 46.38,36.92 46.38,34.81 45.95,34.38 v1(43.84,34.38) 43.84,33.59 44.69,32.74 RN6.4
SP_DSR_N: length 5.9
  TOP w0.254: U24.97 47.27,35.11 46.15,33.99 45.25,33.99 v1(44.8,33.55) 44.8,33.37 45.34,32.83 RN6.3
SP_DTR_N: length 4.3
  TOP w0.254: RN7.3 49.95,33 49.76,33.2 49.76,33.94 49.27,34.44 U24.102
SP_RI_N: length 4.3
  TOP w0.254: U24.103 49.67,34.59 50.44,33.82 v1(50.44,33.59) 50.45,33.58 RN7.2
SP_RTS_N: length 4.8
  TOP w0.254: RN6.1 46.49,32.89 47.26,33.66 47.38,33.66 v1(47.42,33.7) 47.42,33.81 48.07,34.45 U24.99
SP_RXD_N: length 4.9
  TOP w0.254: RN6.2 45.84,33.15 46.04,33.35 v1(46.06,33.35) 46.14,33.44 47.67,34.96 U24.98
SP_TXD_N: length 4.3
  TOP w0.254: v3(48.34,31.51) 48.29,31.51 48.02,31.77 R568.2 47.49,31.76 47.49,30.77 R574.2
  BOTTOM w0.254: v3(48.34,31.51) 48.72,31.51 v2(49.1,31.89) 49.45,32.24 Q111.3
SP_TXD_N_1: length 2.5
  BOTTOM w0.254: Q111.5 47.09,33.77 v2(46.38,34.48) 46.1,34.2 R1076.2
SP_TXD_SIO: length 4.2
  TOP w0.254: U24.100 48.47,34.31 48.29,34.13 48.29,33.45 R568.1
SPEED_100*_CON: length 28.6
  TOP w0.254: R596.2 20.88,24.42 20.85,24.39 20.85,24.32 v3(20.83,24.29)
  BOTTOM w0.254: RJ1.13 23.45,7.75 13.39,17.81 13.39,21.7 14.02,22.34 18.57,22.34 20.52,24.29 v3(20.83,24.29)
SPEED_100_N: length 18.4
  TOP w0.254: v3(20.32,32.37) 21.11,31.58 21.11,29.43 C319.1 20.27,28.58 D12.K 20.27,27.37 R596.1 ; v3(24.41,38.16) 24.64,38.16 25.09,38.62 v1(25.15,38.62) 25.35,38.42 25.35,37.88 25.95,37.28 U26.26
  L3 w0.254: v3(20.32,32.37) 22.15,32.37 23.44,33.66 23.44,37.19 v3(24.41,38.16)
SPEED_1000*_CON: length 32
  TOP w0.254: R595.2 19.68,24.27 v3(19.71,24.24)
  BOTTOM w0.254: v3(19.71,24.24) 18.24,22.77 13.82,22.77 12.98,21.93 12.98,17.61 24.03,6.56 25.76,6.56 RJ1.14
SPEED_1000_N: length 23.3
  TOP w0.254: U26.25 26.16,37.68 25.78,38.06 25.78,38.88 25.41,39.25 24.57,39.25 v3(24.41,39.09) ; v3(19.18,32.37) 17.93,31.12 17.93,29.8 17.27,29.14 D13.K 18.19,26.76 C338.1 R595.1
  L3 w0.254: v3(19.18,32.37) 19.94,33.13 22.25,33.13 22.96,33.84 22.96,38.48 23.58,39.09 v3(24.41,39.09)
  BOTTOM w0.254: v2(23.57,39.09) v3(24.41,39.09)
SPI_CLK: length 31.3
  TOP w0.102: v3(131.75,106.79) 131.75,106.86 132.16,107.26 132.16,108.73 135.84,112.42 135.84,113.98 137.57,115.71 141.52,115.71 R182.1 ; R241.2 128.51,97.09 v1(128.32,97.09) 127.6,97.09 v3(127.46,96.95)
  L4 w0.127: v3(131.75,106.79) 131.51,106.55 131.51,105.49 131.23,105.2 131.23,103.02 129.77,101.56 129.77,100.88 127.07,98.18 127.07,97.58 127.46,97.19 v3(127.46,96.95)
SPI_CLK_1: length 15.8
  TOP w0.102: SRCON1.6 139.79,103.57 v3(139.4,103.97) 139.4,104.63 139.27,104.76 138.2,104.76 138.1,104.86 138.1,105.44 138.2,105.55 139.62,105.55 139.73,105.65 139.73,108.24 140.34,108.85 140.34,109.76 142.17,111.59 142.17,112.07 142.75,112.65 R182.2
SPI_CLK_R: length 13.1
  TOP w0.102: R241.1 129.84,95.3 v1(130.5,94.63) 131.27,93.86 131.27,91.53 131.78,91.03 131.78,90.48 132.69,89.56 132.69,88.64 133.55,87.78 133.55,86.99 134.07,86.47 134.07,85.16 133.77,84.86 U29.U39
SPI_CS0_N: length 37.8
  TOP w0.102: v3(130.81,105.83) 130.81,105.32 130.91,105.22 131.55,105.22 131.65,105.11 131.65,104.86 131.55,104.76 130.91,104.76 130.81,104.66 130.81,102.3 130.91,102.19 131.14,102.19 131.24,102.3 131.24,104.2 131.34,104.3 132.32,104.3 132.42,104.2 132.42,102.37 132.52,102.27 132.79,102.27 132.89,102.37 132.89,105.72 133.28,106.11 U12.1 ; R240.2 v3(127.46,96.19)
  L4 w0.127: v3(127.46,96.19) 126.81,96.83 126.81,98.29 127.17,98.64 127.17,98.82 126.84,99.15 126.84,99.33 127.02,99.51 127.2,99.51 127.53,99.18 127.71,99.18 127.89,99.36 127.89,99.54 127.56,99.87 127.56,100.05 127.74,100.23 127.92,100.23 128.25,99.9 128.43,99.9 128.6,100.07 128.6,100.25 128.27,100.58 128.27,100.76 128.45,100.94 128.63,100.94 128.96,100.61 129.14,100.61 129.51,100.98 129.51,101.45 129.51,101.66 129.51,101.66 129.51,102.78 129.62,102.88 130.71,102.88 130.81,102.98 130.81,103.43 130.68,103.55 128.98,103.55 128.88,103.65 128.88,103.96 128.98,104.06 130.68,104.06 130.81,104.19 v3(130.81,105.83)
  BOTTOM w0.102: v3(127.46,96.19) 128.52,97.25 v2(128.52,97.34)
SPI_CS0_N_R: length 14
  TOP w0.102: R240.1 128.22,95.25 128.22,92.64 v1(127.84,92.27) 127.84,91.87 128.52,91.19 128.76,91.19 130.3,89.65 130.5,89.65 132.79,87.36 132.79,86.34 132.8,86.33 132.8,85.69 133.45,85.05 133.45,84.64 133.15,84.34 U29.R38
SPI_CS1_N: length 7.6
  TOP w0.102: v4(132.49,82.04) 132.93,82.47 U29.R35
  BOTTOM w0.102: v4(132.49,82.04) 131.95,82.58 131.95,82.94 131.87,83.02 131.87,83.94 132.17,84.25 132.17,84.69 131.91,84.95 131.91,87.95 131.95,87.98 TP115.1
SPI_IO2: length 32.8
  TOP w0.102: R179.1 R180.2 140.46,115.12 140.34,115.25 137.87,115.25 136.39,113.77 136.39,111.36 135.65,110.61 135.2,110.61 132.92,108.33 v3(132.92,107.35) ; R267.2 129.6,93.58 v1(129.54,93.58) 128.91,93.58 128.8,93.48 v3(128.68,93.48)
  L4 w0.127: v3(132.92,107.35) 132.93,107.34 132.93,102.01 132.45,101.53 132.45,100.86 130.31,98.73 130.31,95.12 v3(128.68,93.48)
SPI_IO2_R: length 7.7
  TOP w0.102: R267.1 130.9,91.61 131.39,91.13 131.39,90.07 v1(131.86,89.6) 132.43,89.03 132.43,88.6 133.35,87.69 133.35,86.9 133.77,86.48 U29.U40
SPI_IO3: length 37.6
  TOP w0.102: R184.2 R183.1 143.89,114.72 v1(142.88,115.73) 142.67,115.93 137.41,115.93 135.61,114.13 135.61,112.51 131.93,108.83 131.93,107.76 v3(130.94,106.77)
  L4 w0.127: v3(128.72,94.3) 128.72,94.61 130.06,95.95 130.06,99.01 131.41,100.35 131.41,101.22 132.68,102.49 132.68,106.63 132,107.3 131.23,107.3 130.94,107.01 v3(130.94,106.77)
  BOTTOM w0.102: R906.2 128.82,94.41 v3(128.72,94.3)
SPI_IO3_R: length 14.3
  TOP w0.102: U29.U37 133.54,83.61 v4(133.54,83.37)
  BOTTOM w0.102: v2(130.68,94.34) 130.43,94.34 129.67,93.58 R906.1 130.18,93.01 130.18,90.52 130.81,89.89 131.84,89.89 133.22,88.5 133.22,83.69 v4(133.54,83.37)
SPI_MISO: length 27.3
  TOP w0.102: v3(132.21,105.01) 132.21,105.51 133.5,106.8 133.5,108.59 134.85,109.94 v1(135.33,109.94) 136.62,111.23 136.62,113.68 137.42,114.47 R178.1
  L4 w0.127: v3(127.76,93.2) 128.23,93.67 128.23,94.48 129.12,95.37 129.12,98.43 131.15,100.46 131.15,101.33 132.42,102.6 132.42,104.8 v3(132.21,105.01)
  BOTTOM w0.102: v3(127.76,93.2) R917.2
SPI_MISO_R: length 13.2
  TOP w0.102: v4(132.47,82.69) 132.47,82.69 132.53,82.69 U29.R36
  BOTTOM w0.102: R917.1 128.05,91.61 v2(129.03,90.64) 130.28,89.39 131.76,89.39 132.49,88.66 132.49,88.16 132.12,87.79 132.12,86.51 132.38,86.25 132.38,84.16 132.08,83.86 132.08,83.1 132.16,83.02 132.16,83 v4(132.47,82.69)
SPI_MISO_ROM_1: length 20.4
  TOP w0.102: R178.2 138.3,112.58 v3(137.82,112.1) 137.82,111.64 136.4,110.22 136.4,109.39 136.3,109.29 134.9,109.29 134.8,109.19 134.8,108.99 134.9,108.88 136.37,108.88 136.47,108.78 136.47,108.58 136.37,108.48 134.85,108.48 134.75,108.38 134.75,108.14 134.85,108.04 136.3,108.04 136.4,107.93 136.4,107.71 136.3,107.6 134.87,107.6 134.77,107.5 134.77,107.3 134.87,107.2 136.3,107.2 136.4,107.1 136.4,105.09 136.15,104.84 SRCON1.2
SPI_MOSI: length 30.9
  TOP w0.102: R181.1 140.6,115.48 137.66,115.48 136.18,114 136.18,113.88 136.17,113.87 136.17,111.89 135.53,111.26 v1(135.48,111.26) 135.25,111.26 132.46,108.47 132.46,106.54 v3(131.98,106.07) ; R239.2 127,96.06 127,95.88 v3(127.46,95.42)
  L4 w0.127: v3(131.98,106.07) 131.98,105.48 131.48,104.97 131.48,102.91 130.26,101.69 130.26,101.02 127.32,98.07 127.32,97.68 127.6,97.41 127.66,97.41 127.93,97.14 127.93,95.89 v3(127.46,95.42)
SPI_MOSI_1: length 16.9
  TOP w0.102: v3(140.84,101.33) 141.51,102 SRCON1.5 140.01,102.3 138.68,103.63 138.68,104.12 138.43,104.38 137.92,104.38 137.74,104.56 137.74,106.77 139.7,108.72 139.7,110.03 141.1,111.43 141.1,113.08 R181.2
SPI_MOSI_R: length 15.1
  TOP w0.102: U29.P40 132.6,85.42 132.6,86.24 132.58,86.26 132.58,87.28 130.42,89.44 130.22,89.44 128.68,90.98 128.34,90.98 127.28,92.04 127.28,93.75 126.43,94.6 v1(126.06,94.6) 125.92,94.6 R238.1 125.6,95.68 R239.1
SPI_WP_N_1: length 16.8
  TOP w0.102: SRCON1.3 v3(137.21,103.57) 137.41,103.78 137.41,106.86 137.31,106.96 136.86,106.96 136.75,107.06 136.75,107.27 136.86,107.37 137.31,107.37 137.41,107.47 137.41,107.67 137.31,107.77 136.86,107.77 136.75,107.88 136.75,108.08 136.86,108.18 137.31,108.18 137.41,108.28 137.41,108.49 137.31,108.59 136.86,108.59 136.75,108.69 136.75,108.89 136.86,108.99 137.31,108.99 137.41,109.1 137.41,109.97 139.32,111.87 R179.2
SPKR: length 97.6
  TOP w0.305: v4(132.42,80.63) 132.57,80.63 132.99,81.05 U29.R32 ; v3(185.33,99.69) 185.33,99.39 185.93,98.79 R228.1
  L3 w0.305: v3(126.3,93.29) 126.3,96.49 126.9,97.09 126.9,97.18 126.92,97.21 126.92,97.77 128.05,98.89 131.76,98.89 135.8,102.94 135.8,102.99 137.4,104.59 140.32,104.59 141.76,106.03 149.48,106.03 v3(149.61,106.16)
  L4 w0.305: v3(149.61,106.16) 149.61,105.9 150.37,105.14 153.94,105.14 155.4,103.68 155.4,99.98 157.78,97.6 164.2,97.6 v3(164.72,98.12)
  BOTTOM w0.102: 131.36,84.97 131.36,84.25 131.44,84.17 131.67,83.94 131.67,82.93 131.75,82.85 131.75,82.5 131.98,82.27 131.98,81.07 v4(132.42,80.63)
  BOTTOM w0.305: v3(164.72,98.12) 165.24,97.6 165.77,97.6 166.31,98.14 166.31,99.33 169.34,102.36 179.49,102.36 180.79,101.06 v2(182.25,101.06) 182.71,100.59 184.2,100.59 185.11,99.69 v3(185.33,99.69) ; 131.36,84.97 131.36,87.78 130.26,88.88 129.36,88.88 126.6,91.64 126.6,92.98 v3(126.3,93.29) 125.86,93.29 R913.2 125.82,94.15 R895.1
SPKR_1: length 3
  BOTTOM w0.305: R895.2 126.49,95.82 v2(126.36,95.95) 125.58,95.95 R893.1 R898.2
SPKR_DET: length 103.3
  TOP w0.102: v3(170.31,67.67) 170.89,67.09 170.89,65.95 v1(169.97,65.02) 163.47,58.53 163.27,58.53 162.38,57.64 158.59,57.64 156.49,59.74 156.49,60.33 155.45,61.38 154.12,61.38 153.65,61.84 153.65,62.4 147.89,68.16 145.83,68.16 145.35,68.64 U29.AV9 ; L56.1 R1156.2 147.38,19.49 155,19.49 v3(155.57,20.06)
  L3 w0.127: v3(170.31,67.67) 170.89,67.09 170.89,60.13 167.56,56.8 167.56,52.84 167.69,52.71 167.69,32.11 167.08,31.51 167.08,28.81 166.07,27.81 163.33,27.81 159.3,23.77 159.3,23.51 158.98,23.19 158.71,23.19 157.77,22.25 157.25,22.25 156.93,21.93 156.93,21.41 155.58,20.06 v3(155.57,20.06)
SPKR_DET_C: length 6
  TOP w0.102: L56.2 144.2,18.93 142.33,20.8 SPK1.6
SPKR_IN_L: length 5.4
  TOP w0.203: C274.2 158,40.57 C278.2 158.12,39.63 v1(157.99,39.5) 157.99,39.23 158.76,38.45 U25.6
SPKR_IN_R: length 3.1
  TOP w0.203: C287.2 v1(163.45,36.43) 163.09,36.43 162.57,35.9 U25.31
SPKR_L+_C: length 1.4
  BOTTOM w1.016: L42.2 v5(150.24,29.19)
  vias: v1(148.97,29.19)
SPKR_L+_SNB: length 2.5
  TOP w0.635: v1(149.1,31.73) 148.84,31.48 C316.1
  TOP w1.016: R589.2 C316.1
SPKR_L-_C: length 1.8
  BOTTOM w1.016: v5(149.99,27.29) 150.11,27.16 L41.2
  vias: v1(148.84,27.54)
SPKR_L-_SNB: length 4.5
  TOP w1.016: R588.2 v1(148.84,26.15) 150.5,26.15 151.13,26.78 C314.1
SPKR_OUT_L+: length 8.8
  TOP w0.305: 156.64,31.81 156.92,32.08 U25.16
  TOP w1.016: v5(155.7,28.94) 155.83,29.07 C294.2 155.83,30.99 156.64,31.81
  BOTTOM w1.016: v5(155.7,28.94) 155.7,29.91 v2(154.99,30.62) 154.32,30.62 153.62,29.92 L42.1
SPKR_OUT_L-: length 8.2
  TOP w0.305: C301.2 158.26,31.12 U25.18
  TOP w1.016: C301.2 157.23,28.48 v1(156.97,28.23) 156.29,27.54 v5(155.96,27.54)
  BOTTOM w1.016: v5(155.96,27.54) 155.83,27.42 153.87,27.42 L41.1
SPKR_OUT_R+: length 16.9
  TOP w0.305: 162.1,31.68 U25.25
  TOP w1.016: v5(158.75,23.73) 160.66,25.64 162.05,25.64 164.72,28.3 C296.2 163.58,30.21 162.1,31.68
  BOTTOM w1.016: L43.1 v2(157.66,23.73) v5(158.75,23.73)
SPKR_OUT_R-: length 14.5
  TOP w0.305: C302.2 160.76,30.99 U25.23
  TOP w1.016: v5(157.48,21.7) 157.48,23.03 157.35,23.15 157.35,24.31 v1(158.63,25.58) 160.08,27.03 160.78,27.03 161.67,27.92 C302.2
  BOTTOM w1.016: L44.1 v5(157.48,21.7)
SPKR_R+_C: length 4.9
  BOTTOM w1.016: L43.2 153.72,23.35 v2(152.65,23.35) v5(149.35,23.35)
SPKR_R+_SNB: length 4.5
  TOP w1.016: R587.2 v1(150.24,24.75) 151.13,24.75 C315.1
SPKR_R-_C: length 5.1
  BOTTOM w1.016: v5(149.22,21.7) 149.48,21.95 v2(150.8,21.95) 153.85,21.95 L44.2
SPKR_R-_SNB: length 2.8
  TOP w0.762: R586.2 v1(148.84,20.3) 150.24,20.3 C313.1
SPV10: length 14.7
  TOP w0.254: v4(73.74,81.52) 73.72,81.52 73.35,81.14 U13.H8
  TOP w0.508: v4(70.1,75.17) 70.55,74.72 C785.1 C789.1 70.48,72.56 C787.1 L51.2 69.96,70.28 v1(69.52,69.83)
  L4 w0.356: v4(70.1,75.17) 70.11,75.17 70.71,75.77 70.71,76.92 73.53,79.74 73.53,81.31 v4(73.74,81.52)
SPV18: length 12.6
  TOP w0.254: U13.H7 72.96,79.95 72.95,79.95 v4(72.94,79.94)
  TOP w0.508: v4(71.69,74.89) C793.1 C792.1 71.75,72.56 C788.1 L49.2 72.35,70.28 v1(72.85,69.78)
  L3 w0.508: v4(72.94,79.94) 72.94,79.07 71.09,77.22 71.09,75.49 v4(71.69,74.89)
SST_CTL_R: length 11.8
  TOP w0.165: v4(140,80.08) 140.13,80.21 U29.AJ31
  L4 w0.165: v3(148.31,81.87) 146.61,80.17 140.92,80.17 140.83,80.08 v4(140,80.08)
  BOTTOM w0.165: v2(149.48,82.95) 149.48,82.2 R953.2 148.47,82.04 v3(148.31,81.87)
SST_HOLDJ_1: length 11.5
  TOP w0.102: SRCON1.7 140.48,104.84 140.11,105.22 140.11,106.69 v3(140.59,107.17) 141.1,107.68 141.1,109.14 143.89,111.93 R183.2
SUS3V_FON_N: length 9.5
  TOP w0.102: U24.56 50.47,51.07 50.04,50.64 50.04,49.01 v3(49.78,48.75)
  BOTTOM w0.102: v3(49.78,48.75) 49.03,48.75 v2(48.64,48.37) 48.59,48.31 48.59,46.65 48.62,46.62 48.62,45.59 R1023.1
SUS3V_ON_N: length 6.5
  TOP w0.102: v3(49.1,45.86) 48.73,45.86 47.81,46.78 U24.74
  BOTTOM w0.102: v2(50.29,48.09) 50.07,47.87 50.07,47.17 R1020.1 49.1,46.2 v3(49.1,45.86)
SUS5V_ON_N: length 9.1
  TOP w0.102: U24.73 46.66,47.18 46.71,47.13 47.35,47.13 47.37,47.1 v3(48.13,47.1)
  BOTTOM w0.102: v3(48.13,47.1) 48.13,46.67 48.18,46.62 48.18,46.62 48.31,46.49 48.31,44.82 47.83,44.34 v2(47.83,43.16) R1039.2 R1038.1
SUS_ACK_EN_N: length 9.5
  TOP w0.254: U24.94 44.9,38.78 44.29,39.39 43.12,39.39 43.02,39.49 42.64,39.49 42.54,39.58 R535.1 42.46,39.09 v1(43.16,38.38) 43.69,37.86 R551.1 43.05,36.5 43.05,35.8 42.43,35.18 Q74.1
SUS_LED_GREEN_1: length 3.7
  TOP w0.254: R1043.1 18.43,40.89 19.21,40.89 v1(19.81,40.29) 19.99,40.12 R1050.2
SUS_LED_GREEN_C: length 13.8
  TOP w0.254: R1043.2 v3(15.6,40.5)
  BOTTOM w0.254: v3(15.6,40.5) 15.62,40.5 15.84,40.28 Q107.D 15.7,39.4 14.15,40.95 13.6,40.95 13.59,40.94 R1036.2 9.97,40.94 9.12,40.09 6.66,40.09 PWRCN1.4
SUS_PWR_ACK: length 235.5
  TOP w0.102: R259.2 143.14,93.43 141.3,91.59 141.3,90.74 139.57,89.01 v3(139.57,88.96) 139.57,88.71 139.78,88.5 139.78,85.7 139.69,85.61 139.69,85.15 139.75,85.09 139.75,84.94 139.87,84.69 139.88,84.67 139.88,84.14 U29.AJ37 ; v3(45.39,35.7) 45.42,35.72 45.42,35.87 45.04,36.24 R551.2 43.48,36.04 43.48,35.62 43.18,35.31 43.18,33.64 43.69,33.13 R572.1
  L3 w0.127: v3(156.67,51.22) 156.67,50.45 155.37,49.15 155.37,47.42 152.15,44.2 152.15,38.52 150.44,36.81 150.34,36.81 148.72,35.19 148.72,33.54 137.83,22.66 137.83,21.44 134.29,17.9 132.39,17.9 132.28,18.01 128.99,18.01 126.14,15.15 121.38,15.15 121.37,15.15 121.06,15.15 121.03,15.18 120.11,15.18 119.77,15.52 117.68,15.52 117.19,16.01 106.83,16.01 106.34,15.52 101.82,15.52 101.38,15.08 93.65,15.08 93.24,14.67 92.68,14.67 92.6,14.74 91.88,14.74 91.8,14.67 89.94,14.67 88.63,13.36 88.08,12.81 80.8,12.81 78.11,10.12 73.26,10.12 72.5,10.87 72.5,11.41 69.68,14.23 69.68,15.52 67.85,17.36 67.06,17.36 59.35,25.07 59.35,25.94 54.86,30.42 54.86,33.52 v3(54.67,33.72)
  L4 w0.127: v3(139.57,88.96) 140.55,89.94 144.2,89.94 144.47,90.21 145.47,90.21 146.74,88.93 152.9,88.93 153.02,88.81 153.29,88.81 158.34,83.76 158.34,73.54 158.34,73.32 161.33,70.34 161.33,67.32 160.81,66.8 160.81,63.14 160.24,62.57 160.24,61.67 160.46,61.44 160.46,61.05 159.52,60.11 159.52,54.81 159.26,54.54 159.26,54.44 156.67,51.85 v3(156.67,51.22) ; v3(45.39,35.7) 45.36,35.67 45.35,35.67 45.22,35.54 45.22,33.52 47.87,30.88 51.19,30.88 54.03,33.72 v3(54.67,33.72)
  BOTTOM w0.102: v3(45.39,35.7) 45.39,35.67 45.13,35.41 44.64,35.41 R1068.2 44.95,33.84 R1072.2 44.95,32.67 C706.1 v2(44.97,31.71)
SUS_PWR_ACK_5V_DUAL: length 3.1
  BOTTOM w0.254: R1073.1 R1069.1 ; R1069.1 41.99,34.62 R1071.1 ; R1069.1 41.95,35.07 v2(41.55,35.47)
SUS_PWR_ACK_5V_DUAL_L: length 4.4
  TOP w0.254: v3(41.73,31.73) 41.78,31.78 Q74.5
  BOTTOM w0.254: R1073.2 C705.1 ; C705.1 41.06,32.38 41.73,31.71 v3(41.73,31.73) ; C705.1 40.08,32.57 v2(40.01,32.5)
SUS_PWR_ACK_BJT: length 5.7
  TOP w0.254: v1(39.57,34.15) 39.78,33.94 41.44,33.94 41.78,34.29 Q74.2 41.78,35.33 42.35,35.9 R547.2 R543.2
SUS_PWR_ACK_BJT_L: length 3.9
  TOP w0.254: v1(39.4,35.54) 39.74,35.89 40.09,35.89 40.32,36.12 R545.1 40.45,36.18 R547.1 41.47,35.73 41.13,35.4 Q74.3
SUS_PWR_ACK_R: length 4.3
  TOP w0.102: R573.1 43.38,30.53 R572.2 ; R573.1 42.43,31.48 Q74.6 ; R573.1 42.33,31.2 41.71,31.2 v1(41.4,30.9)
SUS_STAT_N: length 7.6
  TOP w0.102: U29.AD37 137.36,84.3 137.31,84.37 137.28,84.91 137.28,85.01 137.21,85.18 137.21,85.64 137.25,85.68 137.25,86.35 137.17,86.42 137.17,89.31 136.54,89.94 v1(136.49,89.94) 136.27,90.15 R278.1
SUS_WARNB: length 11.7
  TOP w0.102: R259.1 142.45,93.46 R253.1 R252.1 141.13,93.39 141.64,92.88 141.64,92.47 140.46,91.3 v1(140.46,90.82) 140.46,90.21 139.64,89.39 139.39,89.39 139.14,89.14 139.14,88.78 139.5,88.43 U29.AG41
SUS_WARNB_R: length 240
  TOP w0.102: v1(141.91,96.02) 141.91,95.59 v3(141.53,95.21) 141.58,95.21 141.83,94.95 141.83,94.94 142.1,94.68 142.11,94.68 142.28,94.51 R253.2 ; v3(49.12,49.42) 48.88,49.18 U24.68
  L3 w0.127: v3(49.12,49.42) 49.12,48.53 49.57,48.08 49.57,45.31 48.23,43.97 48.23,42.98 49.09,42.12 49.09,37.26 48.98,37.16 48.98,34.21 50.93,32.26 51.11,32.26 58.08,25.29 58.08,24.23 62.12,20.18 62.12,19.01 64.19,16.95 64.19,16.84 68.63,12.39 68.63,10.02 68.96,9.69 70.16,9.69 73.32,6.52 81.98,6.52 85.96,10.51 92.81,10.51 93.18,10.88 101.24,10.88 103.33,12.96 126.59,12.96 128.63,15 134.01,15 139.03,20.01 143.16,20.01 143.58,19.59 144.46,19.59 145.04,20.18 149.19,20.18 152.91,23.89 v3(152.91,24.37)
  L4 w0.127: v3(152.91,24.37) 152.78,24.49 152.78,27.03 154.91,29.17 155.16,29.17 155.48,29.49 155.53,29.49 155.83,29.78 155.83,34.15 155.45,34.53 155.45,37.75 155.7,38 155.7,41.56 155.7,42.53 157.23,44.05 157.23,46.85 160.86,50.48 160.86,53.88 162.6,55.62 162.6,65.09 162.41,65.28 162.41,66.14 162.93,66.66 162.93,71 160.02,73.91 160.02,82.57 160.02,82.99 160.02,82.99 160.02,83.76 160.02,87.99 156.51,91.5 151.46,91.5 148.94,94.01 144,94.01 143,95.01 143,95.24 142.54,95.7 142.02,95.7 v3(141.53,95.21)
SUSCLK: length 101.2
  TOP w0.102: U29.W36 135.09,83.18 v4(134.64,82.74) ; R429.1 163.37,64.4 163.83,63.94 v3(163.83,63.81)
  L3 w0.127: v3(154.18,107.48) 154.18,106.54 151.75,104.11 141.86,104.11 138.47,100.72 136.5,100.72 136.09,100.31 136.09,98.65 134.02,96.58 133.9,96.58 131.49,94.17 131.49,91.48 v4(130.92,90.9)
  BOTTOM w0.102: v3(163.83,63.81) 163.83,64.25 164.41,64.83 164.41,73.35 166.05,74.99 166.55,74.99 167.38,75.83 167.38,79.73 167.38,80.35 167.13,80.6 167.13,82.17 167.13,82.57 163.89,85.81 163.89,94.53 161.28,97.14 157.61,97.14 v2(156.46,98.28) 156.31,98.43 156.31,101.12 156.03,101.4 156.03,105.46 154.18,107.32 v3(154.18,107.48) ; v4(134.64,82.74) 134.72,82.81 134.72,84.72 134.24,85.2 134.24,85.84 134.77,86.37 134.77,88.65 133.8,89.62 133.53,89.62 132.25,90.9 v4(130.92,90.9) 130.81,91 R915.1
SUSCLK_1: length 6.4
  TOP w0.102: v1(163.01,63.36) R436.1 R435.1 R429.2 160.57,63.52 160.11,63.98 U21.1
SUSCLK_NGFF: length 301.4
  TOP w0.102: U21.7 159.46,60.23 159.74,60.51 161.47,60.51 161.87,60.91 R435.2 161.49,61.36 161.04,61.81 v3(161.04,62.24) ; v3(107.6,233.96) 107.92,234.27 109.04,234.27 109.32,234.55 NGFF1.50
  L4 w0.127: v3(107.6,233.96) 107.59,233.96 106.62,232.99 106.62,225.69 108.25,224.05 108.25,223.8 110.61,221.45 110.64,221.45 114.43,217.66 116.24,217.66 116.58,217.32 116.97,217.32 118.51,218.86 123.26,218.86 123.75,218.36 124.35,218.36 124.46,218.26 126.67,218.26 127.89,217.04 127.89,216.73 128.28,216.34 129.58,216.34 129.97,215.95 136.97,215.95 138.96,213.95 153.83,213.95 158.86,218.98 170.23,218.98 171.87,220.62 179.65,220.62 182.41,217.86 182.41,216.55 183.87,215.09 183.87,196.72 184.02,196.57 184.02,188.69 183.03,187.7 183.03,186.71 178.45,182.13 178.45,175.67 181.97,172.15 182.35,172.15 186.32,168.17 186.32,160.16 186.42,160.06 186.42,157.22 186.32,157.12 186.32,144.48 178.23,136.39 178.23,124.12 169.85,115.73 165.84,115.73 164.41,114.31 156.58,114.31 151.64,109.37 v3(151.64,108.95)
  BOTTOM w0.102: v3(161.04,62.24) 161.04,62.7 161.67,63.33 163.99,63.33 165,64.34 165,72.27 165.65,72.92 165.65,73.16 167.18,74.69 167.18,74.94 167.91,75.67 168.15,75.91 v2(168.15,77.58) 168.15,78.89 168.3,79.04 168.3,80.12 167.61,80.8 167.61,81.97 167.61,82.77 164.37,86.01 164.37,95.38 162,97.75 157.93,97.75 156.79,98.89 156.79,105.54 156.65,105.69 154.15,108.19 152.78,108.19 152.02,108.95 v3(151.64,108.95)
SUSCLK_SIO: length 209.6
  TOP w0.102: v3(47.12,47.61) 48.66,47.61 49.37,46.9 50.96,46.9 53.86,44 56.8,44 57.05,44.26 58.09,44.26 58.17,44.18 59.25,44.18 59.5,44.43 59.9,44.43 60.12,44.66 60.12,44.82 60.48,45.18 U24.19 ; v3(163.86,61.36) R436.2 163.01,60.51 162.53,60.03 v1(162.23,60.03) 161.19,60.03 160.43,59.27 U21.8
  L3 w0.127: v3(67.49,9.53) 67.31,9.71 67.31,12.99 63.68,16.63 63.68,16.71 61.49,18.89 61.49,18.93 61.07,19.35 61.07,20.32 57.57,23.82 57.57,25.08 50.9,31.75 50.62,31.75 47.69,34.68 47.69,41.52 46.65,42.57 46.65,47.14 v3(47.12,47.61)
  L4 w0.127: v3(163.86,61.36) 163.86,56.16 161.37,53.67 161.37,50.27 157.73,46.64 157.73,43.3 156.84,42.41 156.84,42.4 156.21,41.77 156.21,37.79 156.08,37.66 156.08,34.61 156.34,34.36 156.34,29.03 156.25,28.94 156.25,28.71 155.93,28.39 155.03,28.39 154.18,27.54 154.18,22.73 150.74,19.29 150.49,19.29 148.77,17.57 146.54,17.57 143.93,14.97 141.14,14.97 138.97,14.97 132.85,8.86 132.85,8.81 131.75,7.71 123.65,7.71 122.76,8.59 119.86,8.59 118.78,7.52 110.05,7.52 108.86,8.7 107.04,8.7 105.99,7.65 96.9,7.65 96.16,8.39 94.08,8.39 93.4,7.71 91.16,7.71 90.53,8.34 87.99,8.34 87.25,7.6 80.43,7.6 80.43,7.6 80.01,7.6 79.24,6.83 74.74,6.83 71.43,10.14 71.09,10.14 70.64,9.69 67.64,9.69 v3(67.49,9.53)
SWR_LX: length 1.9
  BOTTOM w0.203: v2(126.85,209.86) 126.93,209.95 U37.17
SWR_V12: length 27.3
  TOP w0.508: C32.1 124.99,207.53 125.29,207.82 C33.1 126.28,207.82 v3(126.59,208.14) ; v3(129.13,206.41) 130.05,206.41 v1(130.1,206.46) 130.18,206.54 C34.1 ; v3(135.76,210.35) 135.76,210.65 136.03,210.92 C29.1
  L3 w0.508: v3(129.13,206.41) 127.41,208.14 v3(126.59,208.14)
  L4 w0.508: v3(135.76,210.35) 133.78,208.37 129.99,208.37 129.52,208.84 128.22,208.84 127.53,208.14 v3(126.59,208.14)
  BOTTOM w0.203: U37.43 v3(135.76,210.35) ; U37.11 129.9,207 129.31,206.41 v3(129.13,206.41) ; v3(126.59,208.14) 127.23,208.77 127.64,208.77 128.01,209.15 U37.15
  BOTTOM w1.27: L28.2 125.84,207.38 v3(126.59,208.14)
SYS_FAN_TACH1_1: length 11.2
  L4 w0.127: FANC1.3 8.54,178.02 8.54,183.78 v3(8.64,183.88)
  BOTTOM w0.102: R805.2 10.83,184.24 R806.2 10.66,184.34 v2(9.55,184.34) 9.09,184.34 v3(8.64,183.88)
SYS_FAN_TACH1_2: length 4
  BOTTOM w0.102: R805.1 R804.1 13.86,183.19 R807.1 13.78,182.9 14.15,182.53 14.61,182.53 v2(14.99,182.15)
SYS_FAN_TACH3_1: length 10.1
  TOP w0.165: R490.1 104.71,49.56 R491.2 107.58,49.56 111.28,45.86 111.28,45.86 FANC2.2
SYS_FAN_TACH3_2: length 5.8
  TOP w0.165: R489.1 103.59,50.25 103.36,50.25 102.62,49.51 v3(102.62,49.13) 103.06,48.69 R488.1 104.67,48.69 R490.2
  BOTTOM w0.165: v3(102.62,49.13) v2(103.43,49.13)
SYSTEM_FAN_PWM1_1: length 16.4
  BOTTOM w0.102: R810.2 12.89,182.04 D16.A 11.86,183.07 8.34,183.07 R811.2 7.91,183 7.39,182.48 7.39,181.04 8.03,180.4 10.26,180.4 10.67,179.99 10.67,178.43 FANC1.4
SYSTEM_FAN_PWM1_2: length 12.2
  TOP w0.165: FANC2.1 114.65,43.47 R534.2 R533.2 117.1,39.87 117.1,38.07 116.61,37.58 D9.A 115.93,36.68 v1(116.55,36.05)
TCM_BA0: length 5.3
  TOP w0.127: U22.9 U23.9 145.96,33.6 146.81,32.75 R424.1 147.64,31.8 v1(147.7,31.73)
TCM_BA1: length 4.1
  TOP w0.127: v1(140.34,33.07) R425.1 141.48,33.44 142.06,34.02 U23.3 U22.3
TCM_CLK_RUN: length 5.8
  TOP w0.127: U22.15 U23.15 149.21,43.02 149.35,43.16 149.86,43.16 149.99,43.04 149.99,42.27 150.5,41.77 v1(151.13,41.77) 151.13,42.59 R474.1
TCM_NC5#: length 4.2
  TOP w0.127: U22.5 U23.5 143.36,34.15 142.49,33.28 C241.1 143.14,33.07 v1(143.43,32.78)
TCM_NCP: length 5.3
  TOP w0.127: C240.1 151.13,31.99 v1(150.5,32.62) 149.21,33.91 U23.14 U22.14
TD_IREF: length 3.9
  TOP w0.165: U29.C3 127.12,65.57 v4(127.2,65.49)
  BOTTOM w0.165: R987.1 128.01,64.79 127.57,64.35 v2(126.97,64.35) 126.8,64.53 126.8,65.08 v4(127.2,65.49)
TESTEN: length 10.8
  TOP w0.356: v4(75.37,79.97) 75.01,80.34 U13.K7
  L3 w0.508: v4(77.9,75.05) 77.86,75.09 77.86,75.09 76.21,76.74 76.21,79.14 v4(75.37,79.97)
  BOTTOM w0.508: R304.1 R302.1 78.61,72.44 78.61,73.64 78.79,73.82 v2(78.79,73.88) 77.9,74.77 v4(77.9,75.05)
TESTLOW_1: length 5.3
  TOP w0.102: v3(73.29,153.15) CPU1.P6
  BOTTOM w0.102: R829.1 73.79,155.94 73.79,153.64 v3(73.29,153.15) 72.43,154.01 v2(72.36,154.01)
TESTLOW_2: length 7.2
  TOP w0.102: v3(73.29,151.32) CPU1.N5
  BOTTOM w0.102: v2(72.45,151.1) 72.67,151.32 v3(73.29,151.32) 73.79,151.81 73.79,153.36 73.99,153.56 73.99,155.11 R828.1
TMIN_SHIFT: length 264
  TOP w0.102: U24.33 59.67,52.55 60.33,53.21 60.33,53.53 60.86,54.06 60.86,55.14 R452.1 61.53,55.81 62.18,55.81 v1(62.23,55.76) 62.23,55.28 61.19,54.24 61.19,53.73 v3(60.83,53.37) ; U29.AJ39 140.1,84.74 140.1,84.87 139.95,85.18 139.9,85.23 139.9,85.27 139.9,85.53 140,85.63 140,88.78 140,88.78 140,89.16 141.5,90.65 141.5,91.14 143.31,92.95 143.88,92.95 R251.1 144.91,93.98 144.91,94.63 143.88,95.67 142.77,95.67 v3(142.34,95.23)
  L3 w0.127: v3(152.15,24.37) 149.77,21.99 149.77,21.47 149.45,21.15 139.45,21.15 135.44,17.14 132.07,17.14 131.97,17.24 129.63,17.24 125.86,13.47 119.81,13.47 118.54,14.74 115.8,14.74 115.3,15.24 107.2,15.24 106.72,14.75 103.21,14.75 101.2,12.74 94.33,12.74 92.6,11.02 80.09,11.02 78.43,9.36 72.94,9.36 70.53,11.77 69.97,11.77 64.69,17.05 64.69,17.6 62.99,19.31 62.99,20.06 58.59,24.47 58.59,25.56 54.05,30.09 54.05,30.8 52.09,32.77 51.14,32.77 49.49,34.42 49.49,36.95 49.6,37.05 49.6,42.33 48.73,43.19 48.73,43.76 50.08,45.1 50.08,47.85 55.06,52.84 60.3,52.84 v3(60.83,53.37)
  L4 w0.127: v3(152.15,24.37) 152.15,24.49 152.27,24.62 152.27,27.26 154.27,29.25 154.27,37.28 155.19,38.21 155.19,41.35 155.19,45.7 160.35,50.86 160.35,54.09 162.09,55.83 162.09,64.87 161.9,65.07 161.9,66.35 162.42,66.87 162.42,70.79 159.51,73.7 159.51,87.78 156.89,90.41 154.41,90.41 154.32,90.32 151.86,90.32 148.59,93.59 143.7,93.59 142.34,94.95 v3(142.34,95.23)
TP3131_GVDD: length 6.8
  TOP w0.203: C268.1 161.93,42.02 R516.1 162.12,40.94 163,40.05 R517.2 162.39,39.37 162.39,39.24 v1(161.93,38.79) 161.31,38.16 160.94,38.16 160.76,37.98 U25.2
TP_1P5_PCH_PWROK: length 4.3
  TOP w0.102: M1.7 v1(137.57,51.71) 138.62,51.71 PR79.2 R479.2
TP_1P5_PCH_PWROK_1: length 1.2
  TOP w0.102: PR79.1 TP31.1
TP_ALL_PWRGD: length 1.9
  TOP w0.102: v3(99.97,44.23) 99.95,44.21 R523.2
  BOTTOM w0.102: v3(99.97,44.23) 99.85,44.11 TP147.1
TP_CPU_G38: length 2
  TOP w0.102: v3(67.81,183.69) CPU1.G38
  BOTTOM w0.102: TP59.1 66.91,184.59 v3(67.81,183.69)
TP_CPU_H37: length 3.5
  TOP w0.102: v3(68.72,183.69) CPU1.H37
  BOTTOM w0.102: v3(68.72,183.69) 68.26,184.15 68.26,186.05 TP54.1
TP_CPU_H38: length 4.2
  TOP w0.102: v3(68.72,184.61) CPU1.H38
  BOTTOM w0.102: v3(68.72,184.61) 68.72,184.83 69.18,185.29 69.18,185.89 68.07,187 TP46.1
TP_CPU_J38: length 2.8
  TOP w0.102: v3(69.63,184.61) CPU1.J38
  BOTTOM w0.102: TP51.1 70.07,186.23 70.07,185.04 v3(69.63,184.61)
TP_CPU_K37: length 4.1
  TOP w0.102: v3(70.55,183.69) CPU1.K37
  BOTTOM w0.102: v3(70.55,183.69) 71.37,184.52 71.37,186.62 TP50.1
TP_CPU_K39: length 1.6
  TOP w0.102: v3(70.55,184.61) CPU1.K39
  BOTTOM w0.102: v3(70.55,184.61) 70.74,184.8 TP57.1
TP_CPU_M38: length 4.2
  TOP w0.102: v3(72.38,184.61) CPU1.M38
  BOTTOM w0.102: v3(72.38,184.61) 72.38,184.88 71.91,185.35 71.91,186.13 72.32,186.55 72.32,187.29 TP43.1
TP_CPU_N36: length 4.4
  TOP w0.102: v3(73.33,182.76) 73.75,182.34 CPU1.N36
  BOTTOM w0.102: v3(73.33,182.76) 73.72,183.15 73.72,186.24 TP53.1
TP_CPU_T35: length 7.2
  TOP w0.102: CPU1.T35 v3(76.04,181.87)
  BOTTOM w0.102: TP44.1 75.58,186.31 75.58,182.32 v3(76.04,181.87)
TP_DET: length 232.6
  TOP w0.102: U29.AT34 143.37,81.96 v4(143.34,81.93) ; TOUCH1.1 6.7,18.97 R579.2 10.21,19.02 10.21,21.45 15.04,26.27 v1(15.04,26.48) 15.24,26.68 15.24,28.3 v3(15.09,28.46)
  L4 w0.127: v4(143.34,81.93) 143.74,81.93 144.36,82.55 148.59,82.55 149.02,82.11 149.02,74.33 150.7,72.66 150.7,72.65 152.05,71.3 152.05,71.01 153.01,70.05 153.01,67.61 151.65,66.25 151.65,62.16 151,61.52 151,61.49 151,59.51 150.29,58.8 150.29,54.08 149.25,53.04 149.25,47.43 149.39,47.29 149.39,45.23 151.92,42.71 151.92,35.95 149.14,33.17 149.14,29.4 146.3,26.57 146.3,25.24 142.37,21.31 142.37,20.11 140.15,17.89 138.95,17.89 133.87,12.81 90.04,12.81 89.66,12.43 79.67,12.43 77.75,10.51 74.86,10.51 72.2,13.17 65.84,13.17 65.77,13.23 65.75,13.23 65.19,13.79 61.84,13.79 61.51,14.12 60.69,14.12 60.16,13.59 56.55,13.59 56.34,13.79 46.4,13.79 46.21,13.59 41.14,13.59 40.23,14.51 39.16,14.51 36.82,16.85 36.82,17.07 36.54,17.35 36.32,17.35 35.53,18.13 34.93,18.13 34.63,18.44 34.63,19.13 34.06,19.71 33.66,19.71 30.67,22.69 29.64,22.69 28.39,23.94 28.39,24.84 26.85,26.37 20.89,26.37 19.34,27.92 15.62,27.92 v3(15.09,28.46)
TP_DISP_J12: length 1.5
  TOP w0.102: v3(69.63,158.63) CPU1.J12
  BOTTOM w0.102: v3(69.63,158.63) 70.5,158.63 TP84.1
TP_DISP_K11: length 4.6
  TOP w0.102: v3(69.63,156.81) CPU1.K11
  BOTTOM w0.102: v3(69.63,156.81) 68.44,156.81 68,156.37 67.54,156.37 67.26,156.64 TP88.1
TP_GPIO52: length 20.3
  TOP w0.102: U29.AJ26 140.41,77.99 v4(140.74,78.32) ; v3(157.1,77.71) 157.46,78.07 R357.1
  BOTTOM w0.102: v3(157.1,77.71) 155.7,76.31 v2(153.92,76.31) 153.47,76.77 152.32,76.77 151.49,77.61 143.38,77.61 143.28,77.71 143.26,77.71 143.2,77.77 141.29,77.77 v4(140.74,78.32)
TP_GPU_CLKREQ#: length 5
  TOP w0.102: v4(76.53,81.01) 77.15,80.39 U13.N7
  BOTTOM w0.102: v4(76.53,81.01) 76.83,81.01 78.05,79.79 78.05,78.94 78.36,78.63 TP158.1
TP_H_CATERR_N: length 1.6
  TOP w0.102: v3(72.38,182.78) CPU1.M36
  BOTTOM w0.102: v3(72.38,182.78) 72.49,182.9 TP60.1
TP_LPC_DRQ0_N: length 5.8
  TOP w0.102: U29.AK22 140.8,75.84 140.8,76.11 v4(140.78,76.12)
  BOTTOM w0.102: v4(140.78,76.12) 141.05,76.38 142.38,76.38 142.84,75.93 144.3,75.93 144.32,75.92 144.65,75.92 144.67,75.93 144.78,75.93 145.01,76.16 TP131.1
TP_NGFF_COEX1: length 5.5
  TOP w0.102: v3(106.9,234.26) 107.4,234.76 108.84,234.76 109.14,235.05 NGFF1.48
  BOTTOM w0.102: TP39.1 107.73,233.18 106.9,234.01 v3(106.9,234.26)
TP_NGFF_COEX2: length 5.6
  TOP w0.102: v3(106.1,234.34) 106.9,235.14 108.9,235.14 109.31,235.55 NGFF1.46
  BOTTOM w0.102: TP38.1 106.1,234.07 v3(106.1,234.34)
TP_NGFF_COEX3: length 3
  TOP w0.102: NGFF1.44 108.84,236.05 v3(108.43,235.65)
  BOTTOM w0.102: TP37.1 108.43,234.6 v3(108.43,235.65)
TP_NGFF_LED1: length 2.9
  TOP w0.102: NGFF1.6 109.17,245.55 v3(108.71,245.09)
  BOTTOM w0.102: TP35.1 108.71,243.98 v3(108.71,245.09)
TP_NGFF_LED2: length 3.9
  TOP w0.102: NGFF1.16 108.19,243.05 v3(107.7,242.55)
  BOTTOM w0.102: TP36.1 107.31,242.93 v3(107.7,242.55)
TP_NGFF_MLDIR: length 2.6
  TOP w0.102: NGFF1.17 v3(116.28,242.8)
  BOTTOM w0.102: TP34.1 116.33,242.75 v3(116.28,242.8)
TP_PCH_A2: length 5.4
  TOP w0.102: U29.A2 125.32,61.93 124.49,61.1 TP29.1
TP_PCH_A3: length 5.3
  TOP w0.102: TP26.1 124.89,62.05 124.89,65.1 U29.A3
TP_PCH_AE30: length 1.6
  TOP w0.102: U29.AE30 138.42,79.89 v4(138.76,79.89)
  BOTTOM w0.102: v4(138.76,79.89) 138.81,79.89 TP126.1
TP_PCH_AH24: length 1.7
  TOP w0.102: v4(139.21,77.1) 139.21,77.07 U29.AH24
  BOTTOM w0.102: v4(139.21,77.1) 139.22,77.11 TP128.1
TP_PCH_AJ14: length 1.5
  TOP w0.102: v4(140.08,70.63) 140.3,70.85 140.3,70.91 140.41,71.02 U29.AJ14
  BOTTOM w0.102: TP137.1 139.7,71.02 v4(140.08,70.63)
TP_PCH_AK14: length 1.7
  TOP w0.102: U29.AK14 140.73,70.85 v4(140.73,70.73)
  BOTTOM w0.102: v4(140.73,70.73) 140.73,70.23 TP141.1
TP_PCH_AM34: length 5.1
  TOP w0.102: U29.AM34 141.67,81.88 141.35,81.57 v4(141.33,81.57)
  BOTTOM w0.102: TP120.1 142.93,82.54 142.64,82.25 142.01,82.25 v4(141.33,81.57)
TP_PCH_AN16: length 7.9
  TOP w0.102: U29.AW23 146.03,76.13 146.52,76.13 149.36,73.29 150.34,73.29 151.1,72.54 TP19.1
TP_PCH_AP18: length 5.8
  TOP w0.102: U29.AV22 145.55,75.36 146.11,75.36 147.09,74.39 147.09,74.14 148.9,72.32 TP18.1
TP_PCH_AV13: length 9.6
  TOP w0.102: U29.AT26 144.56,77.21 145.56,77.21 145.81,76.95 146.58,76.95 149.12,74.41 152.02,74.41 TP17.1
