# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
TR13  MCM1012B900FBP-GP-U  [L125100-4P-1H37]  12.14 26.35 0 top
U1  M24C64-WMN6TP-2-GP  [SOIC8H69]  137.06 216.06 270 top
U2  M24C64-WMN6TP-2-GP  [SOIC8H69]  147.19 214.49 180 top
U3  RT8237CZQW-2-GP  [DFN10G3-G265175H32]  181.74 192.9 180 top
U4  2N7002KDW-1-GP  [SOT-363H44]  177.42 185.15 90 top
U5  NCP81161MNTBG-GP  [DFN8G2-G1309-UH40]  22.23 167.24 90 top
U6  AO4407AL-GP  [SOIC8H69]  18.92 141.84 90 bottom
U9  ISL62882CHRTZ-T-GP  [QFN40-G3D5H32]  41 139.51 0 top
U10  AZ1045-04F-R7G-GP  [DFN10G2510H26]  186.97 126.27 270 top
U11  AZ1045-04F-R7G-GP  [DFN10G2510H26]  187.81 104.53 270 top
U12  MX25L6473EM21-10G-GP  [SOIC8-1H86]  138.04 104.21 270 top
U13  SUN-S3-XT-GP  [BGA631M23H82]  80.15 87.94 90 top
U14  APL5611ACI-TRG-GP  [SOT-6H58]  123.57 103.29 270 top
U15  RT8237CZQW-2-GP  [DFN10G3-G265175H32]  160.91 101.94 90 top
U16  ALC3661-CG-GP  [QFN48J6-G465H40]  179.32 89.01 0 top
U17  NCP81161MNTBG-GP  [DFN8G2-G1309-UH40]  19.14 226.13 270 bottom
U18  SI4214DDY-T1-GE3-GP  [SOIC8H69]  32.08 84.26 0 top
U20  NCP1589AMNTWG-GP-U1  [QFN10-G255185-UH40]  34.88 72.29 0 top
U21  SL23EP04NZZC-1T-GP  [TSOIC8H44]  159.13 62.09 180 top
U22  ST33ZP24AR28PVSP-D-GP  [TSOIC28H48]  144.98 38.62 0 top
U23  SSX44-B-D-T-GP  [TSOIC28-3H44]  144.98 38.62 0 top
U24  SCH5553-NU-GP  [PFPCC128-5H48]  53.47 44.18 270 top
U25  TPA3131D2RHBR-GP-U  [QFN32-G3D55H40]  159.51 34.65 0 top
U26  RTL8111G-CGT-1-GP-U1  [QFN32J4-G2D9-U1H36]  28.78 36.28 180 top
U27  AZ1045-04F-R7G-GP  [DFN10G2510H26]  55.52 27.26 90 top
U28  IP4223CZ6-1-GP  [SOT-6H44]  23.83 27.03 0 top
U29  LYNX-POINT-2-GP-U  [BGA708Z2322H65]  135.62 75.05 90 top
U30  IP4223CZ6-1-GP  [SOT-6H44]  27.89 27.03 0 top
U31  AZ1045-04F-R7G-GP  [DFN10G2510H26]  43.43 27.03 270 top
U32  2N7002KDW-1-GP  [SOT-363H44]  62.36 25.38 270 top
U33  AZ1045-04F-R7G-GP  [DFN10G2510H26]  61.98 22.21 180 top
U34  2N7002KDW-1-GP  [SOT-363H44]  33.02 9.38 0 top
U35  NCP81102MNTXG-SI3-GP  [QFN32J4-G2D8-3H40]  17.65 239.12 180 bottom
U36  AO6402A-GP  [SOT-6-1H50]  115.85 215.88 90 bottom
U37  RTD2136S-CG-GP  [QFN48J6-G4D55H40]  131.7 210.55 0 bottom
U38  NCP81161MNTBG-GP  [DFN8G2-G1309-UH40]  19.12 203.63 270 bottom
U39  OZ621FJ1LN-B-0-TR-GP  [QFN32J4-G2D8-4H32]  181.48 157.08 270 bottom
U40  AO4407AL-GP  [SOIC8H69]  18.92 136.13 90 bottom
U41  APL5337KAI-TRG-GP  [SOIC8-G3530H63]  131.09 112.46 270 bottom
U43  AZC099-04S-1-GP  [SOT-6H58]  38.73 22.06 90 bottom
U44  AZC099-04S-1-GP  [SOT-6H58]  38.73 17.99 270 bottom
U46  LMV7275MG-NOPB-GP  [SC70-5H44]  21.49 144.51 0 top
U47  INA199A1-GP  [SC70-6H44]  26.7 144.48 0 top
U48  AO4407AL-GP  [SOIC8H69]  21.84 157.46 0 top
U49  PM25LD010C-SCE-1-GP  [SOIC8H69]  93.38 63.17 0 top
UHS1  AUDIO-JK441-GP  [2SJ3082-003111F]  201.5 85.55 270 top
USB3  SKT-USB6-127-GP  [SKT-USB6-146072]  94.95 12.88 90 top
USB4  SKT-USB6-127-GP  [SKT-USB6-146072]  107.85 12.88 90 top
USB5  SKT-USB6-127-GP  [SKT-USB6-146072]  120.75 12.88 90 top
USB6  SKT-USB6-127-GP  [SKT-USB6-146072]  133.65 12.88 90 top
VGA1  D-SUB-15-240-GP  [28-00120-1A61-A]  51.6 10.88 0 top
WEBCM1  JWT-CON8-4-GP  [A1251WR0-8PS-5E]  167.62 227.55 180 top
X1  X-32D768KHZ-40GPU  [MC-146H56]  160.6 86.75 0 top
X3  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  118.41 50.58 180 top
X4  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  20.7 36.99 270 top
X5  XTAL-27MHZ-85-GP  [SMD-OSC6H30]  98.3 97.77 90 top
XDPC1  DM-SMC-CONN60A-GP-01  [DM-BSH-03001-FDA-01]  56.11 239.53 180 bottom

## Library data of the parts
ATX1 = G881A04102TEU: tolerance: 020.80050.0004
ATX2 = 733-71-08TB12: tolerance: 20.81924.008
BT1 = AAA-BAT-034-K01: tolerance: 62.70010.031
BTPWR1 BTRST1 DB1 MEJ1 PSWD1 = A2541WV0-1EX2PA-6T: tolerance: 21.60909.102
C1-C6 C9 C17 C20 C26 C38-C40 C48 C49 C79 C88 C93 C94 C100 C101 C103-C105 C110 C115 C116 C118-C120 C123-C125 C143 C144 C154 C168 C173 C187 C194 C198 C226 C232 C241 C243 C244 C247 C248 C257 C273 C276 C284-C286 C290 C291 C295 C297 C300 C303 C310-C312 C354 C357 C359 C362 C364-C369 C373 C374 C376 C379 C381 C384 C387 C388 C392-C394 C396 C401 C404-C409 C414 C415 C418 C419 C428 C430 C431 C434-C437 C442 C444-C448 C450 C452 C453 C456-C458 C467-C472 C474 C476 C481 C501 C502 C539 C544 C550 C572 C581 C584 C598-C600 C606 C633-C635 C639-C646 C648 C649 C654-C658 C661 C668-C672 C674 C676-C678 C683 C685-C688 C691-C696 C698-C701 C703-C706 C709 C710 C712 C713 C717 C719 C720 C724-C726 C732 C763 C764 C831-C834 C869 C870 PC35 = C402H22: tolerance: 78.10421.2FL
C7 C19 C21 C28 C31 C127 C160 C172 C178 C183 C188 C189 C195 C215 C219 C250 C272 C289 C432 C438 C503-C505 C579 C591 C613 C619 C625 C628 C631 C632 C636 C638 C647 C650-C653 C659 C662 C664 C697 C716 C718 C758-C761 C765-C770 C773 C775-C779 C782 C783 C785 C786 C793-C796 C798-C803 C805-C809 C813-C819 C823-C825 C827 C835 C863 C864 PC1 PC72 = C402H22: tolerance: 78.10523.5FL
C8 C179 C317 C391 C702 = C603H36: tolerance: 78.22523.5BL
C10 C42 C71 = C603: tolerance: 78.22224.2BL
C11 C13 C16 C18 C37 C52 C56 C155 C156 C190 C197 C213 PC24 PC42 PC52 PC61 PC63 PC64 PC68 PC71 = C1206H71: tolerance: 78.10622.22LDL
C12 C46 C84 C141 C159 C185 C212 C292 C293 C306 C307 C340 C341 C466 C548 PC70 = C603H36: tolerance: 78.10424.2BL
C14 C15 C131 C164 C165 C169 C223 C398 C399 C560 C562 C570 C609 C666 C729 = C603H38: tolerance: 78.10610.5BL
C22 C32 C43 C117 C126 C180 C182 C184 C193 C201 C202 C298 C333 C358 C360 C361 C363 C397 C488 C515 C525 C660 C663 C665 C707 C715 C838 C840 = C805H54: tolerance: 78.10623.51L
C23 C24 C29 C30 C33-C36 C132 C142 C145 C163 C186 C192 C199 C211 C214 C216 C412 C422 C423 C486 C489 C500 C514 C516 C529 C540 C554 C557-C559 C583 C588 C602 C608 C612 C616 C623 C627 C753 C774 C781 C789-C792 C820 C821 C826 C829 PC23 PC25 PC28 PC34 PC36 = C402H22: tolerance: 78.10423.2FL
C25 C60 C114 C167 C170 C204 C206 C210 C245 C262 C278 C355 C356 C386 C533 C545 C551 C552 C578 C722 C723 C727 C728 = C402H22: tolerance: 78.10134.1FL
C27 C53-C55 C57-C59 C61-C66 C68-C70 C72-C74 C76-C78 C81-C83 C89-C91 C424-C427 C772 = C805H58: tolerance: 78.22610.51L
C41 C128 C601 PC55 PC65 PC66 = C603: tolerance: 78.15224.2BL
C44 C75 C130 C157 C264 C265 C395 C403 C416 C477 C482 C484 PC17 PC18 PC26 PC38 PC45 PC54 PC58 = C603H36: tolerance: 78.10521.2BL
C45 C51 C270 C478 C483 C667 C673 C836 PC22 PC39-PC41 = C1206H71: tolerance: 78.10621.22L
C50 C240 C258 C268 C269 = C603H36: tolerance: 78.10521.5BL
C67 C85 C86 C113 C122 C263 C281 C283 C400 C410 C684 C689 C733 PC12 PC20 PC44 PC49 PC62 = C603H36: tolerance: 78.10422.2BL
C92 C95 C97 C102 C106 C108 C109 C175 C176 C271 C280 C305 C309 C411 C429 C433 C439-C441 C443 C449 C454 C455 C459 C460 C463-C465 C473 C475 C771 C780 C784 C787 C788 C797 C804 C810-C812 C822 C828 C830 = C603H36: tolerance: 78.47520.5BL
C121 C246 C266 C421 C479 C680 C682 C690 = C805H56: tolerance: 78.10622.51L
C129 C177 C451 C735 = C603H36: tolerance: 78.10522.5BL
C133-C140 C146-C153 C736-C751 = C402H22: tolerance: 78.22423.5FL
C158 C207 C218 C220 C222 C224 C229 C242 C251 C252 C254 C256 C675 C681 C755 = C402H22: tolerance: 78.10321.2FL
C161 = C402H22: tolerance: 78.22124.2FLDL
C162 C380 PC2-PC4 PC33 PC46 PC51 = C402H22: tolerance: 78.22034.1FL
C166 C239 = C402H22: tolerance: 78.10422.5FL
C174 C352 C353 C371 C752 = C402H22: tolerance: 78.47034.1FL
C191 = C603H36: tolerance: 78.15034.1BL
C196 = C603H36: tolerance: 78.10523.2BL
C200 C326 C329 C330 C332 C565 = C603H36: tolerance: 78.68421.5BL
C205 = C603H36: tolerance: 78.12034.1BL
C227 C593 = C402H22: tolerance: 78.82321.2FL
C228 = C603H36: tolerance: 78.10523.5BL
C236 C304 C321 C375 C389 C480 PC7 PC31 PC57 = C402H22: tolerance: 78.10224.2FL
C238 C294 C296 C301 C302 = C603H36: tolerance: 78.22421.2BL
C249 PC5 PC10 PC16 PC19 PC60 = C603H40: tolerance: 78.22422.2BL
C253 C255 C382 C383 = C402H22: tolerance: 78.22224.2FL
C259 C260 C288 = C402H24: tolerance: 78.12034.1FL
C261 PC6 PC37 = C402H22: tolerance: 78.15134.1FL
C267 C279 PR72 PR73 PR92 PR93 PR108 PR109 R114 R122 R127 R129 R249 R406 R499 R506 R511 R522 R526 R602 R703 R705 R798 R824 R832 R834 R836 R842 R1035 R1123-R1126 R1150 R1151 = R603H22: tolerance: 63.00000.00L
C274 C275 C277 C287 = C603H36: tolerance: 78.27324.2BLDL
C282 C319 C338 = C603H36: tolerance: 78.47134.1BL
C299 = C402H22: tolerance: 78.12034.1FLDL
C308 = C402-TO0D2H26: tolerance: 78.47510.5FL
C313-C316 = C603: tolerance: 78.10334.2BL
C318 C320 C323 C324 C334-C337 C339 C714 C721 = C402H20: tolerance: 78.10423.5FL
C322 C342 C378 C390 = C402H22: tolerance: 78.47124.2FL
C325 C327 C328 C331 = C603H36: tolerance: 78.10234.1BL
C343-C348 = C402H22: tolerance: 78.3R374.1FL
C349-C351 C708 C711 = C402H22: tolerance: 78.10034.1FL
C370 C462 PC9 PC14 PC43 PC53 PC73 = C402H22: tolerance: 78.10324.2FL
C372 = C805H58: tolerance: 78.22521.21L
C377 = C402H24: tolerance: 78.47222.2FL
C385 PC21 = C402H22: tolerance: 78.10322.2FL
C402 = C805H56: tolerance: 78.47523.51L
C413 C417 C420 = C402H22: tolerance: 78.22321.2FL
C461 = C402H22: tolerance: 78.5R074.1FL
C679 = C805H38: tolerance: 78.33523.51L
C734 = C603H36: tolerance: 78.47422.5BL
C756 C757 C865-C868 = C402H22: tolerance: 78.10034.1FLDL
C762 = C402H22: tolerance: 78.12134.1FL
C837 = C1210H111: tolerance: 78.22611.23L
C839 = C402H22: tolerance: 78.68034.1FL
CONVT1 = A2006WV0-2X6P-6T2-2D3: tolerance: 21.61175.206
CPU1 = SKTBGA1150R740611UH367NF: tolerance: 62.10055.741
D1 = SOD323AKH38: tolerance: 83.R5003.H8H
D2 = SOT-23-9H44: tolerance: 75.00040.07D
D3 = DO214AAAK-1121H97: tolerance: 83.P6SMB.KAG
D5 D10 D11 D20 D21 = SOT23-2D4-312H48: tolerance: 75.00099.F7D
D6 D14 D15 U28 U30 = SOT-6H44: tolerance: 75.04223.07C
D7 = SOT-23-9H44: tolerance: 75.00054.07D
D8 D12 D13 = SOD523AKH31: tolerance: 83.05013.0AF
D9 D16 D19 D22 D23 = SOD323AKH38: tolerance: 83.00355.D1F
D17 = SOD523AKH28: tolerance: 83.02015.0AF
D18 = SOD80CH36: tolerance: 83.R5003.C8F
DIMM1 = 1932210-2: tolerance: 62.10017.T61
DIMM2 = 1932208-2: tolerance: 62.10017.T51
F1 F12 = FUSE-7452-UH50: tolerance: 69.50007.821
F2-F4 F6 F7 F13 F14 = POLYSW-3217-UH40: tolerance: 69.50007.B91
F5 F8 F11 = POLYSW-4633-UH24: tolerance: 69.50007.B81
F9 = FUSE-1005H17: tolerance: 69.42001.431
F10 = FUSE-3216H26: tolerance: 69.43001.391
FANC1 = HF08040-M1: tolerance: 21.60641.104
FANC2 = CI0104P1VKK-NH: tolerance: 21.61996.104
G1-G6 = CON2C-U: tolerance: ZZ.CON2C.XXX
H1 H3-H5 = HOLE236R157: tolerance: ZZ.0HOLE.XXX
H2 H8 H12 = GEN315R138-8-F-A: tolerance: ZZ.AFEN8.138
H7 H11 = GEN315R177-8-F-A: tolerance: ZZ.AFEN8.177
HDD1 ODD1 = 67800-8035: tolerance: 20.81054.007
HDMI1 = SKT-HDMI22-152071: tolerance: 62.10078.631
HS1 = STF256R109H276: tolerance: 34.3NH03.001
HS2 = STF256R109H398: tolerance: 34.3NH02.001
HS3 = STF256R109H99: tolerance: 34.3NH01.001
INTRU1 = HF1103E-P1: tolerance: 21.61830.103
L1 L5 L6 PL1 = RT-D6-4D5-1010H375: tolerance: 19.40335.121
L2 L4 L27 L31 = L603H38: tolerance: 68.00230.231
L3 = L112100-2135H158: tolerance: 68.R561A.10A
L7 L8 L29 = L402H22: tolerance: 68.00084.541
L9 L10 L12 L13 = L125100-4P-1H36: tolerance: 68.12105.201
L11 = L686647H119: tolerance: 68.1R51A.10F
L14 = L109100-2230H158: tolerance: 68.6R81B.10P
L15 = L3330-1230H95: tolerance: 68.4R710.20S
L16 L52 L53 = L603H38: tolerance: 68.00335.141
L17-L19 = L402H24: tolerance: 68.00217.B31
L20-L22 = L402H24: tolerance: 68.00217.B81
L23-L26 L33 L40 L47-L51 L54 = L402H24: tolerance: 68.00213.031
L28 = L3030-3009H40: tolerance: 68.4R710.20T
L41-L44 = L20125H42: tolerance: 68.00216.111
L45 = L603H38: tolerance: 68.00335.181
L46 PR48-PR50 PR65-PR67 PR76 R190-R192 R195-R199 R284 R358 R462 R512 R710-R712 R783-R790 R854 R1000 R1002 R1013 R1088 R1093 R1100 R1108 R1113 R1118 R1119 R1223 R1224 = 0R0805-PAD: tolerance: ZZ.R0805.ZZZ
L56 = L402H24: tolerance: 68.00217.B21
LED1 LED2 = LED1608AKH30: tolerance: 83.01608.Q70
LOUT1 = JAC331-0140A8B-9H: tolerance: 22.10277.2M1
LPC1 = HL5507F: tolerance: 21.60964.207
LVDS1 = 50524-0300N-001: tolerance: 020.K0005.0030
M1 = SOIC8-G3530H63: tolerance: 74.05930.03D
MEM1-MEM4 = BGA96D075130H48: tolerance: 72.51G63.R0U
MEMCD1 = PSDAT0-09GLBS1ZZ4H1: tolerance: 62.10051.661
NGFF1 = 2199230-7: tolerance: 62.10043.K51
PC8 = C402H22: tolerance: 78.33034.1FL
PC11 = C402H22: tolerance: 78.39124.2FL
PC13 PC56 = C402H22: tolerance: 78.33124.2FL
PC15 = C402H22: tolerance: 78.33322.2FL
PC27 PC32 = C402H22: tolerance: 78.47321.2FL
PC29 PC47 PC48 = C805H56: tolerance: 78.47521.21L
PC30 = C402H22: tolerance: 78.47224.2FL
PC50 PC67 = C603H36: tolerance: 78.10520.2BL
PC59 = C603H36: tolerance: 78.10421.2BL
PC69 = C603H36: tolerance: 78.10522.2BL
PG1 PG2 PG5 PG6 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG3 PG4 = CON2C: tolerance: ZZ.CON2C.XX1
PL2 PL3 = L115100-2230H158: tolerance: 68.3R31B.10H
PL4-PL7 = L805H44: tolerance: 68.00335.071
PR1 PR75 PR78 R3 R5 R7-R9 R11 R12 R14-R16 R51 R65 R66 R157 R159 R168 R221 R259 R269 R297 R354 R465 R472 R518 R519 R551 R559 R562 R564 R578 R590 R714 R717 R772 R773 R823 R826 R897 R953 R1033 R1036 R1055 R1067 R1154 R1155 R1208 R1209 R1221 R1222 R1225 R1226 R1229 = R402H16: tolerance: 63.R0034.1DL
PR2 PR10 PR14 PR17 PR18 PR23 PR25 PR28-PR30 PR32 PR35 PR37 PR39 PR44 PR79 PR101 R207 R300 R375 R453 R523 R1005 R1063 R1160 = 0R0402-PAD: tolerance: ZZ.R0402.ZZZ
PR3 PR4 PR7 PR15 PR24 PR26 PR31 PR33 PR36 PR38 PR40 PR94 PR96 PR97 PR100 PR102-PR104 R31 R90 R95 R104 R164 R180 R184 R185 R188 R205 R206 R226 R231-R236 R242 R251 R252 R268 R274 R307 R318 R321 R322 R334 R335 R342 R343 R356 R381 R383 R407 R415 R419 R424 R425 R440 R441 R448 R468 R484 R494 R536 R544 R557 R558 R560 R633 R638 R646 R647 R677 R696 R718-R723 R731-R736 R739 R751-R756 R775-R777 R859 R867 R871 R872 R877 R878 R892 R893 R903 R913 R916 R920 R925 R926 R936 R1061 R1121 R1122 = R402H16: tolerance: 63.10234.1DL
PR5 = R402H16: tolerance: 64.40215.6DL
PR6 = R402H16: tolerance: 64.19115.6DL
PR8 PR9 R228 R245 R329 R345 R422 R530 R576 R584 R707 R914 R1026 R1046 R1133 R1144 = R402H16: tolerance: 64.47025.6DL
PR11 PR12 PR63 R17 R19 R20 R22-R27 R48 R50 R53 R67 R72 R74 R103 R141 R153 R154 R158 R170 R177-R179 R181-R183 R222 R227 R253 R263 R275 R287 R360 R387 R421 R429 R438 R449 R451 R456 R475 R481 R486 R488 R496 R541 R563 R572 R630 R634 R636 R637 R650 R651 R659 R664 R669 R672 R673 R676 R680 R685 R697 R698 R715 R730 R740-R745 R764 R770 R771 R797 R799 R807-R809 R833 R838 R845 R862 R879 R887 R912 R1019 R1024 R1032 R1044 R1048 R1147 R1165 R1166 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR13 = R402H16: tolerance: 64.80615.6DL
PR16 = R402H16: tolerance: 64.91005.6DL
PR19 PR46 PR64 PR84 PR85 PR88 R35 R37 R38 R42 R47 R98 R101 R107 R211 R213 R331 R437 R464 R479 R517 R632 R658 R663 R667 R689 R794 R1010 R1029 R1141 R1142 = R402H16: tolerance: 64.10025.6DL
PR20 = R402H16: tolerance: 64.56205.6DL
PR21 R394 R548 R940 R948 R1008 R1049 = R402H16: tolerance: 64.20015.6DL
PR22 PR27 R145 R147 R403 R533 R641 R652 R653 R768 R810 R889-R891 R1114 R1117 R1197 R1198 = R402H14: tolerance: 64.10005.6DL
PR34 = R402H16: tolerance: 64.82R55.6DL
PR41 = R402H16: tolerance: 64.11025.6DL
PR42 = R402H16: tolerance: 64.26115.6DL
PR43 = R402H16: tolerance: 64.2R205.6DL
PR45 = R603H22: tolerance: 64.36515.55L
PR47 PR95 R996 = R402H16: tolerance: 64.1R005.6DL
PR51 = NTC-402H24: tolerance: 69.60013.131
PR52 PR53 PR55-PR59 PR106 PR107 PR110-PR113 = 0R0805-PAD-1: tolerance: ZZ.00PAD.M31
PR54 = R805H24: tolerance: 63.10133.16L
PR60 = NTC-402H24: tolerance: 69.60013.141
PR61 PR71 R2 R6 R18 R29 R30 R32 R33 R40 R44 R45 R58 R64 R75 R78 R82-R84 R92 R93 R97 R105 R106 R150 R160 R161 R165 R166 R171 R172 R176 R186 R189 R204 R217 R218 R220 R223-R225 R237 R238 R243 R247 R255-R258 R260 R262 R264 R266 R270-R272 R276-R280 R282 R283 R313 R337 R340 R346 R348-R350 R355 R357 R361 R367 R373 R374 R378 R384 R385 R426 R427 R432 R445 R450 R455 R458 R460 R461 R463 R469 R471 R485 R504 R509 R527 R529 R535 R537 R543 R545 R547 R556 R561 R577 R579 R592 R593 R738 R812 R818 R848-R852 R856 R863 R868 R873 R880 R888 R895 R898 R905 R908 R911 R918 R919 R922 R927 R937-R939 R947 R962 R973 R977 R978 R980 R981 R986 R1003 R1004 R1011 R1014 R1018 R1045 R1051 R1056 R1069-R1073 R1080 R1104 R1135 R1153 R1156 R1167 R1184-R1186 R1190 R1191 R1193 R1227 R1228 = R402H16: tolerance: 63.10334.1DL
PR62 R261 R351 R681 R682 R684 R984 R1202 = R402H14: tolerance: 64.10R05.6DL
PR68 = R402H16: tolerance: 64.24025.6DL
PR69 = R402H16: tolerance: 64.45315.6DL
PR70 PR117 R380 R674 R678 R679 R1146 R1149 = R402H16: tolerance: 64.10035.6DL
PR74 R69 = R402H16: tolerance: 64.12025.6DL
PR77 = R402H16: tolerance: 64.15425.6DL
PR80 PR90 PR91 PR115 = R805H24: tolerance: 64.2R205.16L
PR81 R1 R4 R36 R57 R70 R155 R167 R175 R413 R423 R428 R433 R516 R520 R528 R531 R542 R552 R553 R597 R601 R654 R660 R700 R702 R708 R713 R748 R760 R762 R817 R819-R821 R825 R1081 R1138 = R402H16: tolerance: 63.10434.1DL
PR82 = R402H16: tolerance: 64.66515.6DL
PR83 = R402H16: tolerance: 64.21525.6DL
PR86 R666 R1038 = R402H16: tolerance: 64.68025.6DL
PR87 = R402H16: tolerance: 64.15035.6DL
PR89 R156 R497 R554 R591 R855 R1020 = R402H16: tolerance: 64.15025.6DL
PR98 R368 R902 R961 R992 R1220 R1230 R1231 = 0R0603-PAD-1-U: tolerance: ZZ.00PAD.M21
PR99 = R402H16: tolerance: 64.93115.6DL
PR105 R28 R79 R111 = R805H24: tolerance: 63.1R031.16L
PR114 R56 R76 R96 R108 R113 R187 R200 R208 R210 R359 R631 R694 R704 R729 R779 R791 R952 R979 = R805H24: tolerance: 63.2R231.16L
PR116 PR118 R34 R88 R813 R999 = 0R0805-PAD-1-U: tolerance: ZZ.00PAD.M31
PT1 PT3 PT4 TC5 TC7 TC14 TC16 TC20 = ECAP-100D6D3H355: tolerance: 09.8271N.A5L
PT2 TC2 TC3 TC9 TC21 = SE361416H237: tolerance: 79.47612.A0L
PTC1 PTC2 = SE331721H237: tolerance: 79.22710.E0L
PU1 PU2 Q8 Q10 Q12 Q21 Q23-Q25 = PPAK-5PH45: tolerance: 84.00172.A37
PU3 PU4 Q5 Q6 Q13 Q16-Q18 Q27 Q28 = PPAK-5PH45: tolerance: 84.SRA12.037
PU5 = SOIC8-G3530H63: tolerance: 74.05930.B3D
PU6 = QFN20-G1D75H32: tolerance: 74.08243.073
PWRCN1 = A2006WV0-2X5P-6T2-2D3: tolerance: 21.61175.205
Q1 Q2 Q88 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
Q3 Q37 Q46 Q49 Q55 Q56 Q60 Q61 Q63 Q69 Q71-Q73 Q76 Q79 Q83 Q84 Q90-Q96 Q98-Q100 Q103 Q107 Q113 Q118-Q122 Q129 = SOT23DGS2D4H48: tolerance: 84.2N702.E31
Q4 Q80 = SOT23DGS2D8H50: tolerance: 84.03413.B31
Q7 Q14 Q15 Q19 Q20 Q22 Q26 Q35 Q36 Q38 Q48 Q53 Q59 Q67 Q68 Q70 Q89 Q102 Q105 Q108 Q114 Q126-Q128 = SOT23CBE2D4H44: tolerance: 84.T3904.C11
Q9 Q11 Q44 Q45 Q74 Q86 Q87 Q101 Q104 Q106 Q109-Q111 QF1 = SOT-363H44: tolerance: 75.03904.07C
Q39 Q64 Q81 = SOIC8H69: tolerance: 84.04712.A37
Q40 = SMD-TO-252-DGS6698H99: tolerance: 84.03004.036
Q41 Q65 Q77 = SOIC8H69: tolerance: 84.04128.037
Q42 Q85 Q97 = SOT23-2D4-312H46: tolerance: 75.05125.07D
Q51 = SOT23DGS2D4H48: tolerance: 84.02130.031
Q52 = SOT23CBE2D4H44: tolerance: 84.T3906.A11
Q54 Q123 U4 U32 U34 = SOT-363H44: tolerance: 75.27002.F7C
Q57 Q75 Q78 Q82 = SOIC8H69: tolerance: 84.04468.A37
Q58 Q112 Q125 = SOT23DGS2D8H50: tolerance: 84.03401.D31
Q62 Q66 = SOT-363H44: tolerance: 84.M3904.B1F
Q115 = SOT-23-10H44: tolerance: 84.03906.F11
R10 R498 R1090 R1096 = R402H16: tolerance: 63.82234.1DL
R13 R1107 = R402H16: tolerance: 64.39225.6DL
R21 R109 R110 R193 R194 R201 R295 R311 R325 R344 R431 R814-R816 R843 R844 R1065 R1077 R1212-R1219 = R805H24: tolerance: 63.R0031.16L
R39 = NTC-603H28: tolerance: 69.60026.091
R41 R434 R439 R446 R447 R835 R837 R839-R841 R989 R994 = R402H16: tolerance: 63.22034.1DL
R43 R46 R138 R139 R304 R665 R695 R800-R803 R846 R847 R857 R858 R1120 R1158 R1162 = R402H16: tolerance: 64.10015.6DL
R49 R54 R60 R68 R81 R91 R94 R169 R173 R174 R296 R314 R430 R474 R476 R480 R482 R483 R491-R493 R495 R501 R505 R508 R513 R521 R569 R573 R575 R724-R727 R806 R1001 R1028 R1040 R1052 R1066 R1068 R1078 R1079 R1187 RR1 = R402H16: tolerance: 63.47234.1DL
R52 = NTC-402H24: tolerance: 69.60028.031
R55 R1136 = R402H16: tolerance: 63.15434.1DL
R59 = R402H16: tolerance: 64.13015.6DL
R61 R473 = R402H16: tolerance: 63.43034.1DL
R62 R146 R420 R749 = R402H16: tolerance: 64.75R05.6DL
R63 = R402H16: tolerance: 64.66505.6DL
R71 R728 R828 R829 = R402H16: tolerance: 64.49R95.6DL
R73 R442-R444 R605 R606 R609 = R402H16: tolerance: 64.15005.6DL
R99 = R402H16: tolerance: 64.45325.6DL
R100 = R402H16: tolerance: 64.11525.6DL
R102 R214 = R402H16: tolerance: 64.47035.6DL
R112 R254 R643-R645 R699 R701 R750 R774 = R402H16: tolerance: 63.51034.1DL
R119 = R603H22: tolerance: 63.10333.15L
R128 R151 R244 R347 R353 R366 R372 R377 R379 R389 R392 R395 R435 R436 R454 R457 R459 R549 R571 R1009 R1012 R1034 R1062 R1083 R1168-R1171 R1183 = R402H16: tolerance: 63.33034.1DL
R152 R915 = R402H16: tolerance: 63.15234.1DL
R162 = R402H16: tolerance: 64.60415.6DL
R163 = R402H16: tolerance: 64.26715.6DL
R202 R203 R229 R230 R308 R309 R885 R886 R924 R928 R945 R946 R951 R957 R959 R960 = R402H16: tolerance: 64.21015.6DL
R209 R215 R341 R352 R1199 R1200 = R402H16: tolerance: 64.40R25.6DL
R212 R302 = R402H16: tolerance: 64.51115.6DL
R216 R466 R478 R487 R489 R614 R805 = R402H16: tolerance: 63.20334.1DL
R239-R241 R267 R906 R917 = R402H16: tolerance: 63.15034.1DL
R246 = R402H16: tolerance: 64.68R05.6DL
R265 R323 R324 R336 R391 R500 R534 R583 R599 R623 R626 R811 R869 R909 R910 R921 R923 R933 R985 R991 R993 R995 R997 R998 R1015 R1115 R1116 R1204 = R402H16: tolerance: 63.22234.1DL
R273 R600 = R402H16: tolerance: 63.10534.1DL
R281 R298 = R402H16: tolerance: 63.39434.1DL
R289 = R603H22: tolerance: 64.5R115.55L
R294 = R402H16: tolerance: 64.47515.6DL
R299 R320 R870 R899 = R402H16: tolerance: 64.24305.6DL
R303 R388 R943 = R402H16: tolerance: 64.84515.6DL
R305 R306 R333 R514 R1157 = R402H16: tolerance: 64.20025.6DL
R312 = R603H22: tolerance: 64.10055.55L
R316 R382 R411 R982 R988 = R402H16: tolerance: 64.75015.6DLDL
R332 = R402H16: tolerance: 64.51015.6DL
R362 R1058 R1075 = R402H16: tolerance: 64.71515.6DL
R371 R860 = R603H22: tolerance: 63.2R233.15L
R386 R467 R546 R1188 = R603H22: tolerance: 64.10045.55L
R396-R399 R963 R1159 = R402H15: tolerance: 63.10334.L0L
R400 R412 = R402H16: tolerance: 64.15805.6DL
R408 = R402H16: tolerance: 64.22R65.6DL
R410 R418 = R603H22: tolerance: 64.22115.55L
R417 = R402H16: tolerance: 64.33015.6DL
R452 = R402H16: tolerance: 64.33035.6DL
R470 R1053 R1139 = R402H16: tolerance: 63.22334.1DL
R477 = R402H16: tolerance: 64.88715.6DL
R490 R804 R987 R1030 R1057 R1059 R1082 = R402H16: tolerance: 64.82015.6DL
R503 = R805H24: tolerance: 64.10025.16L
R507 R540 = R402H16: tolerance: 63.30234.1DL
R515 = R402H16: tolerance: 64.56015.6DL
R524 R595 R596 R706 = R603H22: tolerance: 63.33133.15L
R538 = R603H22: tolerance: 63.10033.15L
R539 = R402H16: tolerance: 64.14735.6DL
R550 R1047 = R402H16: tolerance: 64.20035.6DL
R555 = R402H16: tolerance: 64.24915.6DL
R565-R567 R574 R1037 R1060 R1076 = R402H16: tolerance: 64.30025.6DL
R568 = R402H16: tolerance: 64.16005.6DL
R586-R589 = R603H22: tolerance: 64.3R305.55L
R624 R625 R1203 = R402H16: tolerance: 63.47034.1DL
R629 R769 = R402H16: tolerance: 64.11005.6DL
R635 = R402H16: tolerance: 64.56225.6DL
R639 = R402H16: tolerance: 64.51R05.6DL
R640 = R402H16: tolerance: 64.82505.6DL
R642 R1210 = R402H16: tolerance: 64.24905.6DL
R648 = R402H16: tolerance: 64.54R95.6DL
R649 R767 = R402H16: tolerance: 64.90R95.6DL
R655 = R402H16: tolerance: 64.20525.6DL
R656 = R402H16: tolerance: 64.12015.6DL
R657 = R402H16: tolerance: 64.69825.6DL
R661 = R402H16: tolerance: 64.47R55.6DL
R662 = R402H16: tolerance: 64.59025.6DL
R668 = R402H16: tolerance: 64.56035.6DL
R670 R1205 = R402H16: tolerance: 64.49915.6DL
R671 R690 R691 R1025 = R402H16: tolerance: 64.68015.6DL
R675 = R402H16: tolerance: 64.18025.6DL
R683 = R402H16: tolerance: 64.75025.6DL
R686 = R402H16: tolerance: 64.17435.6DL
R687 R692 R693 = R603H22: tolerance: 64.11835.55L
R688 = R402H16: tolerance: 64.31625.6DL
R709 R853 = R1206H28: tolerance: 63.R0032.11L
R746 = R402H16: tolerance: 64.44R25.6DL
R757 = R402H16: tolerance: 64.18015.6DL
R758 R795 R796 R830 R831 = R402H16: tolerance: 64.24R95.6DL
R759 R763 = R402H16: tolerance: 63.10534.L0L
R765 = R402H16: tolerance: 63.33234.1DL
R792 R793 = R402H16: tolerance: 64.2R005.6DL
R822 = R603H22: tolerance: 64.56025.55L
R827 = R402H16: tolerance: 64.19105.6DL
R861 = R402H16: tolerance: 64.10535.60L
R864-R866 = R402H16: tolerance: 64.20005.6DL
R896 = R402H16: tolerance: 63.33334.1DL
R935 = R402H16: tolerance: 64.44215.6DL
R970 = 0R0603-PAD-1: tolerance: ZZ.00PAD.M21
R990 = R402H16: tolerance: 64.64905.6DL
R1017 R1039 = R402H16: tolerance: 64.22025.6DL
R1022 = R402H16: tolerance: 64.16025.6DL
R1023 = R402H16: tolerance: 64.22005.6DL
R1027 R1031 R1043 R1050 = R603H22: tolerance: 64.12105.55L
R1041 = R402H16: tolerance: 64.16525.6DL
R1042 = R402H16: tolerance: 64.33025.6DL
R1054 = 0R0603-PAD: tolerance: ZZ.R0603.ZZZ
R1064 = R402H16: tolerance: 64.68005.6DL
R1074 R1087 = R603H22: tolerance: 63.15234.15L
R1091 R1092 R1094 R1097 R1101 R1103 R1105 R1109 = R402H16: tolerance: 63.47134.1DL
R1137 = R402H16: tolerance: 63.47334.1DL
R1143 = R402H16: tolerance: 64.49925.6DL
R1152 = R2512H32: tolerance: 64.R0105.97L
R1161 = R402H16: tolerance: 64.16915.6DL
R1201 = R402H16: tolerance: 64.12005.6DL
R1206 R1207 = R402H16: tolerance: 64.51R15.6DL
R1211 = R402H16: tolerance: 64.49905.6DL
R1233 R1234 = R603H22: tolerance: 64.10525.55L
RJ1 = PT2-P0P-26B9: tolerance: 22.10277.A41
RN2 = ARES8-CN24H20: tolerance: 66.82236.A8L
RN5-RN7 = ARES8-CN24-MUH20: tolerance: 66.10336.08L
RN9 = ARES2H16: tolerance: 66.22236.04L
SATAP1 = 1580C010: tolerance: 21.60859.105
SPK1 = A1501WV0-6PS-5E: tolerance: 21.D0278.106
SPR1 = SPR4330-UH71: tolerance: 34.49U01.001
SRCON1 = G6179-1000000-U: tolerance: 62.10076.011
SSUSB1 SSUSB2 = SKT-USB11-145165: tolerance: 22.10341.A21
TC1 TC12 TC23 = CT7343H75: tolerance: 77.23371.13L
TC4 TC6 TC8 TC10 TC11 = ECAP-100D6D3H375: tolerance: 09.56710.A8L
TC13 TC15 = CT3528H79: tolerance: 77.21071.07L
TC17 = ECAP-100D6D3H237: tolerance: 09.1071D.2AL
TC18 = ECAP-100D6D3H473: tolerance: 09.2271D.X8L
TC19 TC22 = ECAP-100D6D3H237: tolerance: 09.1071D.D5L
TOUCH1 = A1501WV0-5P-6T-2D4: tolerance: 21.61791.105
TOUCH2 = A2001WV2-2P-U: tolerance: 21.61210.102
TP1 TP3-TP9 TP11 TP12 TP17-TP19 TP25-TP112 TP115 TP117-TP120 TP122-TP124 TP126-TP128 TP131 TP132 TP134-TP150 TP155 TP158 TP159 TP163-TP167 = TPAD28: tolerance: ZZ.PAD28.XXX
TR1-TR3 TR8-TR13 = L125100-4P-1H37: tolerance: 68.01012.201
TR4-TR7 = L125100-4P-1H28: tolerance: 68.10129.201
U1 U2 = SOIC8H69: tolerance: 72.24C64.R01
U3 U15 = DFN10G3-G265175H32: tolerance: 74.08237.B73
U5 U17 U38 = DFN8G2-G1309-UH40: tolerance: 74.81161.073
U6 U40 U48 = SOIC8H69: tolerance: 84.04407.G37
U9 = QFN40-G3D5H32: tolerance: 74.62882.A73
U10 U11 U27 U31 U33 = DFN10G2510H26: tolerance: 75.01045.073
U12 = SOIC8-1H86: tolerance: 72.25647.00A
U13 = BGA631M23H82: tolerance: 71.SUNM2.M02
U14 = SOT-6H58: tolerance: 74.05611.03P
U16 = QFN48J6-G465H40: tolerance: 71.03661.003
U18 = SOIC8H69: tolerance: 75.04214.A71
U20 = QFN10-G255185-UH40: tolerance: 74.01589.073
U21 = TSOIC8H44: tolerance: 71.02304.A0W
U22 = TSOIC28H48: tolerance: 71.03324.H0W
U23 = TSOIC28-3H44: tolerance: 71.08172.00W
U24 = PFPCC128-5H48: tolerance: 71.05553.00E
U25 = QFN32-G3D55H40: tolerance: 74.03131.013
U26 = QFN32J4-G2D9-U1H36: tolerance: 71.08111.U03
U29 = BGA708Z2322H65: tolerance: 71.0LYNX.B0U
U35 = QFN32J4-G2D8-3H40: tolerance: 74.81102.B73
U36 = SOT-6-1H50: tolerance: 84.06402.B3D
U37 = QFN48J6-G4D55H40: tolerance: 71.02136.003
U39 = QFN32J4-G2D8-4H32: tolerance: 71.00621.003
U41 = SOIC8-G3530H63: tolerance: 74.05337.031
U43 U44 = SOT-6H58: tolerance: 75.09904.07C
U46 = SC70-5H44: tolerance: 074.07275.003F
U47 = SC70-6H44: tolerance: 74.00199.07P
U49 = SOIC8H69: tolerance: 72.25010.R01
UHS1 = 2SJ3082-003111F: tolerance: 022.10002.0121
USB3-USB6 = SKT-USB6-146072: tolerance: 22.10218.0A1
VGA1 = 28-00120-1A61-A: tolerance: 020.20003.0015
WEBCM1 = A1251WR0-8PS-5E: tolerance: 20.F1245.008
X1 = MC-146H56: tolerance: 82.30001.841
X3 X4 = OSC-3225-4P-4H36: tolerance: 82.30020.G71
X5 = SMD-OSC6H30: tolerance: 82.30034.641
XDPC1 = DM-BSH-03001-FDA-01: tolerance: ZZ.F0441.06001

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
0R0402-PAD
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0402-PAD-1
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
0R0603-PAD
  custom 0.216x0.216 smd: 1(0,0.851) 2(0,-0.673)
0R0603-PAD-1
  custom 0.216x0.216 smd: 1(0,0.851) 2(0,-0.673)
0R0603-PAD-1-U
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
0R0805-PAD
  rect 1.397x1.562 smd: 1(0,0.965)
  rect 1.397x1.569 smd: 2(0,-0.965)
0R0805-PAD-1
  rect 1.397x1.562 smd: 1(0,0.965)
  rect 1.397x1.569 smd: 2(0,-0.965)
0R0805-PAD-1-U
  rect 1.397x1.562 smd: 1(0,0.965)
  rect 1.397x1.569 smd: 2(0,-0.965)
2SJ3082-003111F
  round 0.254 hole 1.27 unplated: (0,0) (0,-6)
  oval 1.321x2.134 hole 0.61x1.422: 1(-3.8,-9.1) 2(3.7,-1.5) 3(-3.7,0.8) 4(2.7,0.6) 5(2.2,-9.1) 6(3.8,-9.1) 7(-4.6,-3.5) 8(4.6,-4.5)
28-00120-1A61-A
  round 1.422 hole 1.016: 1(4.31,1.98) 2(2.02,1.98) 3(-0.27,1.98) 4(-2.56,1.98) 5(-4.85,1.98) 6(5.455,0) 7(3.165,0) 8(0.875,0) 9(-1.415,0) 10(-3.705,0) 11(4.31,-1.98) 12(2.02,-1.98) 13(-0.27,-1.98) 14(-2.56,-1.98) 15(-4.85,-1.98)
  round 3.607 hole 3.2: 16(-12.495,0) 17(12.495,0)
733-71-08TB12
  round 0.254 hole 1.041 unplated: (-7.5,2.44) (7.5,2.44)
  round 1.676 hole 1.041: 1(4.5,-1.5) 2(1.5,-1.5) 3(-1.5,-1.5) 4(-4.5,-1.5) 5(4.5,1.5) 6(1.5,1.5) 7(-1.5,1.5) 8(-4.5,1.5)
1580C010
  round 1.6 hole 1.194: 1(5,0) 2(2.5,0) 3(0,0) 4(-2.5,0) 5(-5,0)
50524-0300N-001
  rect 0.305x1.295 smd: 1(-14.5,5.65) 2(-13.5,5.65) 3(-12.5,5.65) 4(-11.5,5.65) 5(-10.5,5.65) 6(-9.5,5.65) 7(-8.5,5.65) 8(-7.5,5.65) 9(-6.5,5.65) 10(-5.5,5.65) 11(-4.5,5.65) 12(-3.5,5.65) 13(-2.5,5.65) 14(-1.5,5.65) 15(-0.5,5.65) 16(0.5,5.65) 17(1.5,5.65) 18(2.5,5.65) 19(3.5,5.65) 20(4.5,5.65) 21(5.5,5.65) 22(6.5,5.65) 23(7.5,5.65) 24(8.5,5.65) 25(9.5,5.65) 26(10.5,5.65) 27(11.5,5.65) 28(12.5,5.65) 29(13.5,5.65) 30(14.5,5.65)
  rect 1.803x2.21 smd: 31(-17.15,0) 32(17.15,0)
67800-8035
  round 1.118 hole 0.762: 1(3.81,-0.5) 4(0,-0.5) 7(-3.81,-0.5)
  round 1.067 hole 0.762: 2(2.54,0.5) 3(1.27,0.5) 5(-1.27,0.5) 6(-2.54,0.5)
  round 1.778 hole 1.372: 8(6.48,0) 9(-6.48,0)
1932208-2
  round 0.254 hole 1.118 unplated: (-33.4,0)
  round 0.254 hole 1.651 unplated: (33.4,0)
  custom 0.114x0.114 smd: 1(31.65,4.1) 2(31.35,-4.1) 3(31.05,4.1) 4(30.751,-4.1) 5(30.45,4.1) 6(30.15,-4.1) 7(29.85,4.1) 8(29.55,-4.1) 9(29.251,4.1) 10(28.95,-4.1) 11(28.65,4.1) 12(28.35,-4.1) 13(28.051,4.1) 14(27.751,-4.1) 15(27.45,4.1) 16(27.15,-4.1) 17(26.851,4.1) 18(26.551,-4.1) 19(26.25,4.1) 20(25.95,-4.1) 21(25.65,4.1) 22(25.35,-4.1) 23(25.051,4.1) 24(24.75,-4.1) 25(24.45,4.1) 26(24.15,-4.1) 27(23.851,4.1) 28(23.55,-4.1) 29(23.25,4.1) 30(22.95,-4.1) 31(22.651,4.1) 32(22.351,-4.1) 33(22.05,4.1) 34(21.75,-4.1) 35(21.451,4.1) 36(21.151,-4.1) 37(20.85,4.1) 38(20.55,-4.1) 39(20.25,4.1) 40(19.95,-4.1) 41(19.65,4.1) 42(19.35,-4.1) 43(19.049,4.1) 44(18.749,-4.1) 45(18.45,4.1) 46(18.15,-4.1) 47(17.85,4.1) 48(17.549,-4.1) 49(17.25,4.1) 50(16.95,-4.1) 51(16.65,4.1) 52(16.349,-4.1) 53(16.049,4.1) 54(15.75,-4.1) 55(15.45,4.1) 56(15.15,-4.1) 57(14.849,4.1) 58(14.549,-4.1) 59(14.25,4.1) 60(13.95,-4.1) 61(13.649,4.1) 62(13.349,-4.1) 63(13.05,4.1) 64(12.75,-4.1) 65(12.45,4.1) 66(12.149,-4.1) 67(11.85,4.1) 68(11.55,-4.1) 69(11.25,4.1) 70(10.95,-4.1) 71(10.649,4.1) 72(10.349,-4.1) 73(7.65,4.1) 74(7.35,-4.1) 75(7.049,4.1) 76(6.749,-4.1) 77(6.45,4.1) 78(6.15,-4.1) 79(5.85,4.1) 80(5.549,-4.1) 81(5.25,4.1) 82(4.95,-4.1) 83(4.65,4.1) 84(4.349,-4.1) 85(4.05,4.1) 86(3.75,-4.1) 87(3.45,4.1) 88(3.15,-4.1) 89(2.849,4.1) 90(2.549,-4.1) 91(2.25,4.1) 92(1.95,-4.1) 93(1.649,4.1) 94(1.349,-4.1) 95(1.05,4.1) 96(0.75,-4.1) 97(0.45,4.1) 98(0.149,-4.1) 99(-0.15,4.1) 100(-0.45,-4.1) 101(-0.75,4.1) 102(-1.051,-4.1) 103(-1.351,4.1) 104(-1.65,-4.1) 105(-1.95,4.1) 106(-2.25,-4.1) 107(-2.551,4.1) 108(-2.851,-4.1) 109(-3.15,4.1) 110(-3.45,-4.1) 111(-3.751,4.1) 112(-4.051,-4.1) 113(-4.35,4.1) 114(-4.65,-4.1) 115(-4.95,4.1) 116(-5.251,-4.1) 117(-5.55,4.1) 118(-5.85,-4.1) 119(-6.15,4.1) 120(-6.451,-4.1) 121(-6.751,4.1) 122(-7.051,-4.1) 123(-7.35,4.1) 124(-7.65,-4.1) 125(-7.951,4.1) 126(-8.251,-4.1) 127(-8.55,4.1) 128(-8.85,-4.1) 129(-9.15,4.1) 130(-9.451,-4.1) 131(-9.75,4.1) 132(-10.05,-4.1) 133(-10.35,4.1) 134(-10.651,-4.1) 135(-10.95,4.1) 136(-11.25,-4.1) 137(-11.55,4.1) 138(-11.85,-4.1) 139(-12.151,4.1) 140(-12.451,-4.1) 141(-12.75,4.1) 142(-13.05,-4.1) 143(-13.351,4.1) 144(-13.651,-4.1) 145(-13.95,4.1) 146(-14.25,-4.1) 147(-14.55,4.1) 148(-14.851,-4.1) 149(-15.15,4.1) 150(-15.45,-4.1) 151(-15.75,4.1) 152(-16.051,-4.1) 153(-16.35,4.1) 154(-16.65,-4.1) 155(-16.95,4.1) 156(-17.25,-4.1) 157(-17.551,4.1) 158(-17.851,-4.1) 159(-18.15,4.1) 160(-18.45,-4.1) 161(-18.751,4.1) 162(-19.051,-4.1) 163(-19.35,4.1) 164(-19.65,-4.1) 165(-19.95,4.1) 166(-20.251,-4.1) 167(-20.55,4.1) 168(-20.85,-4.1) 169(-21.15,4.1) 170(-21.451,-4.1) 171(-21.751,4.1) 172(-22.051,-4.1) 173(-22.35,4.1) 174(-22.65,-4.1) 175(-22.951,4.1) 176(-23.251,-4.1) 177(-23.55,4.1) 178(-23.85,-4.1) 179(-24.151,4.1) 180(-24.451,-4.1) 181(-24.75,4.1) 182(-25.05,-4.1) 183(-25.35,4.1) 184(-25.651,-4.1) 185(-25.95,4.1) 186(-26.25,-4.1) 187(-26.55,4.1) 188(-26.851,-4.1) 189(-27.151,4.1) 190(-27.451,-4.1) 191(-27.75,4.1) 192(-28.05,-4.1) 193(-28.351,4.1) 194(-28.651,-4.1) 195(-28.95,4.1) 196(-29.25,-4.1) 197(-29.55,4.1) 198(-29.851,-4.1) 199(-30.15,4.1) 200(-30.45,-4.1) 201(-30.75,4.1) 202(-31.05,-4.1) 203(-31.349,4.1) 204(-31.649,-4.1)
  rect 3.505x4.597 smd: 205(-32.8,12) 206(32.8,12)
1932210-2
  round 0.254 hole 1.118 unplated: (-33.4,0)
  round 0.254 hole 1.651 unplated: (33.4,0)
  custom 0.114x0.114 smd: 1(31.65,4.1) 2(31.35,-4.1) 3(31.05,4.1) 4(30.75,-4.1) 5(30.45,4.1) 6(30.15,-4.1) 7(29.85,4.1) 8(29.55,-4.1) 9(29.25,4.1) 10(28.95,-4.1) 11(28.65,4.1) 12(28.35,-4.1) 13(28.05,4.1) 14(27.75,-4.1) 15(27.45,4.1) 16(27.15,-4.1) 17(26.85,4.1) 18(26.55,-4.1) 19(26.25,4.1) 20(25.95,-4.1) 21(25.65,4.1) 22(25.35,-4.1) 23(25.05,4.1) 24(24.75,-4.1) 25(24.45,4.1) 26(24.15,-4.1) 27(23.85,4.1) 28(23.55,-4.1) 29(23.25,4.1) 30(22.95,-4.1) 31(22.65,4.1) 32(22.35,-4.1) 33(22.05,4.1) 34(21.75,-4.1) 35(21.45,4.1) 36(21.15,-4.1) 37(20.85,4.1) 38(20.55,-4.1) 39(20.25,4.1) 40(19.95,-4.1) 41(19.65,4.1) 42(19.35,-4.1) 43(19.05,4.1) 44(18.75,-4.1) 45(18.45,4.1) 46(18.15,-4.1) 47(17.85,4.1) 48(17.55,-4.1) 49(17.25,4.1) 50(16.95,-4.1) 51(16.65,4.1) 52(16.35,-4.1) 53(16.05,4.1) 54(15.75,-4.1) 55(15.45,4.1) 56(15.15,-4.1) 57(14.85,4.1) 58(14.55,-4.1) 59(14.25,4.1) 60(13.95,-4.1) 61(13.65,4.1) 62(13.35,-4.1) 63(13.05,4.1) 64(12.75,-4.1) 65(12.45,4.1) 66(12.15,-4.1) 67(11.85,4.1) 68(11.55,-4.1) 69(11.25,4.1) 70(10.95,-4.1) 71(10.65,4.1) 72(10.35,-4.1) 73(7.65,4.1) 74(7.35,-4.1) 75(7.05,4.1) 76(6.75,-4.1) 77(6.45,4.1) 78(6.15,-4.1) 79(5.85,4.1) 80(5.55,-4.1) 81(5.25,4.1) 82(4.95,-4.1) 83(4.65,4.1) 84(4.35,-4.1) 85(4.05,4.1) 86(3.75,-4.1) 87(3.45,4.1) 88(3.15,-4.1) 89(2.85,4.1) 90(2.55,-4.1) 91(2.25,4.1) 92(1.95,-4.1) 93(1.65,4.1) 94(1.35,-4.1) 95(1.05,4.1) 96(0.75,-4.1) 97(0.45,4.1) 98(0.15,-4.1) 99(-0.15,4.1) 100(-0.45,-4.1) 101(-0.75,4.1) 102(-1.05,-4.1) 103(-1.35,4.1) 104(-1.65,-4.1) 105(-1.95,4.1) 106(-2.25,-4.1) 107(-2.55,4.1) 108(-2.85,-4.1) 109(-3.15,4.1) 110(-3.45,-4.1) 111(-3.75,4.1) 112(-4.05,-4.1) 113(-4.35,4.1) 114(-4.65,-4.1) 115(-4.95,4.1) 116(-5.25,-4.1) 117(-5.55,4.1) 118(-5.85,-4.1) 119(-6.15,4.1) 120(-6.45,-4.1) 121(-6.75,4.1) 122(-7.05,-4.1) 123(-7.35,4.1) 124(-7.65,-4.1) 125(-7.95,4.1) 126(-8.25,-4.1) 127(-8.55,4.1) 128(-8.85,-4.1) 129(-9.15,4.1) 130(-9.45,-4.1) 131(-9.75,4.1) 132(-10.05,-4.1) 133(-10.35,4.1) 134(-10.65,-4.1) 135(-10.95,4.1) 136(-11.25,-4.1) 137(-11.55,4.1) 138(-11.85,-4.1) 139(-12.15,4.1) 140(-12.45,-4.1) 141(-12.75,4.1) 142(-13.05,-4.1) 143(-13.35,4.1) 144(-13.65,-4.1) 145(-13.95,4.1) 146(-14.25,-4.1) 147(-14.55,4.1) 148(-14.85,-4.1) 149(-15.15,4.1) 150(-15.45,-4.1) 151(-15.75,4.1) 152(-16.05,-4.1) 153(-16.35,4.1) 154(-16.65,-4.1) 155(-16.95,4.1) 156(-17.25,-4.1) 157(-17.55,4.1) 158(-17.85,-4.1) 159(-18.15,4.1) 160(-18.45,-4.1) 161(-18.75,4.1) 162(-19.05,-4.1) 163(-19.35,4.1) 164(-19.65,-4.1) 165(-19.95,4.1) 166(-20.25,-4.1) 167(-20.55,4.1) 168(-20.85,-4.1) 169(-21.15,4.1) 170(-21.45,-4.1) 171(-21.75,4.1) 172(-22.05,-4.1) 173(-22.35,4.1) 174(-22.65,-4.1) 175(-22.95,4.1) 176(-23.25,-4.1) 177(-23.55,4.1) 178(-23.85,-4.1) 179(-24.15,4.1) 180(-24.45,-4.1) 181(-24.75,4.1) 182(-25.05,-4.1) 183(-25.35,4.1) 184(-25.65,-4.1) 185(-25.95,4.1) 186(-26.25,-4.1) 187(-26.55,4.1) 188(-26.85,-4.1) 189(-27.15,4.1) 190(-27.45,-4.1) 191(-27.75,4.1) 192(-28.05,-4.1) 193(-28.35,4.1) 194(-28.65,-4.1) 195(-28.95,4.1) 196(-29.25,-4.1) 197(-29.55,4.1) 198(-29.85,-4.1) 199(-30.15,4.1) 200(-30.45,-4.1) 201(-30.75,4.1) 202(-31.05,-4.1) 203(-31.35,4.1) 204(-31.65,-4.1)
  rect 4.496x4.597 smd: 205(37.452,12) 206(-37.452,12)
2199230-7
  round 0.254 hole 1.6 unplated: (-10,0)
  round 0.254 hole 1.118 unplated: (10,0)
  rect 0.305x1.854 smd: 1(9.25,-5.423) 2(9,2.423) 3(8.75,-5.423) 4(8.5,2.423) 5(8.25,-5.423) 6(8,2.423) 7(7.75,-5.423) 16(5.5,2.423) 17(5.25,-5.423) 18(5,2.423) 19(4.75,-5.423) 20(4.5,2.423) 21(4.25,-5.423) 22(4,2.423) 23(3.75,-5.423) 24(3.5,2.423) 25(3.25,-5.423) 26(3,2.423) 27(2.75,-5.423) 28(2.5,2.423) 29(2.25,-5.423) 30(2,2.423) 31(1.75,-5.423) 32(1.5,2.423) 33(1.25,-5.423) 34(1,2.423) 35(0.75,-5.423) 36(0.5,2.423) 37(0.25,-5.423) 38(0,2.423) 39(-0.25,-5.423) 40(-0.5,2.423) 41(-0.75,-5.423) 42(-1,2.423) 43(-1.25,-5.423) 44(-1.5,2.423) 45(-1.75,-5.423) 46(-2,2.423) 47(-2.25,-5.423) 48(-2.5,2.423) 49(-2.75,-5.423) 50(-3,2.423) 51(-3.25,-5.423) 52(-3.5,2.423) 53(-3.75,-5.423) 54(-4,2.423) 55(-4.25,-5.423) 56(-4.5,2.423) 57(-4.75,-5.423) 58(-5,2.423) 59(-5.25,-5.423) 60(-5.5,2.423) 61(-5.75,-5.423) 62(-6,2.423) 63(-6.25,-5.423) 64(-6.5,2.423) 65(-6.75,-5.423) 66(-7,2.423) 67(-7.25,-5.423) 68(-7.5,2.423) 69(-7.75,-5.423) 70(-8,2.423) 71(-8.25,-5.423) 72(-8.5,2.423) 73(-8.75,-5.423) 74(-9,2.423) 75(-9.25,-5.423)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
A1251WR0-8PS-5E
  rect 0.813x1.6 smd: 1(-4.375,2.9) 2(-3.125,2.9) 3(-1.875,2.9) 4(-0.625,2.9) 5(0.625,2.9) 6(1.875,2.9) 7(3.125,2.9) 8(4.375,2.9)
  rect 2.108x2.997 smd: 9(-6.925,0) 10(6.925,0)
A1501WV0-5P-6T-2D4
  round 1.168 hole 0.813: 1(3,0) 2(1.5,0) 3(0,0) 4(-1.5,0) 5(-3,0)
A1501WV0-6PS-5E
  rect 0.711x3.505 smd: 1(3.75,2) 2(2.25,2) 3(0.75,2) 4(-0.75,2) 5(-2.25,2) 6(-3.75,2)
  rect 1.499x2.311 smd: 7(5.8,0) 8(-5.8,0)
A2001WV2-2P-U
  round 1.27 hole 0.889: 1(0.992,-0.003) 2(-1.008,-0.003)
A2006WV0-2X5P-6T2-2D3
  round 1.27 hole 0.889: 1(4,-1) 2(4,1) 3(2,-1) 4(2,1) 5(0,-1) 6(0,1) 7(-2,-1) 8(-2,1) 9(-4,-1) 10(-4,1)
A2006WV0-2X6P-6T2-2D3
  round 1.27 hole 0.889: 1(5,-1) 2(5,1) 3(3,-1) 4(3,1) 5(1,-1) 6(1,1) 7(-1,-1) 8(-1,1) 9(-3,-1) 10(-3,1) 11(-5,-1) 12(-5,1)
A2541WV0-1EX2PA-6T
  round 1.397 hole 0.991: 1(-1.27,0) 2(1.27,0)
AAA-BAT-034-K01
  round 0.254 hole 1.067 unplated: (-7.5,0)
  round 0.254 hole 1.372 unplated: (0,0)
  rect 2.794x3.607 smd: 1(6.2,0)
  rect 2.997x2.591 smd: 2(-15.1,0)
ARES2H16
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
ARES8-CN24-MUH20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
ARES8-CN24H20
  rect 0.61x0.66 smd: 1(-0.9,-0.486) 4(0.9,-0.486) 5(0.9,0.486) 8(-0.9,0.486)
  rect 0.305x0.66 smd: 2(-0.25,-0.486) 3(0.25,-0.486) 6(0.25,0.486) 7(-0.25,0.486)
BGA96D075130H48
  round 0.356 smd: A1(-3.2,6) A2(-2.4,6) A3(-1.6,6) A7(1.6,6) A8(2.4,6) A9(3.2,6) B1(-3.2,5.2) B2(-2.4,5.2) B3(-1.6,5.2) B7(1.6,5.2) B8(2.4,5.2) B9(3.2,5.2) C1(-3.2,4.4) C2(-2.4,4.4) C3(-1.6,4.4) C7(1.6,4.4) C8(2.4,4.4) C9(3.2,4.4) D1(-3.2,3.6) D2(-2.4,3.6) D3(-1.6,3.6) D7(1.6,3.6) D8(2.4,3.6) D9(3.2,3.6) E1(-3.2,2.8) E2(-2.4,2.8) E3(-1.6,2.8) E7(1.6,2.8) E8(2.4,2.8) E9(3.2,2.8) F1(-3.2,2) F2(-2.4,2) F3(-1.6,2) F7(1.6,2) F8(2.4,2) F9(3.2,2) G1(-3.2,1.2) G2(-2.4,1.2) G3(-1.6,1.2) G7(1.6,1.2) G8(2.4,1.2) G9(3.2,1.2) H1(-3.2,0.4) H2(-2.4,0.4) H3(-1.6,0.4) H7(1.6,0.4) H8(2.4,0.4) H9(3.2,0.4) J1(-3.2,-0.4) J2(-2.4,-0.4) J3(-1.6,-0.4) J7(1.6,-0.4) J8(2.4,-0.4) J9(3.2,-0.4) K1(-3.2,-1.2) K2(-2.4,-1.2) K3(-1.6,-1.2) K7(1.6,-1.2) K8(2.4,-1.2) K9(3.2,-1.2) L1(-3.2,-2) L2(-2.4,-2) L3(-1.6,-2) L7(1.6,-2) L8(2.4,-2) L9(3.2,-2) M1(-3.2,-2.8) M2(-2.4,-2.8) M3(-1.6,-2.8) M7(1.6,-2.8) M8(2.4,-2.8) M9(3.2,-2.8) N1(-3.2,-3.6) N2(-2.4,-3.6) N3(-1.6,-3.6) N7(1.6,-3.6) N8(2.4,-3.6) N9(3.2,-3.6) P1(-3.2,-4.4) P2(-2.4,-4.4) P3(-1.6,-4.4) P7(1.6,-4.4) P8(2.4,-4.4) P9(3.2,-4.4) R1(-3.2,-5.2) R2(-2.4,-5.2) R3(-1.6,-5.2) R7(1.6,-5.2) R8(2.4,-5.2) R9(3.2,-5.2) T1(-3.2,-6) T2(-2.4,-6) T3(-1.6,-6) T7(1.6,-6) T8(2.4,-6) T9(3.2,-6)
BGA631M23H82
  round 0.406 smd: A3(-10,10.8) A5(-9.2,10.8) A28(9.2,10.8) A30(10,10.8) A32(10.8,10.8) AH1(-10.8,-9.2) AH3(-10,-9.2) AH5(-9.2,-9.2) AH28(9.2,-9.2) AH30(10,-9.2) AH32(10.8,-9.2) AK1(-10.8,-10) AK3(-10,-10) AK5(-9.2,-10) AK28(9.2,-10) AK30(10,-10) AK32(10.8,-10) AM1(-10.8,-10.8) AM3(-10,-10.8) AM5(-9.2,-10.8) AM28(9.2,-10.8) AM30(10,-10.8) AM32(10.8,-10.8) C1(-10.8,10) C3(-10,10) C5(-9.2,10) C28(9.2,10) C30(10,10) C32(10.8,10) E1(-10.8,9.2) E3(-10,9.2) E5(-9.2,9.2) E28(9.2,9.2) E30(10,9.2) E32(10.8,9.2)
  round 0.356 smd: A7(-7.6,10.8) A9(-6,10.8) A11(-4.4,10.8) A13(-2.8,10.8) A15(-1.2,10.8) A17(0.4,10.8) A19(2,10.8) A21(3.6,10.8) A23(5.2,10.8) A25(6.8,10.8) A27(8.4,10.8) AA1(-10.8,-3.6) AA3(-10,-3.6) AA5(-9.2,-3.6) AA6(-8.4,-3.6) AA11(-4.4,-3.4) AA12(-3.4,-3.4) AA13(-2.4,-3.4) AA15(-1.4,-3.4) AA16(-0.4,-3.4) AA17(0.4,-3.4) AA18(1.4,-3.4) AA20(2.4,-3.4) AA21(3.4,-3.4) AA22(4.4,-3.4) AA27(8.4,-3.6) AA29(9.6,-3.6) AA31(10.4,-3.6) AB2(-10.4,-4.4) AB4(-9.6,-4.4) AB6(-8.4,-4.4) AB7(-7.6,-4.2) AB8(-6.8,-4.2) AB9(-6,-4.2) AB10(-5.2,-4.2) AB11(-4.4,-4.4) AB12(-3.4,-4.4) AB13(-2.4,-4.4) AB15(-1.4,-4.4) AB16(-0.4,-4.4) AB17(0.4,-4.4) AB18(1.4,-4.4) AB20(2.4,-4.4) AB21(3.4,-4.4) AB22(4.4,-4.4) AB23(5.2,-4.2) AB24(6,-4.2) AB25(6.8,-4.2) AB26(7.6,-4.2) AB27(8.4,-4.4) AB28(9.2,-4.4) AB30(10,-4.4) AB32(10.8,-4.4) AC1(-10.8,-5.2) AC3(-10,-5.2) AC5(-9.2,-5.2) AC6(-8.4,-5.2) AC7(-7.6,-5.2) AC8(-6.8,-5.2) AC9(-6,-5.2) AC10(-5.2,-5.2) AC11(-4.2,-5.2) AC13(-3,-5.2) AC14(-1.8,-5.2) AC16(-0.6,-5.2) AC17(0.6,-5.2) AC19(1.8,-5.2) AC20(3,-5.2) AC22(4.2,-5.2) AC23(5.2,-5.2) AC24(6,-5.2) AC25(6.8,-5.2) AC26(7.6,-5.2) AC27(8.4,-5.2) AC29(9.6,-5.2) AC31(10.4,-5.2) AD2(-10.4,-6) AD4(-9.6,-6) AD6(-8.4,-6) AD7(-7.6,-6) AD8(-6.8,-6) AD9(-6,-6) AD10(-5.2,-6) AD11(-4.2,-6) AD13(-3,-6) AD14(-1.8,-6) AD16(-0.6,-6) AD17(0.6,-6) AD19(1.8,-6) AD20(3,-6) AD22(4.2,-6) AD23(5.2,-6) AD24(6,-6) AD25(6.8,-6) AD26(7.6,-6) AD27(8.4,-6) AD28(9.2,-6) AD30(10,-6) AD32(10.8,-6) AE1(-10.8,-6.8) AE3(-10,-6.8) AE5(-9.2,-6.8) AE6(-8.4,-6.8) AE7(-7.6,-6.8) AE8(-6.8,-6.8) AE9(-6,-6.8) AE10(-5.2,-6.8) AE11(-4.2,-6.8) AE13(-3,-6.8) AE14(-1.8,-6.8) AE16(-0.6,-6.8) AE17(0.6,-6.8) AE19(1.8,-6.8) AE20(3,-6.8) AE22(4.2,-6.8) AE23(5.2,-6.8) AE24(6,-6.8) AE25(6.8,-6.8) AE26(7.6,-6.8) AE27(8.4,-6.8) AE29(9.6,-6.8) AE31(10.4,-6.8) AF2(-10.4,-7.6) AF4(-9.6,-7.6) AF6(-8.4,-7.6) AF7(-7.6,-7.6) AF8(-6.8,-7.6) AF9(-6,-7.6) AF10(-5.2,-7.6) AF11(-4.2,-7.6) AF13(-3,-7.6) AF14(-1.8,-7.6) AF16(-0.6,-7.6) AF17(0.6,-7.6) AF19(1.8,-7.6) AF20(3,-7.6) AF22(4.2,-7.6) AF23(5.2,-7.6) AF24(6,-7.6) AF25(6.8,-7.6) AF26(7.6,-7.6) AF27(8.4,-7.6) AF28(9.2,-7.6) AF30(10,-7.6) AF32(10.8,-7.6) AG1(-10.8,-8.4) AG3(-10,-8.4) AG5(-9.2,-8.4) AG6(-8.4,-8.4) AG7(-7.6,-8.4) AG8(-6.8,-8.4) AG9(-6,-8.4) AG10(-5.2,-8.4) AG11(-4.4,-8.4) AG12(-3.6,-8.4) AG13(-2.8,-8.4) AG14(-2,-8.4) AG15(-1.2,-8.4) AG16(-0.4,-8.4) AG17(0.4,-8.4) AG18(1.2,-8.4) AG19(2,-8.4) AG20(2.8,-8.4) AG21(3.6,-8.4) AG22(4.4,-8.4) AG23(5.2,-8.4) AG24(6,-8.4) AG25(6.8,-8.4) AG26(7.6,-8.4) AG27(8.4,-8.4) AG29(9.6,-8.4) AG31(10.4,-8.4) AH6(-8.4,-9.2) AH8(-6.8,-9.2) AH10(-5.2,-9.2) AH12(-3.6,-9.2) AH14(-2,-9.2) AH16(-0.4,-9.2) AH18(1.2,-9.2) AH20(2.8,-9.2) AH22(4.4,-9.2) AH24(6,-9.2) AH26(7.6,-9.2) AJ7(-7.6,-9.6) AJ9(-6,-9.6) AJ11(-4.4,-9.6) AJ13(-2.8,-9.6) AJ15(-1.2,-9.6) AJ17(0.4,-9.6) AJ19(2,-9.6) AJ21(3.6,-9.6) AJ23(5.2,-9.6) AJ25(6.8,-9.6) AJ27(8.4,-9.6) AK6(-8.4,-10) AK8(-6.8,-10) AK10(-5.2,-10) AK12(-3.6,-10) AK14(-2,-10) AK16(-0.4,-10) AK18(1.2,-10) AK20(2.8,-10) AK22(4.4,-10) AK24(6,-10) AK26(7.6,-10) AL7(-7.6,-10.4) AL9(-6,-10.4) AL11(-4.4,-10.4) AL13(-2.8,-10.4) AL15(-1.2,-10.4) AL17(0.4,-10.4) AL19(2,-10.4) AL21(3.6,-10.4) AL23(5.2,-10.4) AL25(6.8,-10.4) AL27(8.4,-10.4) AM6(-8.4,-10.8) AM8(-6.8,-10.8) AM10(-5.2,-10.8) AM12(-3.6,-10.8) AM14(-2,-10.8) AM16(-0.4,-10.8) AM18(1.2,-10.8) AM20(2.8,-10.8) AM22(4.4,-10.8) AM24(6,-10.8) AM26(7.6,-10.8) B6(-8.4,10.4) B8(-6.8,10.4) B10(-5.2,10.4) B12(-3.6,10.4) B14(-2,10.4) B16(-0.4,10.4) B18(1.2,10.4) B20(2.8,10.4) B22(4.4,10.4) B24(6,10.4) B26(7.6,10.4) C7(-7.6,10) C9(-6,10) C11(-4.4,10) C13(-2.8,10) C15(-1.2,10) C17(0.4,10) C19(2,10) C21(3.6,10) C23(5.2,10) C25(6.8,10) C27(8.4,10) D6(-8.4,9.6) D8(-6.8,9.6) D10(-5.2,9.6) D12(-3.6,9.6) D14(-2,9.6) D16(-0.4,9.6) D18(1.2,9.6) D20(2.8,9.6) D22(4.4,9.6) D24(6,9.6) D26(7.6,9.6) E7(-7.6,9.2) E9(-6,9.2) E11(-4.4,9.2) E13(-2.8,9.2) E15(-1.2,9.2) E17(0.4,9.2) E19(2,9.2) E21(3.6,9.2) E23(5.2,9.2) E25(6.8,9.2) E27(8.4,9.2) F2(-10.4,8.4) F4(-9.6,8.4) F6(-8.4,8.4) F7(-7.6,8.4) F8(-6.8,8.4) F9(-6,8.4) F10(-5.2,8.4) F11(-4.4,8.4) F12(-3.6,8.4) F13(-2.8,8.4) F14(-2,8.4) F15(-1.2,8.4) F16(-0.4,8.4) F17(0.4,8.4) F18(1.2,8.4) F19(2,8.4) F20(2.8,8.4) F21(3.6,8.4) F22(4.4,8.4) F23(5.2,8.4) F24(6,8.4) F25(6.8,8.4) F26(7.6,8.4) F27(8.4,8.4) F28(9.2,8.4) F30(10,8.4) F32(10.8,8.4) G1(-10.8,7.6) G3(-10,7.6) G5(-9.2,7.6) G6(-8.4,7.6) G7(-7.6,7.6) G8(-6.8,7.6) G9(-6,7.6) G10(-5.2,7.6) G11(-4.2,7.6) G13(-3,7.6) G14(-1.8,7.6) G16(-0.6,7.6) G17(0.6,7.6) G19(1.8,7.6) G20(3,7.6) G22(4.2,7.6) G23(5.2,7.6) G24(6,7.6) G25(6.8,7.6) G26(7.6,7.6) G27(8.4,7.6) G29(9.6,7.6) G31(10.4,7.6) H2(-10.4,6.8) H4(-9.6,6.8) H6(-8.4,6.8) H7(-7.6,6.8) H8(-6.8,6.8) H9(-6,6.8) H10(-5.2,6.8) H11(-4.2,6.8) H13(-3,6.8) H14(-1.8,6.8) H16(-0.6,6.8) H17(0.6,6.8) H19(1.8,6.8) H20(3,6.8) H22(4.2,6.8) H23(5.2,6.8) H24(6,6.8) H25(6.8,6.8) H26(7.6,6.8) H27(8.4,6.8) H28(9.2,6.8) H30(10,6.8) H32(10.8,6.8) J1(-10.8,6) J3(-10,6) J5(-9.2,6) J6(-8.4,6) J7(-7.6,6) J8(-6.8,6) J9(-6,6) J10(-5.2,6) J11(-4.2,6) J13(-3,6) J14(-1.8,6) J16(-0.6,6) J17(0.6,6) J19(1.8,6) J20(3,6) J22(4.2,6) J23(5.2,6) J24(6,6) J25(6.8,6) J26(7.6,6) J27(8.4,6) J29(9.6,6) J31(10.4,6) K2(-10.4,5.2) K4(-9.6,5.2) K6(-8.4,5.2) K7(-7.6,5.2) K8(-6.8,5.2) K9(-6,5.2) K10(-5.2,5.2) K11(-4.2,5.2) K13(-3,5.2) K14(-1.8,5.2) K16(-0.6,5.2) K17(0.6,5.2) K19(1.8,5.2) K20(3,5.2) K22(4.2,5.2) K23(5.2,5.2) K24(6,5.2) K25(6.8,5.2) K26(7.6,5.2) K27(8.4,5.2) K28(9.2,5.2) K30(10,5.2) K32(10.8,5.2) L1(-10.8,4.4) L3(-10,4.4) L5(-9.2,4.4) L6(-8.4,4.4) L7(-7.6,4.2) L8(-6.8,4.2) L9(-6,4.2) L10(-5.2,4.2) L11(-4.4,4.4) L12(-3.4,4.4) L13(-2.4,4.4) L15(-1.4,4.4) L16(-0.4,4.4) L17(0.4,4.4) L18(1.4,4.4) L20(2.4,4.4) L21(3.4,4.4) L22(4.4,4.4) L23(5.2,4.2) L24(6,4.2) L25(6.8,4.2) L26(7.6,4.2) L27(8.4,4.4) L29(9.6,4.4) L31(10.4,4.4) M2(-10.4,3.6) M4(-9.6,3.6) M6(-8.4,3.6) M11(-4.4,3.4) M12(-3.4,3.4) M13(-2.4,3.4) M15(-1.4,3.4) M16(-0.4,3.4) M17(0.4,3.4) M18(1.4,3.4) M20(2.4,3.4) M21(3.4,3.4) M22(4.4,3.4) M27(8.4,3.6) M28(9.2,3.6) M30(10,3.6) M32(10.8,3.6) N1(-10.8,2.8) N3(-10,2.8) N5(-9.2,2.8) N6(-8.4,2.8) N7(-7.6,3) N8(-6.8,3) N9(-6,3) N10(-5.2,3) N11(-4.4,2.4) N12(-3.4,2.4) N13(-2.4,2.4) N15(-1.4,2.4) N16(-0.4,2.4) N17(0.4,2.4) N18(1.4,2.4) N20(2.4,2.4) N21(3.4,2.4) N22(4.4,2.4) N23(5.2,3) N24(6,3) N25(6.8,3) N26(7.6,3) N27(8.4,2.8) N29(9.6,2.8) N31(10.4,2.8) P2(-10.4,2) P4(-9.6,2) P6(-8.4,2) P7(-7.6,1.8) P8(-6.8,1.8) P9(-6,1.8) P10(-5.2,1.8) P23(5.2,1.8) P24(6,1.8) P25(6.8,1.8) P26(7.6,1.8) P27(8.4,2) P28(9.2,2) P30(10,2) P32(10.8,2) R1(-10.8,1.2) R3(-10,1.2) R5(-9.2,1.2) R6(-8.4,1.2) R11(-4.4,1.4) R12(-3.4,1.4) R13(-2.4,1.4) R15(-1.4,1.4) R16(-0.4,1.4) R17(0.4,1.4) R18(1.4,1.4) R20(2.4,1.4) R21(3.4,1.4) R22(4.4,1.4) R27(8.4,1.2) R29(9.6,1.2) R31(10.4,1.2) T2(-10.4,0.4) T4(-9.6,0.4) T6(-8.4,0.4) T7(-7.6,0.6) T8(-6.8,0.6) T9(-6,0.6) T10(-5.2,0.6) T11(-4.4,0.4) T12(-3.4,0.4) T13(-2.4,0.4) T15(-1.4,0.4) T16(-0.4,0.4) T17(0.4,0.4) T18(1.4,0.4) T20(2.4,0.4) T21(3.4,0.4) T22(4.4,0.4) T23(5.2,0.6) T24(6,0.6) T25(6.8,0.6) T26(7.6,0.6) T27(8.4,0.4) T28(9.2,0.4) T30(10,0.4) T32(10.8,0.4) U1(-10.8,-0.4) U3(-10,-0.4) U5(-9.2,-0.4) U6(-8.4,-0.4) U7(-7.6,-0.6) U8(-6.8,-0.6) U9(-6,-0.6) U10(-5.2,-0.6) U11(-4.4,-0.4) U12(-3.4,-0.4) U13(-2.4,-0.4) U15(-1.4,-0.4) U16(-0.4,-0.4) U17(0.4,-0.4) U18(1.4,-0.4) U20(2.4,-0.4) U21(3.4,-0.4) U22(4.4,-0.4) U23(5.2,-0.6) U24(6,-0.6) U25(6.8,-0.6) U26(7.6,-0.6) U27(8.4,-0.4) U29(9.6,-0.4) U31(10.4,-0.4) V2(-10.4,-1.2) V4(-9.6,-1.2) V6(-8.4,-1.2) V11(-4.4,-1.4) V12(-3.4,-1.4) V13(-2.4,-1.4) V15(-1.4,-1.4) V16(-0.4,-1.4) V17(0.4,-1.4) V18(1.4,-1.4) V20(2.4,-1.4) V21(3.4,-1.4) V22(4.4,-1.4) V27(8.4,-1.2) V28(9.2,-1.2) V30(10,-1.2) V32(10.8,-1.2) W1(-10.8,-2) W3(-10,-2) W5(-9.2,-2) W6(-8.4,-2) W7(-7.6,-1.8) W8(-6.8,-1.8) W9(-6,-1.8) W10(-5.2,-1.8) W23(5.2,-1.8) W24(6,-1.8) W25(6.8,-1.8) W26(7.6,-1.8) W27(8.4,-2) W29(9.6,-2) W31(10.4,-2) Y2(-10.4,-2.8) Y4(-9.6,-2.8) Y6(-8.4,-2.8) Y7(-7.6,-3) Y8(-6.8,-3) Y9(-6,-3) Y10(-5.2,-3) Y11(-4.4,-2.4) Y12(-3.4,-2.4) Y13(-2.4,-2.4) Y15(-1.4,-2.4) Y16(-0.4,-2.4) Y17(0.4,-2.4) Y18(1.4,-2.4) Y20(2.4,-2.4) Y21(3.4,-2.4) Y22(4.4,-2.4) Y23(5.2,-3) Y24(6,-3) Y25(6.8,-3) Y26(7.6,-3) Y27(8.4,-2.8) Y28(9.2,-2.8) Y30(10,-2.8) Y32(10.8,-2.8)
BGA708Z2322H65
  round 0.533 smd: A2(-10.171,10.299) A40(10.339,10.299) AV1(-10.799,-9.839) AV41(10.799,-9.839) AW2(-10.339,-10.299) AW40(10.339,-10.299) B1(-10.799,9.672) B41(10.799,9.839)
  round 0.406 smd: A3(-9.521,10.299) A39(9.689,10.299) AU1(-10.799,-9.081) AU41(10.799,-9.189) AV2(-10.171,-9.671) AV40(10.171,-9.671) AW3(-9.689,-10.299) AW39(9.689,-10.299) B2(-10.14,9.639) B40(10.171,9.671) C1(-10.799,9.021) C41(10.799,9.081)
  round 0.381 smd: A4(-8.732,10.299) A7(-7.653,10.314) A9(-6.383,10.314) A12(-5.113,10.314) A31(5.098,10.314) A33(6.369,10.314) A35(7.639,10.314) A38(8.965,10.299) AA6(-8.135,-0.464) AA7(-7.424,-0.464) AA8(-6.713,-0.464) AA10(-6.002,-0.464) AA11(-5.29,-0.464) AA12(-4.579,-0.464) AA14(-3.629,-0.423) AA16(-2.823,-0.423) AA17(-2.016,-0.423) AA19(-1.21,-0.423) AA20(-0.403,-0.423) AA22(0.403,-0.423) AA23(1.21,-0.423) AA25(2.016,-0.423) AA26(2.822,-0.423) AA28(3.629,-0.423) AA30(4.579,-0.464) AA31(5.29,-0.464) AA32(6.002,-0.464) AA34(6.713,-0.464) AA35(7.424,-0.464) AA36(8.135,-0.464) AB14(-3.629,-1.269) AB16(-2.823,-1.269) AB17(-2.016,-1.269) AB19(-1.21,-1.269) AB20(-0.403,-1.269) AB22(0.403,-1.269) AB23(1.21,-1.269) AB25(2.016,-1.269) AB26(2.822,-1.269) AB28(3.629,-1.269) AC6(-8.186,-1.53) AC7(-7.424,-1.53) AC8(-6.713,-1.53) AC10(-6.002,-1.53) AC11(-5.29,-1.53) AC12(-4.579,-1.53) AC30(4.579,-1.53) AC31(5.29,-1.53) AC32(6.002,-1.53) AC34(6.713,-1.53) AC35(7.424,-1.53) AC36(8.186,-1.53) AD14(-3.629,-2.115) AD16(-2.823,-2.115) AD17(-2.016,-2.115) AD19(-1.21,-2.115) AD20(-0.403,-2.115) AD22(0.403,-2.115) AD23(1.21,-2.115) AD25(2.016,-2.115) AD26(2.822,-2.115) AD28(3.629,-2.115) AE6(-8.135,-2.597) AE7(-7.424,-2.597) AE8(-6.713,-2.597) AE10(-6.002,-2.597) AE11(-5.29,-2.597) AE12(-4.64,-2.597) AE30(4.64,-2.597) AE31(5.29,-2.597) AE32(6.002,-2.597) AE34(6.713,-2.597) AE35(7.424,-2.597) AE36(8.135,-2.597) AF14(-3.629,-2.96) AF16(-2.823,-2.96) AF17(-2.016,-2.96) AF19(-1.21,-2.96) AF20(-0.403,-2.96) AF22(0.403,-2.96) AF23(1.21,-2.96) AF25(2.016,-2.96) AF26(2.822,-2.96) AF28(3.629,-2.96) AG6(-8.135,-3.804) AG7(-7.424,-3.804) AG8(-6.713,-3.804) AG10(-6.002,-3.804) AG11(-5.29,-3.804) AG12(-4.579,-3.804) AG30(4.64,-3.804) AG31(5.29,-3.804) AG32(6.002,-3.804) AG34(6.713,-3.804) AG35(7.424,-3.804) AG36(8.135,-3.804) AH14(-3.804,-4.14) AH16(-2.597,-4.14) AH18(-1.53,-4.079) AH20(-0.464,-4.079) AH22(0.464,-4.079) AH24(1.53,-4.079) AH26(2.597,-4.14) AH28(3.804,-4.14) AJ1(-10.814,-5.118) AJ14(-3.804,-4.79) AJ16(-2.597,-4.79) AJ18(-1.53,-4.79) AJ20(-0.464,-4.79) AJ22(0.464,-4.79) AJ24(1.53,-4.79) AJ26(2.597,-4.79) AJ28(3.804,-4.79) AJ31(5.164,-5.016) AK6(-7.828,-5.086) AK8(-7.117,-5.086) AK9(-6.405,-5.086) AK11(-5.086,-5.133) AK14(-3.804,-5.502) AK16(-2.597,-5.502) AK18(-1.53,-5.502) AK20(-0.464,-5.502) AK22(0.464,-5.502) AK24(1.53,-5.502) AK26(2.597,-5.502) AK28(3.804,-5.502) AK33(6.344,-5.086) AK34(7.056,-5.086) AK36(7.818,-5.086) AK41(10.814,-5.288) AL11(-5.086,-5.845) AL31(5.086,-5.906) AM1(-10.814,-6.388) AM6(-8.135,-6.179) AM7(-7.485,-6.179) AM8(-6.835,-6.179) AM9(-6.189,-6.335) AM11(-5.086,-6.556) AM14(-3.804,-6.213) AM16(-2.597,-6.213) AM18(-1.53,-6.213) AM20(-0.464,-6.213) AM22(0.464,-6.213) AM24(1.53,-6.213) AM26(2.597,-6.213) AM28(3.804,-6.213) AM31(5.086,-6.617) AM33(6.179,-6.274) AM34(6.835,-6.189) AM35(7.485,-6.189) AM36(8.135,-6.189) AM41(10.814,-6.558) AN9(-6.189,-6.985) AN14(-3.804,-6.924) AN16(-2.597,-6.924) AN18(-1.53,-6.924) AN20(-0.464,-6.924) AN22(0.464,-6.924) AN24(1.53,-6.924) AN26(2.597,-6.924) AN28(3.804,-6.924) AN33(6.179,-6.924) AP1(-10.814,-7.658) AP7(-7.332,-7.352) AP9(-6.189,-7.635) AP11(-5.086,-7.318) AP14(-3.804,-7.635) AP16(-2.597,-7.635) AP18(-1.53,-7.686) AP20(-0.464,-7.635) AP22(0.464,-7.635) AP24(1.53,-7.686) AP26(2.597,-7.635) AP28(3.804,-7.635) AP31(5.086,-7.328) AP33(6.179,-7.635) AP35(7.325,-7.347) AR41(10.814,-7.828) AT1(-10.799,-8.357) AT2(-10.148,-8.357) AT40(10.168,-8.357) AT41(10.799,-8.539) AU2(-10.15,-9.021) AU40(10.169,-9.021) AV3(-9.52,-9.671) AV5(-8.34,-9.758) AV39(9.496,-9.671) AW4(-8.965,-10.299) AW7(-7.639,-10.314) AW9(-6.369,-10.314) AW11(-5.099,-10.314) AW30(5.112,-10.314) AW33(6.382,-10.314) AW35(7.652,-10.314) AW38(8.965,-10.299) B3(-9.48,9.639) B37(8.34,9.758) B39(9.52,9.671) C2(-10.14,8.978) C40(10.15,9.021) D1(-10.799,8.371) D2(-10.129,8.327) D40(10.148,8.357) D41(10.799,8.357) E1(-10.814,7.638) F7(-7.325,7.347) F9(-6.179,7.635) F11(-5.086,7.328) F14(-3.804,7.635) F16(-2.597,7.635) F18(-1.53,7.686) F20(-0.464,7.635) F22(0.464,7.635) F24(1.53,7.686) F26(2.597,7.635) F28(3.804,7.635) F31(5.086,7.318) F33(6.189,7.635) F35(7.332,7.352) F41(10.814,7.658) G9(-6.179,6.924) G14(-3.804,6.924) G16(-2.597,6.924) G18(-1.53,6.924) G20(-0.464,6.924) G22(0.464,6.924) G24(1.53,6.924) G26(2.597,6.924) G28(3.804,6.924) G33(6.189,6.985) H1(-10.814,6.558) H6(-8.135,6.189) H7(-7.485,6.189) H8(-6.835,6.189) H9(-6.179,6.274) H11(-5.086,6.617) H14(-3.804,6.213) H16(-2.597,6.213) H18(-1.53,6.213) H20(-0.464,6.213) H22(0.464,6.213) H24(1.53,6.213) H26(2.597,6.213) H28(3.804,6.213) H31(5.086,6.556) H33(6.189,6.335) H34(6.835,6.179) H35(7.485,6.179) H36(8.135,6.179) H41(10.814,6.388) J11(-5.086,5.906) J31(5.086,5.845) K1(-10.814,5.288) K6(-7.818,5.086) K8(-7.056,5.086) K9(-6.344,5.086) K14(-3.804,5.502) K16(-2.597,5.502) K18(-1.53,5.502) K20(-0.464,5.502) K22(0.464,5.502) K24(1.53,5.502) K26(2.597,5.502) K28(3.804,5.502) K31(5.086,5.133) K33(6.405,5.086) K34(7.117,5.086) K36(7.828,5.086) L11(-5.164,5.016) L14(-3.804,4.79) L16(-2.597,4.79) L18(-1.53,4.79) L20(-0.464,4.79) L22(0.464,4.79) L24(1.53,4.79) L26(2.597,4.79) L28(3.804,4.79) L41(10.814,5.118) M14(-3.804,4.14) M16(-2.597,4.14) M18(-1.53,4.079) M20(-0.464,4.079) M22(0.464,4.079) M24(1.53,4.079) M26(2.597,4.14) M28(3.804,4.14) N6(-8.135,3.804) N7(-7.424,3.804) N8(-6.713,3.804) N10(-6.002,3.804) N11(-5.29,3.804) N12(-4.64,3.804) N30(4.579,3.804) N31(5.29,3.804) N32(6.002,3.804) N34(6.713,3.804) N35(7.424,3.804) N36(8.135,3.804) P14(-3.629,2.96) P16(-2.823,2.96) P17(-2.016,2.96) P19(-1.21,2.96) P20(-0.403,2.96) P22(0.403,2.96) P23(1.21,2.96) P25(2.016,2.96) P26(2.822,2.96) P28(3.629,2.96) R6(-8.135,2.597) R7(-7.424,2.597) R8(-6.713,2.597) R10(-6.002,2.597) R11(-5.29,2.597) R12(-4.64,2.597) R30(4.64,2.597) R31(5.29,2.597) R32(6.002,2.597) R34(6.713,2.597) R35(7.424,2.597) R36(8.135,2.597) T14(-3.629,2.115) T16(-2.823,2.115) T17(-2.016,2.115) T19(-1.21,2.115) T20(-0.403,2.115) T22(0.403,2.115) T23(1.21,2.115) T25(2.016,2.115) T26(2.822,2.115) T28(3.629,2.115) U6(-8.186,1.53) U7(-7.424,1.53) U8(-6.713,1.53) U10(-6.002,1.53) U11(-5.29,1.53) U12(-4.579,1.53) U30(4.579,1.53) U31(5.29,1.53) U32(6.002,1.53) U34(6.713,1.53) U35(7.424,1.53) U36(8.186,1.53) V14(-3.629,1.269) V16(-2.823,1.269) V17(-2.016,1.269) V19(-1.21,1.269) V20(-0.403,1.269) V22(0.403,1.269) V23(1.21,1.269) V25(2.016,1.269) V26(2.822,1.269) V28(3.629,1.269) W6(-8.135,0.464) W7(-7.424,0.464) W8(-6.713,0.464) W10(-6.002,0.464) W11(-5.29,0.464) W12(-4.579,0.464) W14(-3.629,0.423) W16(-2.823,0.423) W17(-2.016,0.423) W19(-1.21,0.423) W20(-0.403,0.423) W22(0.403,0.423) W23(1.21,0.423) W25(2.016,0.423) W26(2.822,0.423) W28(3.629,0.423) W30(4.579,0.464) W31(5.29,0.464) W32(6.002,0.464) W34(6.713,0.464) W35(7.424,0.464) W36(8.135,0.464)
  oval 0.254x0.343 smd: A14(-3.703,10.314) A16(-2.534,10.314) A19(-1.176,10.314) A21(-0.007,10.314) A24(1.352,10.314) A26(2.52,10.314) A28(3.879,10.314) AB4(-8.818,-1.181) AC38(8.818,-1.349) AG4(-8.818,-3.71) AG38(8.818,-3.879) AL5(-8.779,-5.631) AM4(-8.818,-6.28) AM38(8.818,-6.498) AW14(-3.88,-10.314) AW16(-2.521,-10.314) AW18(-1.352,-10.314) AW21(0.007,-10.314) AW23(1.175,-10.314) AW26(2.534,-10.314) AW28(3.702,-10.314) H4(-8.818,6.498) H38(8.818,6.28) J37(8.779,5.631) N4(-8.818,3.879) N38(8.818,3.71) U4(-8.818,1.349) V38(8.818,1.181)
  round 0.305 smd: AA2(-10.306,-0.432) AA3(-9.479,-0.486) AA5(-8.787,-0.491) AA37(8.787,-0.677) AA39(9.479,-0.677) AA40(10.289,-0.677) AB2(-9.916,-1.181) AC2(-10.289,-1.853) AC3(-9.479,-1.853) AC5(-8.779,-1.853) AC40(9.916,-1.349) AD37(8.779,-2.044) AD39(9.479,-2.044) AD40(10.306,-2.098) AE2(-9.87,-2.479) AE4(-9.128,-2.466) AE38(9.128,-2.593) AE40(9.87,-2.581) AF2(-10.306,-2.962) AF3(-9.479,-3.015) AF5(-8.779,-3.015) AF37(8.779,-3.207) AF39(9.479,-3.207) AF40(10.289,-3.207) AG2(-9.916,-3.71) AG40(9.916,-3.823) AH2(-10.212,-4.383) AH3(-9.479,-4.383) AH5(-8.779,-4.383) AJ2(-9.87,-5.009) AJ4(-9.128,-4.995) AJ5(-8.478,-4.968) AJ37(8.779,-4.574) AJ39(9.479,-4.574) AJ40(10.306,-4.58) AK37(8.478,-5.182) AK38(9.128,-5.212) AK40(9.87,-5.208) AL2(-10.306,-5.579) AL3(-9.479,-5.632) AL37(8.779,-5.826) AL39(9.479,-5.826) AL40(10.289,-5.826) AM2(-9.916,-6.327) AM40(9.916,-6.485) AN2(-10.205,-7.009) AN3(-9.479,-6.999) AN4(-8.83,-6.931) AN37(8.779,-7.193) AN39(9.479,-7.193) AN40(10.289,-7.255) AP2(-9.87,-7.626) AP4(-9.132,-7.567) AP5(-8.482,-7.567) AR4(-8.859,-8.157) AR7(-7.684,-7.978) AR11(-5.154,-7.978) AR30(4.968,-7.978) AR35(7.498,-7.978) AR37(8.478,-7.78) AR38(9.128,-7.742) AR39(9.853,-7.738) AT5(-8.283,-8.462) AT7(-7.654,-8.628) AT8(-7.104,-8.279) AT10(-5.737,-8.279) AT11(-5.124,-8.628) AT12(-4.575,-8.279) AT15(-3.208,-8.279) AT16(-2.594,-8.628) AT17(-2.045,-8.279) AT20(-0.678,-8.287) AT21(-0.064,-8.628) AT22(0.49,-8.287) AT24(1.852,-8.279) AT26(2.466,-8.628) AT27(3.015,-8.279) AT29(4.382,-8.279) AT30(4.994,-8.628) AT31(5.545,-8.279) AT34(6.912,-8.279) AT35(7.524,-8.628) AT36(8.115,-8.352) AT38(8.843,-8.357) AU3(-9.496,-9.021) AU5(-8.246,-9.115) AU8(-7.104,-8.979) AU10(-5.737,-8.979) AU12(-4.575,-8.979) AU15(-3.208,-8.979) AU17(-2.045,-8.979) AU20(-0.678,-8.979) AU22(0.485,-8.979) AU24(1.852,-8.979) AU27(3.015,-8.979) AU29(4.382,-8.979) AU31(5.545,-8.979) AU34(6.912,-8.979) AU36(8.115,-9.005) AU39(9.496,-9.021) AV4(-8.908,-9.395) AV7(-7.641,-9.371) AV8(-7.158,-9.806) AV9(-6.409,-9.416) AV10(-5.737,-9.725) AV11(-5.111,-9.371) AV12(-4.628,-9.806) AV14(-3.88,-9.416) AV15(-3.208,-9.789) AV16(-2.581,-9.371) AV17(-2.098,-9.806) AV18(-1.35,-9.416) AV20(-0.678,-9.789) AV21(-0.051,-9.371) AV22(0.432,-9.806) AV23(1.18,-9.416) AV24(1.852,-9.789) AV26(2.479,-9.371) AV27(2.962,-9.806) AV28(3.71,-9.416) AV29(4.382,-9.789) AV30(5.008,-9.351) AV31(5.545,-9.786) AV33(6.303,-9.416) AV34(6.912,-9.789) AV35(7.538,-9.371) AV36(8.113,-9.756) AV38(8.843,-9.652) B4(-8.849,9.457) B6(-8.187,9.781) B7(-7.539,9.371) B8(-6.912,9.789) B9(-6.304,9.416) B11(-5.545,9.786) B12(-5.009,9.351) B13(-4.383,9.789) B14(-3.71,9.416) B15(-2.962,9.806) B16(-2.479,9.371) B18(-1.853,9.789) B19(-1.181,9.416) B20(-0.432,9.806) B21(0.051,9.371) B22(0.677,9.789) B24(1.349,9.416) B25(2.098,9.806) B26(2.581,9.371) B27(3.207,9.789) B28(3.879,9.416) B30(4.627,9.806) B31(5.11,9.371) B32(5.737,9.725) B33(6.409,9.416) B34(7.158,9.806) B35(7.641,9.371) B38(8.908,9.395) C3(-9.48,8.978) C6(-8.187,9.005) C8(-6.912,8.979) C11(-5.545,8.979) C13(-4.383,8.979) C15(-3.015,8.979) C18(-1.853,8.979) C20(-0.486,8.979) C22(0.677,8.979) C25(2.044,8.979) C27(3.207,8.979) C30(4.574,8.979) C32(5.737,8.979) C34(7.104,8.979) C37(8.246,9.115) C39(9.496,9.021) D4(-8.849,8.339) D6(-8.187,8.354) D7(-7.498,8.628) D8(-6.912,8.279) D11(-5.545,8.279) D12(-4.995,8.628) D13(-4.383,8.279) D15(-3.015,8.279) D16(-2.466,8.628) D18(-1.853,8.279) D20(-0.491,8.287) D21(0.064,8.628) D22(0.677,8.287) D25(2.044,8.279) D26(2.593,8.628) D27(3.207,8.279) D30(4.574,8.279) D31(5.123,8.628) D32(5.737,8.279) D34(7.104,8.279) D35(7.654,8.628) D37(8.283,8.462) E3(-9.815,7.752) E4(-9.129,7.752) E5(-8.452,7.752) E7(-7.498,7.978) E12(-4.968,7.978) E31(5.154,7.978) E35(7.684,7.978) E38(8.859,8.157) F37(8.482,7.567) F38(9.132,7.567) F40(9.87,7.626) G2(-10.289,7.255) G3(-9.479,7.19) G5(-8.779,7.19) G38(8.83,6.931) G39(9.479,6.999) G40(10.205,7.009) H2(-9.916,6.485) H40(9.916,6.327) J2(-10.289,5.826) J3(-9.479,5.826) J5(-8.779,5.826) J39(9.479,5.632) J40(10.306,5.579) K2(-9.87,5.208) K4(-9.128,5.212) K5(-8.478,5.182) L2(-10.306,4.58) L3(-9.479,4.574) L5(-8.779,4.574) L37(8.478,4.968) L38(9.128,4.995) L40(9.87,5.009) M37(8.779,4.383) M39(9.479,4.383) M40(10.212,4.383) N2(-9.916,3.823) N40(9.916,3.71) P2(-10.289,3.207) P3(-9.479,3.207) P5(-8.779,3.207) P37(8.779,3.015) P39(9.479,3.015) P40(10.306,2.962) R2(-9.87,2.581) R4(-9.128,2.593) R38(9.128,2.466) R40(9.87,2.479) T2(-10.306,2.098) T3(-9.479,2.044) T5(-8.779,2.044) U2(-9.916,1.349) U37(8.779,1.853) U39(9.479,1.853) U40(10.289,1.853) V40(9.916,1.181) W2(-10.289,0.677) W3(-9.479,0.677) W5(-8.787,0.677) W37(8.787,0.491) W39(9.479,0.486) W40(10.306,0.432) Y2(-9.87,0.051) Y4(-9.128,0.064) Y38(9.128,-0.064) Y40(9.87,-0.051)
  oval 0.343x0.254 smd: AB1(-10.814,-1.181) AC41(10.814,-1.349) AE1(-10.814,-2.54) AE41(10.814,-2.52) AG1(-10.814,-3.708) AG41(10.814,-3.879) AT9(-6.409,-8.319) AT14(-3.88,-8.319) AT18(-1.35,-8.319) AT23(1.18,-8.319) AT28(3.71,-8.319) AT33(6.24,-8.319) D9(-6.24,8.319) D14(-3.71,8.319) D19(-1.181,8.319) D24(1.349,8.319) D28(3.879,8.319) D33(6.409,8.319) N1(-10.814,3.879) N41(10.814,3.708) R1(-10.814,2.52) R41(10.814,2.54) U1(-10.814,1.349) V41(10.814,1.181) Y1(-10.814,-0.01) Y41(10.814,0.01)
