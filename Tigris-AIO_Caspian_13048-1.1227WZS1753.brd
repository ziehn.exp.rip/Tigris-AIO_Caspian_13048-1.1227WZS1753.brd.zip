# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAA7: length 73.5
  TOP w0.102: v4(52.83,91.22) 52.83,91.19 52.62,90.98 52.32,90.98 52.13,91.17 51.83,91.17 51.73,91.07 51.73,90.78 51.6,90.65 51.34,90.65 51.22,90.78 51.22,91.13 51.12,91.23 50.59,91.23 50.46,91.36 50.46,91.62 50.33,91.74 49.9,91.74 49.79,91.84 49.79,92.17 49.9,92.28 50.66,92.28 50.76,92.38 50.76,92.68 50.66,92.78 50.05,92.78 49.95,92.89 49.95,93.17 50.05,93.27 50.71,93.27 50.81,93.37 50.81,94.32 50.71,94.42 MEM1.R2 ; v4(74.51,89.16) 74.96,89.16 75.08,89.29 75.08,89.61 74.96,89.74 U13.K19 ; v4(53.59,88.73) 53.33,88.73 53.12,88.94 53.12,89.18 53.22,89.28 55.18,89.28 v1(55.5,88.96) 55.41,88.86 55.41,87.32 55.31,87.22 54.77,87.22 54.67,87.12 54.67,86.79 54.77,86.69 55.38,86.69 55.48,86.59 55.48,86.26 55.38,86.16 54.9,86.16 54.8,86.06 54.8,84.86 54.9,84.76 MEM2.R2
  L3 w0.127: v4(74.51,89.16) 74.85,89.16 75.05,89.35 75.05,89.53 74.66,89.91 74.48,89.91 74.32,89.75 73.51,89.75 73.43,89.67 70.87,89.67 70.54,90 70.03,90 69.9,89.87 69.9,89.54 69.77,89.42 69.52,89.42 69.39,89.54 69.39,89.87 69.26,90 65.65,90 65.52,89.87 64.21,89.87 64.03,90.05 63.4,90.05 63.22,90.23 62.81,90.23 62.64,90.05 60.58,90.05 60.35,90.28 60.02,90.28 59.79,90.05 59.47,90.05 58.71,90.81 57.64,90.81 57.53,90.93 57.18,90.93 56.93,90.68 56.93,90.26 56.81,90.13 56.31,90.13 55.96,90.48 54.33,90.48 54.2,90.36 54.2,90.1 54.42,89.89 v4(54.54,89.89)
  L4 w0.127: v4(53.59,88.73) 53.57,88.73 53.47,88.63 53.47,88.26 53.57,88.16 54.16,88.16 54.27,88.26 54.27,88.85 54.04,89.08 54.04,89.25 54.14,89.36 54.61,89.36 54.71,89.46 54.71,89.78 54.61,89.89 v4(54.54,89.89) 54.54,90.4 54.13,90.81 54.13,91.42 53.78,91.76 52.93,91.76 52.73,91.96 52.53,91.96 52.4,91.83 52.4,91.35 52.53,91.22 v4(52.83,91.22)
  BOTTOM w0.102: MEM3.R2 54.82,94.42 54.72,94.32 54.72,93.25 54.82,93.14 55.23,93.14 55.33,93.04 55.33,92.69 55.23,92.59 54.9,92.59 54.8,92.48 54.8,92.15 54.61,91.97 54.61,91.77 54.51,91.67 54.19,91.67 54.09,91.56 54.09,91.29 54.19,91.18 54.9,91.18 55,91.08 55,90.91 54.87,90.78 52.94,90.78 52.81,90.65 52.58,90.65 52.37,90.85 52.37,91.01 52.59,91.22 v4(52.83,91.22) ; v4(53.59,88.73) 53.76,88.73 53.96,88.94 53.96,89.19 53.87,89.28 53.66,89.28 53.51,89.43 53.4,89.43 53.4,89.43 53.15,89.43 53.05,89.33 53.05,88.93 52.94,88.83 52.68,88.83 52.55,88.7 52.55,88.26 52.42,88.14 51.88,88.14 51.78,88.03 51.78,87.88 51.39,87.49 51.23,87.49 51.1,87.62 50.95,87.62 50.76,87.42 50.76,87.28 51.02,87.01 51.02,86.77 50.62,86.36 50.62,85.78 50.69,85.7 50.69,85.49 50.76,85.43 50.76,85.31 50.65,85.21 50.05,85.21 49.95,85.11 49.95,84.86 50.05,84.76 MEM4.R2
MAA8: length 63
  TOP w0.102: U13.J14 74.19,86.14 74.32,86.27 74.32,86.62 74.19,86.75 v4(73.86,86.75) ; v4(53.05,88.4) 52.51,88.4 52.41,88.51 52.41,88.95 52.31,89.05 51.93,89.05 51.83,88.95 51.83,87.88 51.7,87.76 50.49,87.76 50.36,87.63 50.36,87.22 50.26,87.12 49.9,87.12 49.79,87.02 49.79,86.79 49.9,86.69 50.26,86.69 50.36,86.59 MEM2.T8 ; v4(53.64,91.31) 53.64,90.86 53.96,90.53 56.05,90.53 56.3,90.78 56.3,93.01 56.2,93.11 55.27,93.11 55.16,93.22 MEM1.T8
  L3 w0.127: v4(53.89,89.71) 53.87,89.71 53.75,89.59 53.75,89.17 53.96,88.96 54.51,88.96 54.64,89.09 54.64,89.39 55.04,89.79 55.04,89.97 55.29,90.21 55.83,90.21 55.96,90.09 55.96,88.81 56.08,88.68 58.43,88.68 59.95,87.16 62.49,87.16 63.17,87.16 63.17,87.16 63.26,87.16 63.57,87.46 63.98,87.46 64.11,87.33 64.11,86.72 64.24,86.6 64.49,86.6 64.62,86.72 64.62,87.73 64.88,87.99 66.74,87.99 66.77,87.97 68.91,87.97 69.16,87.72 69.39,87.72 69.65,87.97 69.88,87.97 70.1,87.74 70.1,86.82 70.48,86.45 71.52,86.45 71.6,86.37 72.47,86.37 72.65,86.19 73.94,86.19 74.07,86.32 74.07,86.62 73.94,86.75 v4(73.86,86.75)
  L4 w0.127: v4(53.05,88.4) 52.88,88.4 52.76,88.53 52.76,88.77 53.13,89.14 53.13,89.24 53.26,89.37 53.76,89.37 53.89,89.49 v4(53.89,89.71) 53.98,89.71 54.1,89.84 54.1,90.39 53.89,90.6 53.89,90.79 53.64,91.04 v4(53.64,91.31)
  BOTTOM w0.102: MEM4.T8 55.16,85.88 55.27,85.98 55.64,85.98 55.74,86.08 v2(55.74,88.47) 55.74,89 55.64,89.1 54.39,89.1 54.34,89.05 54.34,88.77 54.26,88.69 54.26,88.36 54.16,88.26 53.19,88.26 v4(53.05,88.4) ; MEM3.T8 50.36,93.96 50.49,94.09 50.75,94.09 50.88,93.96 50.88,93.8 50.83,93.76 50.83,93.48 51.03,93.29 51.03,92.9 50.84,92.71 50.35,92.71 50.25,92.61 50.25,92.26 50.35,92.16 51.04,92.16 51.13,92.25 51.13,92.38 51.23,92.48 51.55,92.48 51.65,92.38 51.65,92.18 51.75,92.08 52.2,92.08 52.62,91.65 53.51,91.65 53.64,91.52 v4(53.64,91.31)
MAA9: length 55.7
  TOP w0.102: U13.K14 74.65,86.14 74.54,86.03 v4(74.54,85.71) ; MEM1.R3 51.3,94.55 51.7,94.55 51.8,94.45 51.8,94.06 52,93.86 52.44,93.86 52.52,93.94 52.76,93.94 52.88,93.81 52.88,93.57 52.76,93.44 v4(52.68,93.44) ; v4(53.76,86.78) 53.76,87.04 53.86,87.15 54.14,87.15 54.24,87.04 54.24,85.93 53.97,85.66 53.97,85.29 54.08,85.19 54.26,85.19 54.36,85.09 MEM2.R3
  L3 w0.127: v4(74.54,85.71) 74.34,85.91 71.42,85.91 71.23,86.11 70.49,86.11 69.6,87 67.18,87 66.6,87.59 65.27,87.59 65.16,87.49 65.16,86.8 65.3,86.66 65.99,86.66 66.12,86.53 66.12,86.29 65.99,86.17 64.09,86.17 63.51,86.75 62.95,86.75 62.82,86.62 62.82,86.47 62.69,86.34 62.44,86.34 62.31,86.47 62.31,86.62 62.19,86.75 61.93,86.75 61.81,86.62 61.81,86.47 61.68,86.34 61.42,86.34 61.3,86.47 61.3,86.62 61.17,86.75 60.92,86.75 60.79,86.62 60.79,86.47 60.66,86.34 60.41,86.34 60.28,86.47 60.28,86.62 60.15,86.75 59.74,86.75 59.57,86.92 59.57,86.93 58.52,87.98 58.52,88.23 58.38,88.38 55.37,88.38 55.17,88.58 55.17,88.68 54.94,88.91 54.94,89.09 55.07,89.21 55.52,89.21 55.65,89.34 55.65,89.67 55.52,89.79 v4(55.46,89.79)
  L4 w0.127: v4(52.68,93.44) 52.1,93.44 51.97,93.32 51.97,93.11 52.1,92.98 52.94,92.98 53.13,92.79 53.13,92.39 53.3,92.23 53.96,92.23 54.32,91.87 54.33,91.87 54.76,91.43 54.76,91.08 54.87,90.97 55.14,90.97 55.27,90.85 55.27,90.57 55.66,90.18 55.66,90 v4(55.46,89.79) 55.29,89.79 55.19,89.69 55.19,89.23 55.29,89.13 55.56,89.13 55.66,89.02 55.66,88.75 55.56,88.64 55.23,88.64 55.13,88.54 55.13,88.34 55.3,88.17 55.3,88.03 54.69,87.42 54.55,87.42 54.32,87.65 54.18,87.65 54.01,87.47 54.01,87.33 54.21,87.12 54.21,86.94 54.06,86.78 v4(53.76,86.78)
  BOTTOM w0.102: MEM3.R3 54.41,94.42 54.52,94.31 54.52,94.08 54.41,93.96 54.14,93.96 54.01,93.84 54.01,93.55 53.91,93.44 53.74,93.44 53.55,93.63 53.25,93.63 53.06,93.44 v4(52.68,93.44) ; v2(56.24,90.03) 56,89.79 v4(55.46,89.79) ; v4(53.76,86.78) 53.7,86.84 52.6,86.84 52.44,86.99 52.11,86.99 51.87,86.75 51.87,85.92 51.55,85.6 51.55,85.4 51.32,85.18 51.31,85.18 51.16,85.03 MEM4.R3
MAA10: length 59.9
  TOP w0.102: v4(53.01,97.69) 53.18,97.86 54.09,97.86 54.33,97.62 MEM1.L7 ; U13.J11 74.15,84.34 v4(74.09,84.4) ; v4(51.9,80.78) 51.9,81.01 51.73,81.18 51.26,81.18 51.16,81.28 MEM2.L7
  L3 w0.127: v4(74.09,84.4) 74.09,84.54 73.96,84.67 72.58,84.67 72.56,84.68 71.45,84.68 71.32,84.81 70.65,84.81 69.14,86.32 66.9,86.32 66.75,86.17 66.75,85.43 66.67,85.35 63.61,85.35 63.26,85 60.6,85 59.69,85.91 59.35,85.91 58.77,86.49 58.77,86.8 58.19,87.37 57.92,87.37 v4(57.73,87.56)
  L4 w0.127: v4(51.9,80.78) 50.94,80.78 50.93,80.78 50.59,80.78 50.58,80.78 50.3,80.78 50.2,80.88 50.2,81.16 50.3,81.26 51.1,81.26 51.21,81.36 51.21,81.58 51.1,81.68 50.42,81.68 50.29,81.81 50.29,82.09 50.42,82.21 51.98,82.21 52.25,82.49 54.18,82.49 54.48,82.79 54.48,84.07 55.16,84.74 55.4,84.74 55.4,84.75 55.78,84.75 56.01,84.97 56.01,86.32 56.79,87.1 57.27,87.1 v4(57.73,87.56) 58.35,87.56 58.78,87.99 58.78,88.26 59.26,88.74 59.26,93.63 58.66,94.23 57.33,94.23 56.78,94.78 55.8,94.78 55.12,95.46 55.12,95.99 53.41,97.69 v4(53.01,97.69)
  BOTTOM w0.102: MEM3.L7 51.48,97.93 51.87,97.93 52.15,97.65 52.97,97.65 v4(53.01,97.69) ; v4(57.73,87.56) 57.73,87.59 57.81,87.66 v2(58.6,87.66) ; v4(51.9,80.78) 52.9,81.35 53.17,81.45 53.54,81.56 MEM4.L7
MAA11: length 54
  TOP w0.102: MEM1.R7 54.36,94.1 54.26,94 54.01,94 53.91,93.9 53.91,92.5 53.59,92.19 52.84,92.19 52.71,92.31 v4(52.71,92.56) ; v4(52.28,86.58) 51.83,86.58 51.73,86.48 51.73,86.03 51.83,85.93 52,85.93 52.11,85.82 52.11,85.48 52,85.38 51.6,85.38 51.5,85.28 51.5,84.87 51.39,84.76 MEM2.R7 ; U13.J13 73.9,84.94 73.72,85.12 v4(73.72,85.41)
  L3 w0.127: v4(54.69,88.51) 54.26,88.51 54,88.25 54,87.88 54.44,87.44 54.84,87.44 54.97,87.56 54.97,87.84 55.09,87.97 55.35,87.97 55.47,87.84 55.47,87.56 55.6,87.44 55.85,87.44 55.98,87.56 55.98,87.89 56.11,88.02 56.36,88.02 56.49,87.89 56.49,87.56 56.62,87.44 57.19,87.44 57.32,87.56 57.32,87.74 57.56,87.98 57.91,87.98 59.58,86.31 59.86,86.31 60.24,85.94 60.55,85.94 60.67,85.81 60.67,85.53 60.8,85.4 61.05,85.4 61.18,85.53 61.18,85.81 61.31,85.94 61.56,85.94 61.69,85.81 61.69,85.53 61.82,85.4 62.07,85.4 62.2,85.53 62.2,85.81 62.32,85.94 62.58,85.94 62.71,85.81 62.71,85.53 62.83,85.4 63.09,85.4 63.21,85.53 63.21,86.01 63.34,86.14 63.54,86.14 63.93,85.76 66.27,85.76 66.52,86.01 66.52,86.5 66.65,86.62 69.49,86.62 71.07,85.05 72.01,85.05 72.06,85.01 72.56,85.01 72.67,84.9 73.59,84.9 73.72,85.02 v4(73.72,85.41)
  L4 w0.127: v4(52.28,86.58) 52.28,86.84 52.38,86.94 52.82,86.94 52.92,86.84 52.92,86.31 53.02,86.21 53.23,86.21 53.34,86.31 53.34,86.96 53.54,87.17 53.54,87.78 53.65,87.88 54.57,87.88 54.69,88.01 v4(54.69,88.51) 54.96,88.78 54.96,90.41 54.48,90.89 54.48,91.38 53.88,91.99 53.06,91.99 52.71,92.33 v4(52.71,92.56)
  BOTTOM w0.102: v4(52.28,86.58) 53.15,86.58 53.43,86.3 53.72,86.3 53.99,86.03 53.99,85.13 MEM4.R7 ; MEM3.R7 51.32,94.42 51.54,94.2 51.54,93.36 51.39,93.22 51.39,93.08 51.65,92.82 51.8,92.82 52,93.02 52.16,93.02 52.62,92.56 v4(52.71,92.56)
MAA12: length 55
  TOP w0.102: U13.H11 73.3,83.74 v4(72.81,83.24) ; MEM2.N7 51.69,83.16 52.04,83.51 52.67,83.51 53.04,83.13 v4(53.1,83.13) ; MEM1.N7 54.09,96.02 54.09,96.01 53.68,96.01 53.57,96.13 53.23,96.13 52.95,95.85 52.3,95.85 v4(52.07,96.08)
  L3 w0.127: v4(49.61,88.83) 49.61,88.44 51.05,87.01 53.39,87.01 53.58,87.2 54.03,87.2 54.48,86.75 57.3,86.75 57.83,86.22 58.01,86.22 58.27,85.96 58.27,85.79 58.96,85.09 59.1,85.09 60.01,84.18 63.63,84.18 63.98,84.54 67.02,84.54 67.15,84.67 67.15,84.72 67.5,85.06 68,85.06 68.14,84.92 69.24,84.92 70.48,83.68 71.83,83.68 72.26,83.24 v4(72.81,83.24)
  L4 w0.127: v4(53.1,83.13) 53.09,83.13 52.67,83.55 51.56,83.55 51.2,83.91 51.2,84.11 51.43,84.34 51.43,84.49 51.02,84.91 50.87,84.91 50.61,84.64 50.47,84.64 50.05,85.06 50.05,85.52 50.38,85.85 50.38,86.34 49.42,87.3 49.42,88.64 v4(49.61,88.83) 49.61,89.36 49.2,89.77 49.2,93.4 49.81,94.01 49.81,94.42 51.47,96.08 v4(52.07,96.08)
  BOTTOM w0.102: v4(53.1,83.13) 53.1,83.12 53.34,82.88 54.09,82.88 MEM4.N7 ; MEM3.N7 51.16,96.33 51.65,96.81 52.04,96.81 52.34,96.52 52.34,96.35 v4(52.07,96.08) ; v4(49.61,88.83) 49.76,88.98 v2(49.76,89.61)
MAA13: length 58.5
  TOP w0.102: MEM2.T3 54.55,85.75 54.55,86.46 54.46,86.55 54.46,87.72 54.24,87.94 52.61,87.94 52.48,87.81 v4(52.48,87.43) ; v4(52.08,92.5) 52.08,92.31 51.95,92.18 51.14,92.18 51.04,92.28 51.04,92.94 51.14,93.04 51.93,93.04 52.03,93.14 52.03,93.55 51.6,93.98 51.27,93.98 51.16,93.88 MEM1.T3 ; U13.G20 72.27,91.22 v4(72.27,91.42)
  L3 w0.127: v4(52.09,90.52) 51.44,89.87 50.75,89.87 50.6,89.72 50.6,89.49 51.54,88.55 52.48,88.55 52.58,88.66 52.58,88.97 52.48,89.07 52.19,89.07 52.01,89.24 52.01,89.7 52.28,89.96 52.36,89.96 52.59,90.19 52.59,90.66 52.71,90.79 53.08,90.79 53.17,90.88 53.8,90.88 54.02,91.1 56.42,91.1 56.88,91.56 61.94,91.56 62.15,91.78 67.77,91.78 67.86,91.69 68.58,91.69 68.6,91.7 71.57,91.7 71.85,91.42 v4(72.27,91.42)
  L4 w0.127: v4(52.48,87.43) 51.94,86.89 51.79,86.89 51.36,87.32 51.36,87.5 51.47,87.61 51.74,87.61 51.87,87.74 51.87,89.86 52,89.98 52.46,89.98 52.56,90.09 52.56,90.42 52.46,90.52 v4(52.09,90.52) 51.69,90.52 51.49,90.72 51.49,91.91 51.27,92.13 51.27,93.32 51.37,93.42 51.62,93.42 51.73,93.32 51.73,92.6 51.83,92.5 v4(52.08,92.5)
  BOTTOM w0.102: v2(51.62,89.76) 51.62,90.05 v4(52.09,90.52) ; v4(52.08,92.5) 52.44,92.14 53.48,92.14 53.58,92.04 53.58,91.9 53.68,91.79 53.97,91.79 54.07,91.9 54.07,92.1 54.17,92.2 54.43,92.2 54.54,92.3 54.54,92.61 54.43,92.71 53.91,92.71 53.81,92.81 53.81,93.12 53.91,93.22 54.29,93.22 54.36,93.29 MEM3.T3 ; v4(52.48,87.43) 52.28,87.63 52.07,87.63 51.6,87.16 51.6,86.45 51.47,86.32 51.12,86.32 51,86.2 51,85.73 MEM4.T3
MAA_BA0: length 64.7
  TOP w0.102: v4(52.47,83.05) 52.81,82.71 53.28,82.71 53.28,82.71 54.82,82.71 MEM2.M2 ; U13.J16 74.15,87.25 v4(74.74,86.66) ; v1(57.52,88.82) 57.52,89.05 v4(57.99,89.52) ; MEM1.M2 50.48,96.94 50.71,96.94 50.83,96.81 50.83,96.68 51.03,96.49 51.03,96.49 51.12,96.47 51.27,96.47 51.74,96.72 53.04,96.72 53.08,96.68 53.52,96.68 53.62,96.78 53.82,96.78 53.95,96.66 v4(53.95,96.45)
  L3 w0.127: v4(74.74,86.66) 74.78,86.66 74.89,86.77 74.89,87.07 74.52,87.44 72.87,87.44 72.6,87.71 72.6,88.12 72.4,88.33 71.65,88.33 71.53,88.2 71.53,87.77 71.61,87.69 71.61,87.34 71.35,87.08 70.84,87.08 70.71,87.21 70.71,88.27 70.46,88.53 68.5,88.53 68.38,88.66 68.38,88.69 68.25,88.82 65.67,88.82 65.43,89.06 64.29,89.06 64.16,88.93 64.16,88.5 64.03,88.38 63.08,88.38 62.96,88.25 62.96,88.1 62.83,87.97 62.58,87.97 62.45,88.1 62.45,88.25 62.32,88.38 62.07,88.38 61.94,88.25 61.94,88.1 61.81,87.97 61.56,87.97 61.43,88.1 61.43,88.25 61.31,88.38 61.05,88.38 60.93,88.25 60.93,88.1 60.8,87.97 60.54,87.97 60.42,88.1 60.42,88.25 60.29,88.38 59.88,88.38 59.1,89.16 58.99,89.16 58.63,89.52 v4(57.99,89.52)
  L4 w0.127: v4(52.47,83.05) 52.81,82.72 53.73,82.72 54.16,83.15 54.16,84.08 55.13,85.04 55.13,85.08 55.13,85.09 55.13,85.35 55.38,85.59 55.55,85.59 55.68,85.72 55.68,86.48 56.56,87.36 57.05,87.36 57.18,87.49 57.18,87.86 57.3,87.98 57.91,87.98 58.09,87.8 58.27,87.8 58.55,88.09 58.55,88.27 58.39,88.43 57.94,88.43 57.81,88.55 57.81,88.81 57.94,88.93 58.39,88.93 58.52,89.06 58.52,89.39 58.39,89.52 v4(57.99,89.52) 57.99,89.94 58.12,90.07 58.32,90.07 58.45,90.19 58.45,90.45 58.32,90.57 58.12,90.57 57.99,90.7 57.99,90.95 58.12,91.08 58.32,91.08 58.45,91.21 58.45,91.46 58.32,91.59 58.12,91.59 57.99,91.72 57.99,91.97 58.12,92.1 58.32,92.1 58.45,92.22 58.45,92.48 58.32,92.61 58.12,92.61 57.99,92.73 57.99,93.01 57.9,93.1 57.9,93.28 58.14,93.53 58.14,93.71 57.96,93.89 57.78,93.89 57.54,93.64 57.36,93.64 56.53,94.47 55.7,94.47 54.64,95.54 54.64,95.71 53.95,96.4 v4(53.95,96.45)
  BOTTOM w0.102: MEM3.M2 55.51,96.82 55.63,96.95 55.63,96.96 55.83,97.15 55.83,97.29 55.65,97.47 55.48,97.47 55.3,97.29 54.85,97.29 54.71,97.15 54.71,96.5 54.59,96.37 54.03,96.37 v4(53.95,96.45) ; v4(52.47,83.05) 52.47,83.22 52.34,83.35 51.82,83.35 51.28,82.81 51.03,82.81 50.9,82.94 50.62,82.94 50.49,82.81 50.14,82.81 50.01,82.68 50.01,82.49 50.14,82.36 MEM4.M2
MAA_BA1: length 58.5
  TOP w0.102: v4(53.17,84.02) 53.12,84.02 52.73,84.41 52.27,84.41 51.45,83.59 50.79,83.59 MEM2.N8 ; v4(75.51,86.02) 75.51,85.96 75.6,85.87 76.05,85.87 76.15,85.97 76.15,86 76.15,86 76.15,86.38 76.15,86.38 76.15,86.44 76.05,86.54 U13.L15 ; MEM1.N8 55.03,96.15 54.81,96.15 54.71,96.05 54.71,95.67 54.6,95.55 54.23,95.55 54.14,95.46 53.54,95.46 53.42,95.59 v4(53.42,95.68)
  L3 w0.127: v4(75.51,86.02) 75.34,86.19 74.5,86.19 74.32,86.37 74.32,87 74.14,87.18 72.49,87.18 72.36,87.31 72.36,87.89 72.24,88.02 71.98,88.02 71.86,87.89 71.86,87.03 71.6,86.78 70.48,86.78 70.36,86.9 70.36,87.99 70.13,88.22 68.15,88.22 67.97,88.4 65.48,88.4 65.23,88.66 64.89,88.66 64.37,88.14 64.37,88.06 64.19,87.88 63.96,87.88 63.87,87.97 63.41,87.97 63.27,87.84 63.27,87.74 63.09,87.56 63,87.56 63,87.56 62.66,87.56 62.66,87.56 60.12,87.56 58.93,88.76 58.82,88.76 58.57,89.01 57.76,89.01 57.56,89.21 57.2,89.21 57,89.01 56.39,89.01 56.26,89.14 56.26,89.7 56.39,89.82 56.87,89.82 v4(56.97,89.73)
  L4 w0.127: v4(53.42,95.68) 53.79,95.68 54.84,94.62 54.84,93.86 55.33,93.37 56.58,93.37 57,92.95 57,92.77 56.87,92.64 56.72,92.64 56.59,92.52 56.59,92.25 56.71,92.14 56.9,92.14 57,92.03 57,91.71 56.94,91.65 56.94,90.69 56.93,90.68 56.93,90.34 56.94,90.33 56.94,89.76 v4(56.97,89.73) 56.69,89.46 56.69,88.99 56.9,88.78 56.9,88.48 54.78,86.36 54.6,86.36 54.43,86.19 54.43,85.8 54.51,85.72 54.51,85.23 53.98,84.7 53.83,84.7 53.64,84.51 53.64,84.33 53.33,84.02 v4(53.17,84.02)
  BOTTOM w0.102: v2(57.24,88.67) 57.23,88.67 56.9,89 56.9,89.66 v4(56.97,89.73) ; MEM4.N8 55.26,83.16 55.37,83.27 55.37,83.5 55.25,83.62 55.04,83.62 54.94,83.72 54.73,83.72 54.51,83.49 54.14,83.49 54.01,83.62 54.01,83.79 53.49,84.32 53.29,84.32 53.17,84.2 v4(53.17,84.02) ; v4(53.42,95.68) 53.16,95.68 53.13,95.7 52.71,95.7 52.62,95.62 50.77,95.62 MEM3.N8
MAA_BA2: length 55.9
  TOP w0.102: U13.G11 72.55,83.75 v4(73.02,84.22) ; v4(52.07,97.23) 52.07,97.09 51.93,96.94 51.28,96.94 MEM1.M3 ; MEM2.M3 52.31,82.36 v4(51.9,82.77) ; v1(49.58,90.48) v4(48.74,90.48)
  L3 w0.127: v4(48.74,90.48) 49.07,90.48 51.58,87.97 53.24,87.97 53.78,87.43 54.13,87.43 54.43,87.13 57.56,87.13 59.19,85.5 59.53,85.5 60.44,84.59 63.42,84.59 63.78,84.95 66.95,84.95 67.34,85.33 69.6,85.33 70.97,83.96 71.88,83.96 72,83.83 72.62,83.83 v4(73.02,84.22)
  L4 w0.127: v4(52.07,97.23) 52.07,97.24 50.54,97.24 49.51,96.21 49.51,94.62 49.2,94.3 48.91,94.3 48.67,94.06 48.67,93.71 48.74,93.63 v4(48.74,90.48) 48.74,88.9 49.08,88.57 49.08,85.41 51.72,82.77 v4(51.9,82.77)
  BOTTOM w0.102: v4(52.07,97.23) 52.92,96.78 53.11,96.68 53.15,96.66 53.27,96.66 53.35,96.67 53.6,96.77 53.77,96.84 53.84,96.86 53.97,96.87 MEM3.M3 ; MEM4.M3 51.23,82.3 52.18,82.3 52.31,82.42 52.31,82.61 52.15,82.77 v4(51.9,82.77)
MB_REG_PG: length 23.2
  TOP w0.203: U24.109 52.07,35.6 52.86,34.81 52.86,33.77
  TOP w0.508: R566.2 53.19,33.38 v3(52.83,33.74) 52.86,33.77
  L4 w0.508: v3(48.31,32.42) 48.39,32.5 51.31,32.5 52.4,33.59 52.68,33.59 v3(52.83,33.74)
  BOTTOM w0.381: v3(48.31,32.42) 48.44,32.55 48.44,34.17 48.19,34.42 Q111.6 47.57,35.21 47.07,35.72 46.43,35.72 46.02,36.13 Q109.3 47.3,36.42 v2(47.55,36.66) 47.76,36.88 47.76,38.2 46.37,39.59 Q106.6 45.85,39.59 44.15,37.89 Q109.6
MB_REG_PG_1: length 4.5
  BOTTOM w0.254: Q111.2 50.29,33.77 50.67,33.38 R1075.1 50.99,33.19 51.31,32.88 R1082.2 50.8,32.36 50.34,31.9 v2(50.34,31.43)
MB_REG_PG_2: length 4.6
  BOTTOM w0.254: Q109.5 43.56,37.07 42.8,37.83 v2(42.8,38.21) 42.8,38.46 42.33,38.93 R1049.2 42.33,39.73 R1042.1
MB_REG_PG_3: length 6.2
  BOTTOM w0.254: Q109.2 45.52,37.07 45.09,36.64 45.09,36.29 44.64,35.85 43.02,35.85 v2(42.87,36) 42.49,36.37 R1057.2 41.43,36.37 41.25,36.19 R1058.1
MB_SKU_ID0: length 24.1
  TOP w0.102: U29.N32 131.21,81.05 v4(131.18,81.07)
  L4 w0.127: v4(126.89,89.81) 126.89,91.46 125.19,93.16 v3(125.19,97.15)
  BOTTOM w0.102: v4(131.18,81.07) 130.45,81.81 130.45,83.53 130.07,83.91 130.07,85.48 v2(130.3,85.71) 129.83,86.18 129.83,87.64 129.21,88.26 129.12,88.26 127.57,89.81 v4(126.89,89.81) ; R318.1 125.46,100.61 125.88,100.19 125.88,99.34 R322.2 124.99,98.45 124.99,97.34 v3(125.19,97.15)
MB_SKU_ID1: length 22.1
  TOP w0.102: v1(114.86,95.31) R233.1 R234.2 117.7,94.7 119.56,94.7 120.22,94.04 123.93,94.04 125.6,92.37 125.6,91.96 128.73,88.83 128.73,88.48 129.66,87.54 130.79,87.54 131.31,87.02 131.31,85.39 131.24,85.32 U29.M40
MB_SKU_ID2: length 12.5
  TOP w0.102: U29.AV34 145.61,81.96 145.69,81.89 147.43,81.89 148.05,82.51 149.53,82.51 150.06,81.98 153.34,81.98 154.27,82.9 v1(154.56,82.9) R871.1 155.99,82.84 R872.2
MCLK: length 4.6
  TOP w0.102: U24.115 54.47,35.61 54.94,35.14 55.47,35.14 55.81,34.8 55.81,34.26 56.36,33.72 RN5.2
MDA0: length 39.2
  TOP w0.127: U13.K27 74.95,96.54 74.93,96.56 74.93,96.68 74.61,97 v3(74.61,100.29)
  L3 w0.165: v3(74.61,100.29) 74.61,101.68 68.45,107.83 52.08,107.83 51.3,107.05 51.3,103.98 51.61,103.67 51.61,103.25 51.96,102.89 v4(51.96,102.78)
  BOTTOM w0.127: v3(74.61,100.29) 74.61,100.89 v2(74.8,101.08) ; v4(51.96,102.78) 51.96,102.7 51.34,102.08 51,102.08 50.54,101.62 MEM3.F8
MDA1: length 38.6
  TOP w0.127: U13.J29 74.15,97.69 73.73,98.11 73.73,99.43 v3(73.98,99.68) 74.09,99.79 74.09,101.08 v1(74.17,101.15)
  L3 w0.165: v4(52.72,103.31) 52.48,103.55 52.48,103.61 52.02,104.07 52.02,105.83 52.58,106.38 52.58,107.02 52.77,107.21 53.55,107.21 53.71,107.05 53.71,106.8 53.88,106.64 54.21,106.64 54.37,106.8 54.37,107.05 54.69,107.36 66.53,107.36 66.84,107.05 66.84,106.59 66.97,106.46 67.38,106.46 67.5,106.59 67.5,107.05 67.67,107.21 68.44,107.21 74.08,101.57 74.08,99.77 v3(73.98,99.68)
  BOTTOM w0.127: v4(52.72,103.31) 52.72,102.85 51.49,101.62 MEM3.F7
MDA2: length 38.1
  TOP w0.127: v4(70.72,100.98) 70.69,101.01 70.69,101.51 70.82,101.63 73.08,101.63 73.2,101.51 73.2,101.14 73.08,101.01 71.48,101.01 71.35,100.89 71.35,100.63 71.6,100.38 71.6,99.86 71.73,99.73 71.96,99.73 72.09,99.86 72.09,100.26 72.33,100.51 73,100.51 73.1,100.4 73.1,100.13 73.1,100.13 73.1,100.09 73.13,100.06 73.13,99.14 73.01,99.03 73.01,98.28 U13.H30
  L3 w0.165: v4(70.72,100.98) 70.63,101.07 66.12,101.07 65.71,100.67 65.27,100.67 65.11,100.83 65.11,101.52 64.94,101.69 64.61,101.69 64.45,101.52 64.45,100.83 64.28,100.67 63.95,100.67 63.78,100.83 63.78,101.52 63.62,101.69 63.29,101.69 63.12,101.52 63.12,100.83 62.96,100.67 62.63,100.67 62.46,100.83 62.46,101.52 62.3,101.69 61.97,101.69 61.8,101.52 61.8,100.83 61.64,100.67 61.31,100.67 61.14,100.83 61.14,101.52 60.98,101.69 60.65,101.69 60.48,101.52 60.48,100.83 60.32,100.67 59.99,100.67 59.82,100.83 59.82,101.52 59.66,101.69 59.33,101.69 59.16,101.52 59.16,100.83 59,100.67 58.32,100.67 58.23,100.58 57.2,100.58 56.81,100.19 56.13,100.19 56.01,100.31 56.01,100.63 55.88,100.76 55.51,100.76 55.39,100.63 54.9,100.63 54.77,100.51 v4(54.77,100.42)
  BOTTOM w0.127: v2(70,101.36) 70.34,101.36 v4(70.72,100.98) ; v4(54.77,100.42) 54.37,100.02 MEM3.H3
MDA3: length 37.6
  TOP w0.127: v3(73.54,100.31) 73.51,100.31 73.38,100.19 73.38,98.77 U13.H32
  L3 w0.165: v4(52.78,103.94) 52.78,104 52.91,104.12 53.72,104.12 53.85,104 53.85,103.26 54.2,102.9 54.61,102.9 54.74,103.03 54.74,104.28 54.14,104.87 53.53,104.87 53.26,105.14 52.73,105.14 52.6,105.27 52.6,105.65 52.73,105.77 53.01,105.77 53.35,106.11 55,106.11 55.78,106.89 66,106.89 66.81,106.08 68.94,106.08 73.54,101.47 v3(73.54,100.31)
  BOTTOM w0.127: v2(73.31,101.09) 73.54,100.86 v3(73.54,100.31) ; MEM3.E3 54.36,102.61 53.79,103.19 53.79,103.98 53.67,104.1 52.91,104.1 52.78,103.97 v4(52.78,103.94)
MDA4: length 37.8
  TOP w0.127: U13.G29 72.67,97.42 72.67,97.06 72.52,96.91 v4(72.29,96.91) ; v1(58.18,100.84) 57.48,100.84 v4(57.29,101.03)
  L3 w0.165: v4(57.29,101.03) 58.07,101.03 59.11,102.07 60.89,102.07 61.05,102.23 61.05,102.36 61.22,102.52 61.55,102.52 61.71,102.36 61.71,102.23 61.88,102.07 62.21,102.07 62.37,102.23 62.37,102.36 62.54,102.52 62.87,102.52 63.03,102.36 63.03,102.23 63.2,102.07 63.53,102.07 63.69,102.23 63.69,102.36 63.86,102.52 64.19,102.52 64.35,102.36 64.35,102.23 64.52,102.07 65.1,102.07 65.66,101.51 65.94,101.51 66.17,101.74 66.17,104.05 66.29,104.17 66.7,104.17 66.83,104.05 66.83,101.81 66.95,101.68 67.67,101.68 67.79,101.81 67.79,104.05 67.92,104.17 68.49,104.17 68.88,103.78 68.88,103.55 68.5,103.16 68.5,102.65 68.63,102.52 68.8,102.52 69.01,102.32 69.01,101.81 69.14,101.68 70.89,101.68 71.24,101.34 71.24,101.25 71.37,101.12 71.37,98.33 71.93,97.77 72.52,97.77 72.72,97.57 72.72,97.34 v4(72.29,96.91)
  BOTTOM w0.127: v4(57.29,101.03) 57.61,101.03 57.73,100.9 57.73,100.57 57.61,100.44 57.12,100.44 57,100.31 57,100.03 56.87,99.91 56.54,99.91 56.41,100.03 56.41,100.27 56.29,100.4 55.59,100.4 MEM3.G2
MDA5: length 37.5
  TOP w0.127: v4(72.64,99.81) 72.13,99.29 72.13,98.8 72.21,98.72 72.21,97.6 U13.F28
  L3 w0.165: v4(72.64,99.81) 72.64,101.83 68.78,105.69 65,105.69 64.83,105.53 64.83,105.2 64.67,105.04 64.33,105.04 64.17,105.2 64.17,105.53 64,105.69 63.67,105.69 63.51,105.53 63.51,104.61 63.39,104.49 62.98,104.49 62.85,104.61 62.85,105.53 62.68,105.69 62.35,105.69 62.19,105.53 62.19,104.61 62.07,104.49 61.74,104.49 61.65,104.49 61.53,104.61 61.53,105.53 61.36,105.69 61.03,105.69 60.87,105.53 60.87,104.02 60.72,103.88 60.3,103.88 60.21,103.97 60.21,105.53 60.04,105.69 57.3,105.69 57.15,105.55 57.15,105.21 57.65,104.71 57.65,102.91 57.31,102.58 v4(57.31,102.47)
  BOTTOM w0.127: v2(73.29,99.25) 73.2,99.25 v4(72.64,99.81) ; v4(57.31,102.47) 56.84,102 55.55,102 MEM3.F2
MDA6: length 36.8
  TOP w0.127: v4(70.78,100.23) 71.75,99.26 U13.F32
  L3 w0.165: v4(70.78,100.23) 70.78,98.61 70.65,98.49 70.19,98.49 70.03,98.32 70.03,97.99 70.19,97.82 70.65,97.82 70.78,97.7 70.78,97.42 70.65,97.29 69.55,97.29 69.42,97.42 69.42,98.38 69.29,98.51 66.34,98.51 66.22,98.38 66.22,97.8 66.09,97.67 65.09,97.67 64.93,97.84 64.93,98.23 64.8,98.36 64.4,98.36 64.27,98.23 64.27,97.84 64.1,97.67 63.77,97.67 63.61,97.84 63.61,98.23 63.48,98.36 63.08,98.36 62.95,98.23 62.95,97.84 62.78,97.67 62.45,97.67 62.29,97.84 62.29,98.26 62.16,98.38 61.75,98.38 61.63,98.26 61.63,97.84 61.46,97.67 61.13,97.67 60.97,97.84 60.97,98.21 60.84,98.33 60.43,98.33 60.31,98.21 60.31,97.84 60.14,97.67 59.81,97.67 59.65,97.84 59.65,98.35 59.48,98.51 58.5,98.51 58.32,98.33 57.15,98.33 57.02,98.46 57.02,98.79 56.85,98.96 56.35,98.96 56.11,98.73 55.29,98.73 54.94,98.38 54.58,98.38 54.33,98.64 54.33,99.3 53.48,100.14 53.48,100.25 53.03,100.69 52.43,100.69 52.4,100.72 52.04,100.72 51.99,100.67 51.3,100.67 50.76,100.12 v4(50.76,99.61)
  BOTTOM w0.127: MEM3.H8 50.76,99.63 v4(50.76,99.61) ; v4(70.78,100.23) 70.78,99.51 v2(70.69,99.42)
MDA7: length 37.4
  TOP w0.127: v1(69.98,101.46) 69.98,100.69 v4(70.1,100.57) 70.1,100.31 71.34,99.07 71.34,98.35 U13.F30
  L3 w0.165: v4(70.1,100.57) 70.1,100.62 69.98,100.75 68.76,100.75 68.63,100.62 68.63,100.26 68.5,100.14 68.1,100.14 67.97,100.26 67.97,100.57 67.84,100.69 67.44,100.69 67.21,100.47 66.85,100.47 66.63,100.69 66.32,100.69 66.01,100.39 66.01,99.45 65.74,99.17 65.26,99.17 65.09,99.34 65.09,100.14 64.97,100.26 64.56,100.26 64.43,100.14 64.43,99.34 64.27,99.17 63.94,99.17 63.77,99.34 63.77,100.16 63.65,100.29 63.24,100.29 63.11,100.16 63.11,99.34 62.95,99.17 62.62,99.17 62.45,99.34 62.45,100.16 62.32,100.29 61.92,100.29 61.79,100.16 61.79,99.34 61.63,99.17 61.3,99.17 61.13,99.34 61.13,100.16 61,100.29 60.6,100.29 60.47,100.16 60.47,99.34 60.31,99.17 60.07,99.17 59.31,99.93 58.09,99.93 57.6,99.44 57.23,99.44 56.85,99.83 55.97,99.83 55.74,100.06 55.38,100.06 55.31,99.99 54.56,99.99 54.28,100.27 54.28,100.54 54.08,100.75 53.8,100.75 53.16,101.39 52.71,101.39 v4(52.68,101.42)
  BOTTOM w0.127: v4(52.68,101.42) 52.71,101.38 53.29,101.38 53.42,101.25 53.42,100.62 53.29,100.49 52.93,100.49 52.68,100.75 52.05,100.75 51.97,100.67 51.79,100.67 51.58,100.46 51.28,100.46 51.16,100.34 MEM3.H7
MDA8: length 34.6
  TOP w0.127: v4(66.55,99.78) 66.63,99.7 68.17,99.7 68.86,99.01 68.86,98.71 69.2,98.37 69.72,98.37 U13.C30
  BOTTOM w0.127: MEM3.D7 50.98,103.22 50.55,103.65 49.17,103.65 48.57,104.25 48.57,106.55 51.51,109.5 59.4,109.5 65.87,103.02 v2(65.87,102.5) 66.18,102.19 66.18,101.96 66.55,101.59 v4(66.55,99.78)
MDA9: length 36.4
  TOP w0.127: U13.F27 71.72,96.34 v4(71.35,96.71)
  BOTTOM w0.127: MEM3.C8 50.07,104.02 49.95,104.15 49.95,105.48 49.91,105.52 49.91,105.76 49.71,105.96 49.47,105.96 49.15,106.28 49.15,106.64 51.64,109.13 59.24,109.13 59.48,108.89 59.48,108.71 59.22,108.45 59.22,108.27 59.4,108.09 59.58,108.09 59.84,108.35 60.02,108.35 60.2,108.17 60.2,107.99 60.04,107.83 60.04,107.65 60.22,107.47 60.4,107.47 60.56,107.63 60.74,107.63 60.92,107.45 60.92,107.27 60.75,107.1 60.75,106.92 60.93,106.74 61.11,106.74 61.28,106.91 61.46,106.91 65.27,103.1 65.27,102.13 65.77,101.63 v2(65.77,101.23) 65.77,99.84 66.24,99.36 66.74,99.36 66.92,99.54 68.52,99.54 v4(71.35,96.71)
MDA10: length 35.2
  TOP w0.127: U13.A28 69.23,97.02 68.74,97.02 68.02,97.74 68.02,98.25 67.36,98.91 67.36,99.07 v4(67.36,99.07)
  BOTTOM w0.127: MEM3.B8 50.36,105.11 50.74,105.49 50.74,106.59 50.42,106.91 50.42,107.23 51.85,108.66 58.28,108.66 61.32,105.62 61.49,105.62 61.68,105.81 61.86,105.81 62.04,105.63 62.04,105.45 61.85,105.26 61.85,105.08 62.03,104.9 62.21,104.9 62.4,105.09 62.58,105.09 62.76,104.91 62.76,104.73 62.57,104.54 62.57,104.37 62.75,104.19 62.93,104.19 63.22,104.48 63.4,104.48 63.58,104.3 63.58,104.12 63.29,103.83 63.29,103.65 63.47,103.47 63.65,103.47 63.94,103.76 64.12,103.76 64.3,103.58 64.3,103.4 64.01,103.11 64.01,102.93 64.25,102.68 64.25,102.48 63.7,101.92 63.7,101.74 63.88,101.56 64.05,101.56 64.61,102.12 64.79,102.12 65.15,101.76 65.15,101.42 65.03,101.29 64.59,101.29 64.47,101.16 64.47,100.91 64.59,100.78 65.03,100.78 65.15,100.66 v2(65.15,100.12) 65.15,99.73 65.86,99.02 67.31,99.02 v4(67.36,99.07)
MDA11: length 35
  TOP w0.127: v4(67.6,98.02) 67.6,97.89 67.61,97.88 67.61,97.52 68.45,96.68 69.21,96.68 69.21,96.68 69.49,96.68 69.49,96.68 70.02,96.68 70.15,96.81 U13.C28
  BOTTOM w0.127: v4(67.6,98.02) 67.89,98.02 68.1,98.23 68.1,98.53 67.97,98.66 67.54,98.66 65.04,98.66 64.78,98.92 64.78,99.1 64.96,99.29 64.96,99.44 64.75,99.65 64.6,99.65 64.42,99.46 64.24,99.46 64.06,99.64 64.06,99.82 64.44,100.21 64.44,100.39 64.26,100.57 64.08,100.57 63.7,100.18 63.52,100.18 63.34,100.36 63.34,100.54 63.76,100.97 63.76,101.15 63.58,101.32 63.4,101.32 62.98,100.9 62.8,100.9 v2(62.34,101.36) 62.34,101.99 62.47,102.11 63.22,102.11 63.35,102.24 63.35,102.5 63.22,102.62 62.47,102.62 62.34,102.75 62.34,103 62.47,103.13 62.56,103.13 62.69,103.26 62.69,103.51 62.56,103.64 62.47,103.64 62.34,103.77 62.34,104.11 58.2,108.25 52.03,108.25 51.03,107.26 51.03,105.75 MEM3.A7
MDA12: length 36
  TOP w0.102: v4(67,95.95) 67.96,95.95 67.97,95.93 68.86,95.93 68.93,95.87 69.07,95.87 69.14,95.84 69.23,95.81 69.37,95.81 69.45,95.81 69.58,95.85 69.61,95.87 70.48,95.87 U13.E27
  BOTTOM w0.127: MEM3.A3 55.42,106.67 57.24,106.67 57.61,106.31 57.61,106.13 57.37,105.89 57.37,105.71 57.55,105.53 57.73,105.53 57.97,105.77 58.14,105.77 58.32,105.59 58.32,105.41 58.09,105.17 58.09,104.99 58.27,104.81 58.44,104.81 58.68,105.05 58.86,105.05 59.04,104.87 59.04,104.69 58.8,104.45 58.8,104.27 58.98,104.09 59.16,104.09 59.4,104.33 59.58,104.33 59.95,103.96 59.95,100.07 60.15,99.88 60.15,97.21 v2(60.88,96.48) 60.88,96.38 61.01,96.25 62.48,96.25 62.61,96.12 62.61,95.56 62.74,95.44 62.99,95.44 63.12,95.56 63.12,96.12 63.24,96.25 63.5,96.25 63.62,96.12 63.62,95.56 63.75,95.44 64.01,95.44 64.13,95.56 64.13,96.12 64.26,96.25 64.51,96.25 64.64,96.12 64.64,95.56 64.77,95.44 65.02,95.44 65.15,95.56 65.15,96.12 65.28,96.25 65.53,96.25 65.66,96.12 65.66,95.56 65.78,95.44 66.04,95.44 66.16,95.56 66.16,96.4 66.52,96.76 66.9,96.76 67.26,97.11 67.44,97.11 67.71,96.84 67.71,96.66 v4(67,95.95)
MDA13: length 36.2
  TOP w0.127: v4(72.94,95.94) 72.94,95.92 72.57,95.54 U13.G26
  BOTTOM w0.127: MEM3.A2 55.53,105.25 56.82,105.25 59.6,102.48 59.6,97.76 59.81,97.55 59.81,96.79 60.9,95.7 v2(61.96,95.7) 61.96,95.45 63.14,94.27 63.48,94.27 63.61,94.4 63.61,94.9 63.74,95.03 63.99,95.03 64.12,94.9 64.12,94.4 64.25,94.27 64.5,94.27 64.63,94.4 64.63,94.93 64.75,95.06 65.01,95.06 65.13,94.93 65.13,94.4 65.26,94.27 65.52,94.27 65.64,94.4 65.64,94.93 65.77,95.06 66.02,95.06 66.15,94.93 66.15,94.4 66.28,94.27 67.05,94.27 67.18,94.4 67.18,95.53 67.81,96.17 68.08,96.17 68.21,96.29 68.21,96.83 68.33,96.96 68.59,96.96 68.71,96.83 68.71,96.29 68.84,96.17 69.1,96.17 69.22,96.29 69.22,96.83 69.35,96.96 69.6,96.96 69.73,96.83 69.73,96.29 69.86,96.17 71.5,96.17 71.63,96.04 71.63,95.06 71.75,94.93 72.82,94.93 72.94,95.06 v4(72.94,95.94)
MDA14: length 36
  TOP w0.102: v4(68.02,95.44) 68.17,95.44 68.5,95.11 68.93,95.11 68.97,95.16 69.09,95.27 69.4,95.27 69.57,95.24 69.61,95.24 69.7,95.21 70.22,95.21 U13.D26
  BOTTOM w0.127: MEM3.C2 55.57,103.61 56.12,103.61 56.35,103.39 56.68,103.39 56.96,103.1 57.61,103.1 57.78,102.94 57.78,101.41 58.04,101.15 58.04,99.86 57.66,99.48 57.66,98.37 57.87,98.16 57.87,97.64 58.29,97.22 58.47,97.22 58.73,97.48 58.91,97.48 59.12,97.26 59.12,97.08 58.8,96.76 v2(58.8,96.14) 60.06,94.88 61.56,94.88 63.22,93.22 63.22,91.53 63.35,91.4 63.69,91.4 63.82,91.53 63.82,92.19 63.94,92.31 64.2,92.31 64.33,92.19 64.33,91.53 64.45,91.4 64.71,91.4 64.83,91.53 64.83,92.19 64.96,92.31 65.21,92.31 65.34,92.19 65.34,91.53 65.47,91.4 65.72,91.4 65.85,91.53 65.85,92.19 65.98,92.31 66.23,92.31 66.36,92.19 66.36,91.67 66.5,91.53 66.74,91.53 66.87,91.65 66.87,92.19 66.99,92.31 67.25,92.31 67.37,92.19 67.37,91.73 67.5,91.6 67.77,91.6 67.9,91.73 67.9,92.51 68.02,92.64 v4(68.02,95.44)
MDA15: length 36
  TOP w0.127: U13.F25 71.18,95.31 v4(71.07,95.31)
  BOTTOM w0.127: MEM3.C3 54.77,104.43 56.41,104.43 56.56,104.27 57.45,104.27 58.33,103.4 v2(58.33,102.28) 58.33,100.95 59.14,100.14 59.14,97.73 59.47,97.4 59.47,96.6 60.85,95.22 61.7,95.22 63.56,93.36 63.56,92.85 63.74,92.67 64.08,92.67 64.21,92.8 64.21,93.76 64.34,93.89 64.59,93.89 64.72,93.76 64.72,92.8 64.85,92.67 65.1,92.67 65.23,92.8 65.23,93.79 65.35,93.91 65.61,93.91 65.74,93.79 65.74,92.8 65.86,92.67 66.12,92.67 66.24,92.8 66.24,93.79 66.37,93.91 66.62,93.91 66.75,93.79 66.75,92.8 66.88,92.67 67.34,92.67 67.6,92.94 67.6,95.61 67.93,95.94 70.5,95.94 71.07,95.37 v4(71.07,95.31)
MDA16: length 35.9
  TOP w0.102: MEM1.A2 50.82,106.08 50.82,107.54
  TOP w0.127: 50.82,107.54 52.87,109.58 v1(54.23,109.58) 54.46,109.36 58.42,109.36 58.7,109.36 59.33,109.36 65.63,103.06 65.63,101.71 65.5,101.58 65.35,101.58 65.23,101.45 65.23,101.2 65.35,101.07 65.5,101.07 65.63,100.94 65.63,100.69 65.5,100.56 65.15,100.56 65.02,100.44 65.02,100.18 65.15,100.05 65.5,100.05 65.63,99.93 65.63,99.67 65.5,99.55 65.15,99.55 65.02,99.42 65.02,99.17 65.15,99.04 65.5,99.04 65.63,98.91 65.63,98.66 65.5,98.53 65.15,98.53 65.02,98.4 65.02,98.15 65.15,98.02 65.5,98.02 65.63,97.9 65.63,97.64 65.5,97.51 65.15,97.51 65.02,97.39 65.02,97.13 65.15,97.01 65.5,97.01 65.63,96.88 65.63,96.19 67.08,94.74 67.95,94.74 68.02,94.67 69.11,94.67 69.12,94.67 69.28,94.67 U13.A25
MDA17: length 36.1
  TOP w0.102: 50.49,106.54 50.24,106.28 50.16,106.28 50.04,106.16 50.04,105.76 50.03,105.76 50.03,105.48 50.04,105.48 50.04,105.39 50.16,105.27 50.55,105.27 50.8,105.02 50.8,104.45 MEM1.C2 ; 68.71,94.9 69,94.9 69.11,95.01 69.17,95.07 69.38,95.07 69.53,95.04 69.56,95.04 69.96,94.93 U13.C25
  TOP w0.127: 50.49,106.54 50.49,107.38 50.48,107.4 50.48,108.02 52.61,110.16 v1(55.91,110.16) 59.12,110.16 66.1,103.18 66.1,96.21 66.8,95.5 66.8,95.5 67.33,94.98 68.05,94.98 68.13,94.9 68.71,94.9
MDA18: length 36.6
  TOP w0.102: U13.E25 70.88,94.74 70.47,94.33 68.94,94.33 68.82,94.45 68.49,94.45 68.48,94.44 67.56,94.44
  TOP w0.127: 67.56,94.44 67.56,94.45 66.81,94.45 66.02,95.23 65.98,95.23 64.68,96.53 64.68,97.48 64.55,97.61 63.86,97.61 63.73,97.73 63.73,97.99 63.86,98.12 64.55,98.12 64.68,98.24 64.68,98.5 64.55,98.62 63.86,98.62 63.73,98.75 63.73,99 63.86,99.13 64.55,99.13 64.68,99.26 64.68,102.04 v1(64.97,102.33) 64.97,103.16 59.12,109.01 58.56,109.01 52.78,109.01 52.2,108.43 52.2,108.26 52.35,108.11 52.35,107.93 52.17,107.75 51.99,107.75 51.84,107.9 51.66,107.9 51.43,107.66 51.43,106.36 51.33,106.26 51.29,106.26 51.16,106.13 MEM1.A3
MDA19: length 36.6
  TOP w0.102: 68.48,93.61 68.8,93.61 68.9,93.71 69.48,93.71 69.52,93.68 69.61,93.64 69.73,93.6 69.87,93.62 69.95,93.68 70.08,93.73 70.15,93.8 70.46,93.94 U13.D24
  TOP w0.127: MEM1.C3 51.16,104.29 52.32,105.44 52.32,106.1 52.96,106.74 52.96,106.92 52.46,107.41 52.46,107.56 52.58,107.68 53.01,107.68 53.22,107.47 53.56,107.47 53.74,107.65 53.74,107.98 53.62,108.11 53.16,108.11 53.04,108.24 53.04,108.54 53.16,108.67 58.98,108.67 64.34,103.31 64.34,99.68 64.13,99.47 63.71,99.47 63.31,99.07 63.31,97.67 64,96.97 v1(64.07,96.97) 64.07,96.65 66.55,94.18 67.92,94.18 68.48,93.61
MDA20: length 36.2
  TOP w0.102: U13.E23 70.5,92.69 69.67,92.69 69.62,92.65 69.55,92.61 69.54,92.61 69.07,92.61 68.93,92.75 67.38,92.75
  TOP w0.127: 67.38,92.75 66.77,92.75 66.73,92.71 65.13,92.71 64.62,93.21 64.44,93.21 63.89,92.66 63.71,92.66 63.53,92.84 63.53,93.02 64.08,93.57 64.08,93.75 63.9,93.93 63.73,93.93 63.35,93.56 63.17,93.56 62.99,93.73 62.99,93.91 63.37,94.29 63.37,94.47 63.19,94.65 63.01,94.65 62.63,94.27 62.45,94.27 62.27,94.45 62.27,94.63 62.65,95.01 62.65,95.19 62.47,95.37 62.29,95.37 61.91,94.99 61.73,94.99 61.55,95.17 61.55,95.35 61.93,95.73 61.93,95.91 61.8,96.04 61.8,96.39 61.67,96.52 61.11,96.52 60.99,96.64 60.99,97.51 61.11,97.63 61.67,97.63 61.8,97.76 61.8,101.59 61.8,102.16 v1(62.14,102.5) 62.48,102.84 62.48,103.02 62.2,103.31 61.07,103.31 58.17,106.22 58.17,106.87 57.93,107.1 55.22,107.1 54.83,106.71 54.76,106.71 54.42,106.38 54.42,106.36 54.43,106.35 54.43,105.69 MEM1.A7
MDA21: length 36.9
  TOP w0.102: MEM1.D7 54.36,103.55 54.07,103.85 54.07,103.85 53.85,104.07 ; U13.F23 71.42,93.47 70.13,93.47 arc(69.98,93.44) 69.85,93.35 69.62,93.35 69.53,93.45 69.46,93.49 68.96,93.49 68.83,93.36 68.38,93.36 67.92,93.81 67.31,93.81
  TOP w0.127: 53.85,104.07 53.72,104.2 53.72,104.5 52.92,105.3 52.92,105.7 52.92,106.26 54.93,108.27 58.89,108.27 63.93,103.23 63.93,100.24 63.52,99.82 63.25,99.82 v1(63.13,99.7) 62.97,99.54 62.97,97.27 63.26,96.98 63.26,96.8 63.15,96.68 63.15,96.5 63.33,96.32 63.51,96.32 63.62,96.44 63.8,96.44 64.7,95.54 64.7,95.36 64.5,95.16 64.5,94.99 64.69,94.8 64.85,94.8 65.06,95 65.24,95 65.42,94.82 65.42,94.64 65.21,94.44 65.21,94.27 65.41,94.08 65.57,94.08 65.78,94.28 65.96,94.28 66.41,93.83 67.29,93.83 67.31,93.81
MDA22: length 37.1
  TOP w0.102: U13.D22 70.32,92.11 70,92.11 69.94,92.05 69.81,92 69.69,92 69.51,92.07 69.3,92.07 69.13,92.07 69,91.95 68.5,91.95 68.48,91.93 68.15,91.93 67.77,92.31
  TOP w0.127: MEM1.B8 55.16,104.88 55.54,105.26 55.54,105.76 55.32,105.99 54.92,105.99 54.8,106.11 54.8,106.36 55.18,106.74 57.15,106.74 61.44,102.45 61.44,101.28 61.32,101.15 60.52,101.15 60.39,101.03 60.39,100.77 60.52,100.65 61.32,100.65 61.44,100.52 61.44,100.27 61.32,100.14 60.52,100.14 60.39,100.01 60.39,99.76 60.52,99.63 61.32,99.63 61.44,99.5 61.44,99.25 61.32,99.12 60.52,99.12 60.39,99 60.39,98.74 60.52,98.61 61.29,98.61 61.42,98.49 61.42,98.19 61.29,98.07 60.46,98.07 60.25,97.85 60.25,96.88 61.04,96.1 v1(61.04,95.73) 61.04,95.11 61.6,94.54 61.6,94.36 61.56,94.31 61.56,94.13 61.74,93.95 61.92,93.95 61.96,94 62.14,94 62.32,93.82 62.32,93.64 62.27,93.59 62.27,93.41 62.45,93.23 62.63,93.23 62.68,93.28 62.86,93.28 63.04,93.1 63.04,92.92 62.93,92.81 62.93,92.48 63.09,92.31 67.77,92.31
MDA23: length 37.7
  TOP w0.102: U13.F21 71.42,91.87 70.03,91.87 arc(69.98,91.83) 69.92,91.8 arc(69.89,91.8) 69.85,91.79 69.65,91.79 arc(69.55,91.81) 69.47,91.87 69.21,91.87 69.09,91.74 68.58,91.74 68.57,91.73 67.96,91.73 67.89,91.8
  TOP w0.127: MEM1.C8 55.43,104.02 55.81,104.4 56.49,104.4 56.58,104.31 57.06,104.31 57.25,104.51 57.7,104.51 58.18,104.99 58.36,104.99 58.65,104.69 58.65,104.51 58.33,104.18 58.33,104 58.61,103.72 58.79,103.72 59.15,104.08 59.33,104.08 60.74,102.66 v1(60.74,101.91) 59.91,101.08 59.91,96.34 60.03,96.22 60.33,96.22 60.45,96.09 60.45,95.83 60.33,95.71 60.03,95.71 59.91,95.58 59.91,95.33 60.03,95.2 60.58,95.2 60.69,95.08 60.69,94.82 60.57,94.69 60.03,94.69 59.91,94.56 59.91,92.25 60.19,91.97 60.53,91.97 60.66,92.1 60.66,93.41 60.78,93.53 61.04,93.53 61.16,93.41 61.16,92.1 61.29,91.97 61.54,91.97 61.67,92.1 61.67,92.77 61.8,92.9 62.05,92.9 62.18,92.77 62.18,92.1 62.31,91.97 66.69,91.97 66.7,91.98 67.71,91.98 67.89,91.8
MDA24: length 35
  TOP w0.127: U13.E21 70.95,91.42 v4(71.29,91.08) ; MEM1.G2 50.36,100.83 v4(50.76,101.23)
  L4 w0.165: v4(50.76,101.23) 51.21,101.67 51.21,103.82 51.8,104.41 51.8,104.7 53.81,106.71 54.51,106.71 54.81,106.41 55.32,106.41 55.63,106.71 56.79,106.71 57.05,106.46 57.66,106.46 57.91,106.71 58.78,106.71 65.71,99.78 65.71,99.35 66.26,98.8 66.26,97.08 66.56,96.78 68.04,96.78 69.29,95.53 69.29,94.71 70.66,93.33 70.66,91.71 v4(71.29,91.08)
MDA25: length 34.8
  TOP w0.127: v4(71.06,90.52) 70.84,90.74 U13.D20 ; v4(50.76,102.82) MEM1.E3
  L4 w0.165: v4(71.06,90.52) 71.48,90.52 71.78,90.81 71.78,91.96 71.68,92.06 71.68,94.05 68.36,97.37 67.58,97.37 67.16,97.79 67.16,98.45 66.09,99.53 66.09,100.11 59.1,107.1 53.82,107.1 50.76,104.04 v4(50.76,102.82)
MDA26: length 35.7
  TOP w0.127: MEM1.H3 51.81,100.67 v4(51.81,101.1) ; v4(71.11,89.11) 71.11,89.3 U13.F19
  L4 w0.165: v4(51.81,101.1) 51.81,102.31 51.52,102.6 51.52,102.97 51.61,103.05 51.61,103.64 52.2,104.23 52.2,104.73 53.6,106.13 54.15,106.13 54.49,105.79 59.01,105.79 65.33,99.48 65.33,99.19 65.76,98.76 65.76,96.49 68.22,94.03 68.22,93.69 70.08,91.83 70.08,90.14 v4(71.11,89.11)
MDA27: length 34.9
  TOP w0.127: v4(67.33,89.58) 67.34,89.59 67.59,89.59 67.96,89.96 68.31,89.96 68.31,89.96 69.33,89.96 U13.A19 ; MEM1.F2 50.73,101.98 51.24,101.98 51.54,102.29 51.54,102.96 51.63,103.04 51.63,103.6 52.55,104.53 52.63,104.53 v4(52.64,104.53)
  L4 w0.165: v4(52.64,104.53) 52.88,104.78 55.03,104.78 55.42,105.17 58.95,105.17 64.64,99.48 64.64,99.34 65.28,98.7 65.28,96.28 67.73,93.82 67.73,93.6 68.88,92.44 68.88,91.09 69.09,90.89 69.37,90.89 69.57,90.69 69.57,90.33 69.39,90.15 68.05,90.15 67.48,89.59 67.34,89.59 v4(67.33,89.58)
MDA28: length 35.9
  TOP w0.102: U13.D18 70.55,89.43 70.37,89.61 69.21,89.61 69.07,89.75 68.44,89.75 v4(68.22,89.53)
  TOP w0.127: v4(57.42,99.88) 57.27,99.73 56.89,99.73 56.24,100.38 55.53,100.38 MEM1.H8
  L4 w0.165: v4(68.22,89.53) 67.84,89.14 66.75,89.14 66.47,88.87 64.08,88.87 63.21,89.73 61.51,89.73 61.34,89.89 61.34,90.24 61.51,90.4 63.03,90.4 63.2,90.57 63.2,90.9 63.03,91.06 61.73,91.06 61.59,91.2 61.59,91.58 61.73,91.72 63.03,91.72 63.2,91.89 63.2,92.22 63.03,92.38 61.79,92.38 61.62,92.55 61.62,92.88 61.79,93.05 62.6,93.05 62.76,93.21 62.76,93.59 62.24,94.11 62.01,94.11 61.71,93.81 61.47,93.81 61.24,94.04 61.24,94.27 61.54,94.58 61.54,94.81 61.31,95.05 61.08,95.05 60.62,94.59 60.39,94.59 60.15,94.82 60.15,95.06 60.61,95.51 60.61,95.75 58.56,97.79 58.56,99.08 58.12,99.53 57.77,99.53 v4(57.42,99.88)
  BOTTOM w0.127: v2(68.7,90.16) 68.22,89.68 v4(68.22,89.53)
MDA29: length 36.4
  TOP w0.102: v4(66.64,89.58) 66.03,88.97 66.03,88.79 66.24,88.58 66.42,88.58 66.95,89.11 68.43,89.11 68.67,88.87 69.48,88.87 69.5,88.86 69.58,88.85 69.58,88.84 69.6,88.84 69.6,88.83 69.61,88.83 69.67,88.81 70.84,88.81 70.98,88.67 71.42,88.67 U13.F17
  TOP w0.127: MEM1.H7 53.65,100.02 53.52,100.15 53.52,100.3 53.39,100.43 52.78,100.43 52.65,100.56 52.65,100.81 52.78,100.93 53.29,100.93 53.42,101.06 53.42,101.57 v4(53.16,101.82)
  L4 w0.165: v4(53.16,101.82) 53.16,101 53.38,100.78 53.71,100.78 53.98,100.52 53.98,100.19 54.18,99.99 55.07,99.99 55.22,100.14 55.73,100.14 56.09,99.78 56.7,99.78 57.23,100.32 57.91,100.32 59.01,99.22 59.01,99.03 59.01,97.95 59.2,97.76 59.43,97.76 59.68,98.01 59.92,98.01 60.15,97.77 60.15,96.88 63.67,93.37 63.67,92.99 63.87,92.78 63.87,92.31 63.67,92.11 63.67,91.67 63.87,91.46 63.87,90.99 63.67,90.79 63.67,89.82 64.22,89.26 64.6,89.26 64.77,89.43 64.77,89.73 64.94,89.9 65.27,89.9 65.43,89.73 65.43,89.3 65.6,89.13 66.19,89.13 66.64,89.58 v4(66.64,89.58)
MDA30: length 34.8
  TOP w0.102: U13.A17 69.24,88.45 67.46,88.45
  TOP w0.127: v4(53.77,102.43) 53.96,102.25 54,102.25 54.36,101.88 MEM1.F7 ; v4(64.9,90.76) 62.2,90.76 62.08,90.64 62.08,90.08 62.2,89.95 64.34,89.95 64.5,89.79 64.5,88.26 64.83,87.93 64.83,87.93 64.94,87.83 66.64,87.83 67.26,88.45 67.46,88.45
  L4 w0.165: v4(53.77,102.43) 53.77,102.44 54.27,102.44 54.35,102.36 54.72,102.36 54.89,102.2 54.89,101.82 55.05,101.66 55.38,101.66 55.55,101.82 55.55,102.2 55.71,102.36 56.3,102.36 56.83,101.83 57.5,101.83 57.9,102.23 58.13,102.23 58.42,101.94 58.42,101.71 58.23,101.52 58.23,101.14 60.32,99.05 60.92,99.05 63.49,96.48 63.49,95.69 65.3,93.88 65.3,91.16 v4(64.9,90.76)
MDA31: length 34.9
  TOP w0.102: U13.C17 70.01,88.48 69.85,88.48 69.52,88.63 69.5,88.65 69.45,88.66 69.43,88.67 68.5,88.67 68.39,88.78 67.1,88.78
  TOP w0.127: 67.1,88.78 66.59,88.27 64.97,88.27 64.85,88.4 64.85,89.42 65.01,89.58 v4(65.96,89.58) ; MEM1.F8 v4(55.56,101.22)
  L4 w0.165: v4(65.96,89.58) 65.94,89.61 65.94,90.03 65.67,90.3 64.7,90.3 64.34,90.67 64.34,91.48 64.5,91.65 64.76,91.65 64.92,91.81 64.92,92.15 64.76,92.31 64.5,92.31 64.34,92.47 64.34,92.8 64.5,92.97 64.76,92.97 64.92,93.13 64.92,93.72 64.65,93.99 64.39,93.99 64.18,93.78 63.94,93.78 63.57,94.15 63.57,94.39 63.8,94.62 63.8,94.8 63.51,95.1 63.28,95.1 63.06,94.88 62.82,94.88 62.59,95.11 62.59,95.35 63.1,95.86 63.1,96.09 62.87,96.32 62.63,96.32 62.12,95.82 61.89,95.82 61.66,96.05 61.66,96.28 62.29,96.92 62.29,97.14 62.05,97.39 61.83,97.39 61.19,96.75 60.96,96.75 60.72,96.98 60.72,97.22 61.33,97.83 61.33,98.06 61.07,98.32 60.82,98.32 60.66,98.15 60.33,98.15 60.02,98.46 59.59,98.46 59.39,98.66 59.39,99.42 58.22,100.59 56.99,100.59 56.66,100.26 56.18,100.26 55.56,100.88 v4(55.56,101.22)
MDA32: length 35.3
  TOP w0.102: U13.E17 70.63,88.02 70.3,88.02 70.29,88.01 70.03,88.01 70,88.02 69.99,88.04 69.84,88.07 69.83,88.07 69.56,88.07 69.53,88.06 69.53,88.06 69.43,88.01 69.22,88.01 69.15,88.08 69.15,88.08 69,88.22 68.52,88.22 68.5,88.2 67.59,88.2 66.5,87.11 v3(66.5,87.06)
  L4 w0.165: v3(66.5,87.06) 66.08,86.64 62.62,86.64 62.35,86.37 62.35,86.14 62.59,85.9 62.59,85.66 62.36,85.43 62.12,85.43 61.88,85.67 61.65,85.67 61.2,85.23 61.2,84.8 61.37,84.64 61.86,84.64 62.03,84.47 62.03,84.14 61.86,83.98 61.37,83.98 61.2,83.81 61.2,83.48 61.37,83.32 61.87,83.32 62.04,83.16 62.04,82.82 61.87,82.66 61.37,82.66 61.2,82.49 61.2,82.16 61.37,82 61.85,82 62.01,81.83 62.01,81.5 61.85,81.34 61.37,81.34 61.2,81.17 61.2,80.88 60.93,80.61 60.93,80.38 61.69,79.62 61.69,79.39 61.45,79.16 61.22,79.16 60.46,79.91 60.23,79.91 60,79.68 60,79.45 60.75,78.69 60.75,78.46 60.51,78.23 60.28,78.23 59.53,78.98 59.3,78.98 59.06,78.74 59.06,78.51 59.79,77.79 59.79,77.55 59.55,77.32 59.32,77.32 58.58,78.06 58.34,78.06 57.69,77.41 v4(57.31,77.41)
  BOTTOM w0.127: v4(57.31,77.41) 56.57,77.41 56.3,77.13 55.72,77.13 55.29,77.56 MEM4.F8
MDA33: length 35.1
  TOP w0.102: v4(67.5,87.5) 67.5,87.76 67.73,87.99 68.94,87.99 69.14,87.8 69.45,87.8 69.49,87.81 69.62,87.87 69.8,87.87 69.92,87.83 70.13,87.74 U13.D16
  L4 w0.165: v4(67.5,87.5) 67.43,87.57 61.58,87.57 61.41,87.4 61.41,86.82 61.22,86.63 61,86.63 60.13,87.49 59.9,87.49 59.66,87.25 59.66,87.02 60.2,86.48 60.2,81.21 58.69,79.7 58.14,79.7 57.97,79.54 57.97,79.32 57.81,79.16 57.48,79.16 57.31,79.32 57.31,79.54 57.15,79.7 v3(56.5,79.7)
  BOTTOM w0.127: v3(56.5,79.7) 56.5,79.41 56.63,79.28 57.15,79.28 57.28,79.41 57.28,79.79 58.74,81.25 58.74,81.77 58.26,82.25 58.08,82.25 57.81,81.98 57.81,81.8 58.01,81.6 58.01,81.42 57.83,81.24 57.65,81.24 57.45,81.44 57.27,81.44 57.09,81.26 57.09,81.08 57.29,80.88 57.29,80.7 57.11,80.52 56.93,80.52 56.74,80.72 56.56,80.72 56.23,80.39 55.66,80.39 55.56,80.3 55.56,79.56 MEM4.H8
MDA34: length 35.7
  TOP w0.102: 68.57,87.07 71.42,87.07 U13.F15
  TOP w0.127: v4(68.11,87.53) 68.57,87.07
  L4 w0.165: v4(68.11,87.53) 67.93,87.36 67.93,87.32 66.85,86.23 63.7,86.23 62.42,84.94 62.42,81.11 62.1,80.79 61.81,80.79 61.65,80.63 61.65,80.29 61.81,80.12 62.25,80.12 62.42,79.96 62.42,79.58 59.4,76.57 59.17,76.57 58.45,77.28 58.21,77.28 57.98,77.05 57.98,76.82 58.7,76.1 58.7,75.87 58.25,75.42 57.16,75.42 55.4,77.18 54.39,77.18 54.08,77.49 53.37,77.49 v4(53.2,77.66)
  BOTTOM w0.127: v4(53.2,77.66) 53.08,77.78 52.36,77.78 52.19,77.61 52.19,77.02 52.31,76.9 53.94,76.9 54.36,77.32 MEM4.F7
MDA35: length 35.6
  TOP w0.127: U13.A15 68.99,86.74 68.96,86.77 67.12,86.77 66.85,86.5 63.78,86.5 63.25,87.03 63.25,88.68 63.12,88.81 62.1,88.81 61.98,88.93 61.98,89.29 62.1,89.42 63.77,89.42 63.89,89.29 63.89,87.49 64.27,87.11 v4(65.71,87.11)
  L4 w0.165: v4(53.8,78.56) 53.84,78.56 54.29,78.11 54.29,77.8 54.58,77.52 56.24,77.52 56.56,77.84 57.5,77.84 60.67,81.01 60.67,85.38 62.45,87.16 65.66,87.16 v4(65.71,87.11)
  BOTTOM w0.127: v4(53.8,78.56) 53.8,78.62 54.35,79.16 MEM4.H7
MDA36: length 34.9
  TOP w0.127: v4(71.05,85.69) 70.8,85.94 U13.D14
  L4 w0.165: v4(71.05,85.69) 69.53,85.69 68.05,84.21 66.98,84.21 66.64,84.55 64.62,84.55 64.31,84.23 64.31,77.65 59.57,72.92 54.02,72.92 53.23,73.7 53.23,74.16 52.95,74.45 52.83,74.45 51.79,75.49 51.79,76.11 51.22,76.69 51.22,77.85 51.2,77.87 51.2,78.32 v4(50.76,78.76)
  BOTTOM w0.127: v4(50.76,78.76) MEM4.H3
MDA37: length 34.5
  TOP w0.127: v4(71.15,84.39) 71.75,84.99 U13.F13
  L4 w0.165: v4(71.15,84.39) 70.17,83.41 70.17,80.21 67.54,77.58 66.75,77.58 60.67,71.5 53.94,71.5 50.4,75.04 50.4,75.37 50.4,75.37 50.4,75.74 49.88,76.26 49.88,77.07 v4(50.76,77.95)
  BOTTOM w0.127: v4(50.76,77.95) 50.36,78.35 MEM4.G2
MDA38: length 35
  TOP w0.102: 69.15,85.14 69.13,85.15 68.29,85.15 68.19,85.05 67.65,85.05 67.65,85.05 67.28,85.05
  TOP w0.127: 69.15,85.14 U13.A13 ; v1(63.95,84.06) 64.79,84.06 v4(64.79,84.06) 65.21,83.64 65.87,83.64 67.28,85.05
  L4 w0.165: v4(52.77,74.01) 52.77,73.58 53.9,72.45 59.77,72.45 64.79,77.46 64.79,79.47 64.96,79.63 65.48,79.63 65.61,79.76 65.61,80.17 65.48,80.29 64.96,80.29 64.79,80.46 64.79,80.79 64.96,80.95 65.48,80.95 65.61,81.08 65.61,81.49 65.48,81.61 64.96,81.61 64.79,81.78 64.79,82.11 64.96,82.28 65.44,82.28 65.57,82.4 65.57,82.81 65.44,82.94 64.96,82.94 64.79,83.1 v4(64.79,84.06)
  BOTTOM w0.127: v4(52.77,74.01) 52.71,74.07 52.71,74.57 51.66,75.62 51.66,76.27 MEM4.E3
MDA39: length 35.2
  TOP w0.102: U13.C13 69.82,85.47 69.21,85.47 69.1,85.36 68.05,85.36 67.96,85.27 66.83,85.27
  TOP w0.127: 66.83,85.27 65.64,84.08 v4(65.61,84.08) 65.61,84.92 v1(65.68,85)
  L4 w0.165: v4(65.61,84.08) 66.73,82.97 66.73,79.08 65.53,77.89 65.53,77.24 60.26,71.97 54,71.97 50.86,75.11 50.86,75.67 50.35,76.18 50.35,76.73 v4(50.77,77.16)
  BOTTOM w0.127: v4(50.77,77.16) MEM4.F2
MDA40: length 36.8
  TOP w0.127: MEM2.C3 54.27,75.06 53.25,75.06 53.13,75.19 53.13,75.47 52.91,75.68 52.48,75.68 52.02,75.22 52.02,74.89 52.47,74.45 53.36,74.45 53.49,74.32 53.49,73.74 53.31,73.56 52.66,73.56 52.38,73.28 52.38,72.73 52.74,72.37 52.74,72.11 52.87,71.98 53.29,71.98 53.41,72.11 53.41,72.28 53.52,72.39 53.89,72.39 54,72.28 54,72.11 54.12,71.98 54.6,71.98 54.72,72.11 54.72,72.24 54.85,72.37 55.3,72.37 55.65,72.01 57.77,72.01 58.23,72.47 58.23,73.17 58.68,73.63 59.06,73.63 59.74,74.31 v1(59.74,75.39) 59.74,77.12 60.67,78.05 60.67,78.8 60.86,79 60.86,79.31 60.67,79.51 60.67,79.82 60.86,80.01 60.86,80.33 60.67,80.52 60.67,80.97 61.07,81.37 61.83,81.37 61.95,81.25 61.95,81.24 62.08,81.11 62.33,81.11 62.46,81.24 62.46,81.25 62.59,81.37 62.84,81.37 62.97,81.25 62.97,81.24 63.1,81.11 63.35,81.11 63.48,81.24 63.48,81.25 63.6,81.37 63.95,81.37 64.5,81.92 66.7,81.92 68.07,83.3 69.1,83.3 69.2,83.2 70.61,83.2 U13.E11
MDA41: length 36.4
  TOP w0.102: 67.77,83.5 67.78,83.51 69.16,83.51 69.18,83.53 69.34,83.53 U13.A11
  TOP w0.127: 67.77,83.5 66.54,82.27 64.31,82.27 63.76,81.72 61.01,81.72 60.89,81.84 60.89,82 60.77,82.12 60.33,82.12 60.2,82 60.2,81.2 60.07,81.07 59.73,81.07 59.6,81.2 59.6,82.07 59.47,82.19 59.01,82.19 58.89,82.07 58.89,80.98 58.76,80.85 58.53,80.85 58.41,80.72 58.41,80.27 58.53,80.14 v1(59.14,80.14) 60.07,80.14 60.25,79.96 60.25,79.61 60.07,79.43 59.56,79.43 59.38,79.25 59.38,78.87 59.53,78.72 60.07,78.72 60.25,78.54 60.25,78.15 60.09,78 59.53,78 59.37,77.83 59.37,76.96 59.36,76.96 59.36,76.72 59.14,76.49 59.14,74.46 58.84,74.16 58.43,74.16 57.95,73.68 57.95,72.52 57.67,72.24 57.19,72.24 57.02,72.42 57.02,72.47 56.84,72.65 56.48,72.65 56.3,72.47 56.3,72.42 56.13,72.24 55.75,72.24 55.27,72.73 55.27,73.05 55.14,73.18 54.81,73.18 54.68,73.05 54.68,72.8 54.55,72.67 52.99,72.67 52.86,72.8 52.86,73.16 52.99,73.29 53.46,73.29 53.59,73.42 53.59,73.42 53.71,73.55 54.36,73.55 MEM2.A3
