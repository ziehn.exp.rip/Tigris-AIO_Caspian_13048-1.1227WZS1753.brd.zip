# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Nets (continued)
GND: ATX1.1 ATX1.2 ATX2.2 ATX2.3 ATX2.7 BT1.2 C7.2 C8.2 C9.2 C10.2 C11.2 C12.2 C13.2 C14.2 C15.2 C16.2 C17.2 C18.2 C19.2 C20.2 C21.2 C22.2 C23.2 C24.2 C25.2 C26.2 C27.2 C28.2 C29.2 C30.2 C31.2 C32.2 C33.2 C34.2 C35.2 C36.2 C37.2 C38.2 C39.2 C40.2 C41.2 C42.1 C43.2 C44.2 C45.2 C48.2 C49.2 C50.2 C51.2 C52.2 C53.2 C54.2 C55.2 C56.2 C57.2 C58.2 C59.2 C61.2 C62.2 C63.2 C64.2 C65.2 C66.2 C68.2 C69.2 C70.2 C71.1 C72.2 C73.2 C74.2 C75.1 C76.2 C77.2 C78.2 C79.1 C81.2 C82.2 C83.2 C84.2 C85.2 C86.2 C88.2 C89.2 C90.2 C91.2 C92.1 C93.2 C94.2 C95.2 C97.1 C100.2 C101.2 C102.1 C103.2 C104.1 C105.2 C106.1 C108.1 C109.2 C110.2 C113.2 C115.2 C116.2 C117.1 C118.2 C121.2 C122.1 C123.2 C124.2 C125.1 C126.1 C127.2 C128.2 C129.2 C130.2 C131.2 C132.2 C142.2 C145.2 C154.2 C155.2 C156.2 C157.2 C158.1 C159.2 C160.2 C161.2 C162.1 C163.2 C164.2 C165.2 C167.1 C168.2 C169.2 C172.2 C173.2 C174.2 C177.2 C178.2 C180.2 C182.2 C183.2 C185.2 C186.2 C188.2 C189.2 C190.2 C191.2 C192.2 C197.2 C198.2 C199.2 C200.2 C205.2 C207.2 C211.2 C213.2 C214.2 C215.2 C216.2 C219.2 C223.2 C226.2 C227.1 C228.2 C229.2 C232.2 C239.2 C240.2 C241.2 C246.2 C247.2 C248.1 C249.2 C250.2 C257.2 C258.2 C259.2 C260.2 C262.2 C263.2 C264.2 C265.2 C266.2 C270.2 C271.2 C272.2 C273.2 C276.2 C280.2 C281.2 C282.2 C284.2 C288.2 C289.2 C290.1 C291.2 C293.2 C297.2 C298.2 C299.2 C303.2 C304.2 C305.2 C307.2 C308.2 C309.2 C310.1 C311.2 C312.2 C313.2 C314.2 C315.2 C316.2 C317.2 C319.2 C321.2 C322.2 C325.2 C326.2 C327.2 C328.2 C329.2 C330.2 C331.2 C332.2 C333.1 C335.1 C338.2 C341.2 C342.2 C343.2 C344.2 C345.2 C346.2 C347.2 C348.2 C349.2 C350.2 C351.2 C352.2 C353.2 C354.1 C357.2 C358.1 C359.2 C360.1 C361.1 C362.1 C363.1 C364.2 C365.2 C366.2 C367.2 C369.2 C370.1 C371.2 C372.2 C377.2 C379.2 C384.2 C385.2 C389.2 C390.2 C391.2 C392.2 C393.2 C394.2 C395.1 C396.2 C397.2 C398.2 C399.2 C401.2 C402.2 C403.1 C411.2 C412.2 C416.2 C418.2 C419.2 C421.2 C422.2 C423.2 C424.2 C425.2 C426.2 C427.2 C428.2 C429.2 C430.2 C431.2 C432.2 C433.2 C434.2 C435.1 C436.1 C437.2 C438.2 C439.2 C440.2 C441.1 C442.2 C443.2 C444.1 C445.2 C446.2 C447.1 C448.2 C449.2 C450.2 C452.2 C453.2 C454.2 C455.2 C456.2 C457.2 C458.2 C459.2 C460.2 C461.2 C462.2 C463.2 C464.2 C465.2 C466.2 C467.2 C468.2 C469.2 C470.2 C471.2 C472.2 C473.2 C474.2 C475.2 C476.2 C477.2 C478.2 C479.2 C480.2 C481.2 C482.2 C483.2 C484.2 C486.2 C488.2 C489.2 C500.2 C501.2 C502.2 C503.2 C504.2 C505.2 C514.2 C515.2 C516.2 C529.2 C539.2 C540.2 C545.2 C548.2 C550.2 C551.2 C552.2 C554.2 C557.2 C558.2 C559.2 C560.2 C565.2 C578.2 C579.2 C581.2 C583.2 C584.2 C588.2 C591.2 C593.1 C598.2 C599.2 C600.2 C601.2 C602.2 C606.2 C608.2 C609.2 C612.2 C613.2 C616.2 C619.2 C623.2 C625.2 C627.2 C628.2 C631.2 C632.2 C633.2 C636.2 C638.2 C639.2 C640.2 C645.2 C646.2 C647.2 C648.2 C649.2 C650.2 C651.2 C652.2 C653.2 C654.2 C655.2 C656.2 C657.2 C658.2 C659.2 C660.2 C661.1 C662.2 C663.2 C664.2 C665.2 C666.2 C667.2 C668.1 C669.1 C670.1 C671.1 C672.1 C673.2 C674.2 C675.1 C676.1 C677.1 C678.1 C680.2 C681.2 C682.2 C684.2 C685.2 C686.2 C687.2 C688.2 C689.2 C690.2 C691.1 C692.2 C693.2 C694.2 C695.1 C696.2 C697.2 C698.2 C699.2 C700.2 C701.2 C702.2 C703.2 C704.2 C705.2 C706.2 C707.2 C708.2 C709.2 C710.2 C711.2 C712.2 C713.2 C714.1 C715.2 C716.2 C717.2 C718.2 C719.1 C720.2 C721.1 C722.2 C723.2 C724.2 C725.2 C726.2 C727.2 C728.2 C729.2 C732.2 C735.2 C752.2 C753.2 C755.2 C756.2 C757.2 C758.2 C759.2 C760.2 C761.2 C762.2 C765.2 C766.2 C767.2 C768.2 C769.2 C770.2 C771.2 C772.2 C773.2 C774.2 C775.2 C776.2 C777.2 C778.2 C779.2 C780.2 C781.2 C782.2 C783.2 C784.2 C785.2 C786.2 C787.2 C788.2 C789.2 C790.2 C791.2 C792.2 C793.2 C794.2 C795.2 C796.2 C797.2 C798.2 C799.2 C800.2 C801.2 C802.2 C803.2 C804.2 C805.2 C806.2 C807.2 C808.2 C809.2 C810.2 C811.2 C812.2 C813.2 C814.2 C815.2 C816.2 C817.2 C818.2 C819.2 C820.2 C821.2 C822.2 C823.2 C824.2 C825.2 C826.2 C827.2 C828.2 C829.2 C830.2 C831.2 C832.2 C833.2 C834.2 C835.2 C836.2 C837.2 C838.1 C839.2 C840.2 C863.2 C864.2 C865.1 C866.1 C867.1 C868.1 C869.2 C870.2 CONVT1.3 CONVT1.5 CONVT1.6 CPU1.A5 CPU1.A7 CPU1.A11 CPU1.A13 CPU1.A15 CPU1.A17 CPU1.A23 CPU1.AA3 CPU1.AA6 CPU1.AA7 CPU1.AA8 CPU1.AA33 CPU1.AA35 CPU1.AA38 CPU1.AB5 CPU1.AB7 CPU1.AB34 CPU1.AB37 CPU1.AC3 CPU1.AC6 CPU1.AC7 CPU1.AC33 CPU1.AC34 CPU1.AC35 CPU1.AC36 CPU1.AC37 CPU1.AC38 CPU1.AC39 CPU1.AC40 CPU1.AD1 CPU1.AD2 CPU1.AD3 CPU1.AD4 CPU1.AD5 CPU1.AD6 CPU1.AD7 CPU1.AD8 CPU1.AD33 CPU1.AD36 CPU1.AE5 CPU1.AE8 CPU1.AE33 CPU1.AE36 CPU1.AE37 CPU1.AE40 CPU1.AF1 CPU1.AF4 CPU1.AF5 CPU1.AF8 CPU1.AF33 CPU1.AF36 CPU1.AG5 CPU1.AG8 CPU1.AG33 CPU1.AG36 CPU1.AG37 CPU1.AG38 CPU1.AG39 CPU1.AG40 CPU1.AH1 CPU1.AH2 CPU1.AH3 CPU1.AH4 CPU1.AH5 CPU1.AH8 CPU1.AH33 CPU1.AH36 CPU1.AJ5 CPU1.AJ8 CPU1.AJ11 CPU1.AJ14 CPU1.AJ16 CPU1.AJ18 CPU1.AJ19 CPU1.AJ22 CPU1.AJ23 CPU1.AJ26 CPU1.AJ27 CPU1.AJ30 CPU1.AJ31 CPU1.AJ32 CPU1.AJ33 CPU1.AJ34 CPU1.AJ35 CPU1.AJ36 CPU1.AJ37 CPU1.AJ40 CPU1.AK1 CPU1.AK4 CPU1.AK5 CPU1.AK6 CPU1.AK7 CPU1.AK8 CPU1.AK9 CPU1.AK10 CPU1.AK11 CPU1.AK12 CPU1.AK13 CPU1.AK14 CPU1.AK18 CPU1.AK19 CPU1.AK24 CPU1.AK25 CPU1.AK26 CPU1.AK27 CPU1.AK28 CPU1.AK29 CPU1.AK30 CPU1.AK36 CPU1.AL5 CPU1.AL11 CPU1.AL14 CPU1.AL17 CPU1.AL21 CPU1.AL22 CPU1.AL24 CPU1.AL27 CPU1.AL30 CPU1.AL36 CPU1.AL37 CPU1.AL38 CPU1.AL39 CPU1.AL40 CPU1.AM1 CPU1.AM2 CPU1.AM3 CPU1.AM4 CPU1.AM5 CPU1.AM11 CPU1.AM14 CPU1.AM15 CPU1.AM19 CPU1.AM24 CPU1.AM27 CPU1.AM30 CPU1.AM31 CPU1.AM32 CPU1.AM33 CPU1.AM34 CPU1.AM35 CPU1.AM36 CPU1.AN5 CPU1.AN6 CPU1.AN7 CPU1.AN8 CPU1.AN9 CPU1.AN10 CPU1.AN11 CPU1.AN14 CPU1.AN16 CPU1.AN18 CPU1.AN19 CPU1.AN22 CPU1.AN23 CPU1.AN24 CPU1.AN27 CPU1.AN30 CPU1.AN36 CPU1.AN37 CPU1.AN40 CPU1.AP1 CPU1.AP4 CPU1.AP5 CPU1.AP11 CPU1.AP14 CPU1.AP15 CPU1.AP24 CPU1.AP27 CPU1.AP30 CPU1.AP36 CPU1.AR5 CPU1.AR11 CPU1.AR14 CPU1.AR16 CPU1.AR17 CPU1.AR18 CPU1.AR19 CPU1.AR20 CPU1.AR21 CPU1.AR22 CPU1.AR23 CPU1.AR24 CPU1.AR27 CPU1.AR30 CPU1.AR31 CPU1.AR32 CPU1.AR33 CPU1.AR34 CPU1.AR35 CPU1.AR36 CPU1.AR37 CPU1.AR38 CPU1.AR39 CPU1.AR40 CPU1.AT1 CPU1.AT2 CPU1.AT3 CPU1.AT4 CPU1.AT5 CPU1.AT6 CPU1.AT7 CPU1.AT8 CPU1.AT9 CPU1.AT10 CPU1.AT11 CPU1.AT12 CPU1.AT13 CPU1.AT14 CPU1.AT15 CPU1.AT16 CPU1.AT24 CPU1.AT25 CPU1.AT26 CPU1.AT27 CPU1.AT28 CPU1.AT29 CPU1.AT30 CPU1.AT32 CPU1.AT34 CPU1.AT36 CPU1.AT38 CPU1.AT39 CPU1.AU2 CPU1.AU3 CPU1.AU5 CPU1.AU7 CPU1.AU25 CPU1.AU30 CPU1.AU34 CPU1.AU38 CPU1.AU40 CPU1.AV3 CPU1.AV7 CPU1.AV21 CPU1.AV28 CPU1.AV30 CPU1.AV34 CPU1.AV38 CPU1.AV39 CPU1.AW3 CPU1.AW7 CPU1.AW26 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AW38 CPU1.AY3 CPU1.AY5 CPU1.AY7 CPU1.AY17 CPU1.AY23 CPU1.AY26 CPU1.AY27 CPU1.AY30 CPU1.B4 CPU1.B8 CPU1.B10 CPU1.B23 CPU1.B24 CPU1.B26 CPU1.B28 CPU1.B30 CPU1.B32 CPU1.B34 CPU1.B36 CPU1.B38 CPU1.B39 CPU1.C3 CPU1.C4 CPU1.C6 CPU1.C12 CPU1.C14 CPU1.C16 CPU1.C18 CPU1.C19 CPU1.C21 CPU1.C23 CPU1.C36 CPU1.C40 CPU1.D2 CPU1.D5 CPU1.D6 CPU1.D7 CPU1.D9 CPU1.D11 CPU1.D13 CPU1.D15 CPU1.D17 CPU1.D23 CPU1.D24 CPU1.D26 CPU1.D28 CPU1.D30 CPU1.D32 CPU1.D34 CPU1.D36 CPU1.D37 CPU1.D40 CPU1.E3 CPU1.E6 CPU1.E7 CPU1.E8 CPU1.E10 CPU1.E18 CPU1.E20 CPU1.E22 CPU1.E23 CPU1.E36 CPU1.E38 CPU1.F1 CPU1.F4 CPU1.F7 CPU1.F12 CPU1.F14 CPU1.F16 CPU1.F19 CPU1.F21 CPU1.F22 CPU1.F24 CPU1.F26 CPU1.F28 CPU1.F30 CPU1.F32 CPU1.F34 CPU1.F36 CPU1.G3 CPU1.G6 CPU1.G7 CPU1.G9 CPU1.G11 CPU1.G12 CPU1.G13 CPU1.G14 CPU1.G15 CPU1.G16 CPU1.G17 CPU1.G21 CPU1.G36 CPU1.G37 CPU1.H1 CPU1.H4 CPU1.H7 CPU1.H8 CPU1.H9 CPU1.H10 CPU1.H11 CPU1.H13 CPU1.H17 CPU1.H18 CPU1.H20 CPU1.H21 CPU1.H22 CPU1.H24 CPU1.H26 CPU1.H28 CPU1.H30 CPU1.H32 CPU1.H34 CPU1.H36 CPU1.H39 CPU1.J3 CPU1.J6 CPU1.J7 CPU1.J11 CPU1.J14 CPU1.J18 CPU1.J19 CPU1.J20 CPU1.J36 CPU1.J37 CPU1.K1 CPU1.K4 CPU1.K7 CPU1.K10 CPU1.K14 CPU1.K15 CPU1.K16 CPU1.K17 CPU1.K18 CPU1.K20 CPU1.K22 CPU1.K24 CPU1.K26 CPU1.K28 CPU1.K30 CPU1.K32 CPU1.K34 CPU1.K36 CPU1.K40 CPU1.L3 CPU1.L6 CPU1.L7 CPU1.L8 CPU1.L9 CPU1.L11 CPU1.L13 CPU1.L14 CPU1.L35 CPU1.L36 CPU1.L38 CPU1.M1 CPU1.M4 CPU1.M5 CPU1.M6 CPU1.M7 CPU1.M9 CPU1.M12 CPU1.M14 CPU1.M16 CPU1.M18 CPU1.M20 CPU1.M22 CPU1.M24 CPU1.M26 CPU1.M28 CPU1.M30 CPU1.M32 CPU1.M34 CPU1.M35 CPU1.M37 CPU1.M40 CPU1.N1 CPU1.N2 CPU1.N3 CPU1.N4 CPU1.N6 CPU1.N7 CPU1.N8 CPU1.N33 CPU1.N34 CPU1.N39 CPU1.P2 CPU1.P5 CPU1.P7 CPU1.P34 CPU1.P35 CPU1.P38 CPU1.P39 CPU1.P40 CPU1.R3 CPU1.R5 CPU1.R6 CPU1.R7 CPU1.R8 CPU1.R35 CPU1.R37 CPU1.R38 CPU1.R39 CPU1.R40 CPU1.T1 CPU1.T2 CPU1.T4 CPU1.T5 CPU1.T6 CPU1.T7 CPU1.T33 CPU1.T36 CPU1.T37 CPU1.T38 CPU1.T39 CPU1.U2 CPU1.U4 CPU1.U7 CPU1.U33 CPU1.U34 CPU1.U35 CPU1.U36 CPU1.U37 CPU1.V3 CPU1.V6 CPU1.V8 CPU1.V33 CPU1.V34 CPU1.V40 CPU1.W1 CPU1.W4 CPU1.W7 CPU1.W33 CPU1.W35 CPU1.W37 CPU1.Y4 CPU1.Y5 CPU1.Y6 CPU1.Y33 D3.A D5.1 D6.2 D8.A D10.1 D11.1 D12.A D13.A D14.2 D15.2 D17.A D19.A D20.1 D21.1 DB1.2 DIMM1.2 DIMM1.3 DIMM1.8 DIMM1.9 DIMM1.11 DIMM1.13 DIMM1.14 DIMM1.19 DIMM1.20 DIMM1.25 DIMM1.26 DIMM1.28 DIMM1.31 DIMM1.32 DIMM1.37 DIMM1.38 DIMM1.43 DIMM1.44 DIMM1.46 DIMM1.48 DIMM1.49 DIMM1.54 DIMM1.55 DIMM1.60 DIMM1.61 DIMM1.63 DIMM1.65 DIMM1.66 DIMM1.71 DIMM1.72 DIMM1.127 DIMM1.128 DIMM1.133 DIMM1.134 DIMM1.136 DIMM1.138 DIMM1.139 DIMM1.144 DIMM1.145 DIMM1.150 DIMM1.151 DIMM1.153 DIMM1.155 DIMM1.156 DIMM1.161 DIMM1.162 DIMM1.167 DIMM1.168 DIMM1.170 DIMM1.172 DIMM1.173 DIMM1.178 DIMM1.179 DIMM1.184 DIMM1.185 DIMM1.187 DIMM1.189 DIMM1.190 DIMM1.195 DIMM1.196 DIMM1.205 DIMM1.206 DIMM2.2 DIMM2.3 DIMM2.8 DIMM2.9 DIMM2.11 DIMM2.13 DIMM2.14 DIMM2.19 DIMM2.20 DIMM2.25 DIMM2.26 DIMM2.28 DIMM2.31 DIMM2.32 DIMM2.37 DIMM2.38 DIMM2.43 DIMM2.44 DIMM2.46 DIMM2.48 DIMM2.49 DIMM2.54 DIMM2.55 DIMM2.60 DIMM2.61 DIMM2.63 DIMM2.65 DIMM2.66 DIMM2.71 DIMM2.72 DIMM2.127 DIMM2.128 DIMM2.133 DIMM2.134 DIMM2.136 DIMM2.138 DIMM2.139 DIMM2.144 DIMM2.145 DIMM2.150 DIMM2.151 DIMM2.153 DIMM2.155 DIMM2.156 DIMM2.161 DIMM2.162 DIMM2.167 DIMM2.168 DIMM2.170 DIMM2.172 DIMM2.173 DIMM2.178 DIMM2.179 DIMM2.184 DIMM2.185 DIMM2.187 DIMM2.189 DIMM2.190 DIMM2.195 DIMM2.196 DIMM2.205 DIMM2.206 FANC1.1 FANC2.4 H1.1 H2.1 H2.2 H2.3 H2.4 H2.5 H2.6 H2.7 H2.8 H3.1 H4.1 H5.1 H7.1 H7.2 H7.3 H7.4 H7.5 H7.6 H7.7 H7.8 H8.1 H8.2 H8.3 H8.4 H8.5 H8.6 H8.7 H8.8 H11.1 H11.2 H11.3 H11.4 H11.5 H11.6 H11.7 H11.8 H12.1 H12.2 H12.3 H12.4 H12.5 H12.6 H12.7 H12.8 HDD1.1 HDD1.4 HDD1.7 HDD1.8 HDD1.9 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HS1.1 HS2.1 HS3.1 INTRU1.2 LED1.K LED2.K LPC1.12 LPC1.14 LVDS1.17 LVDS1.24 LVDS1.31 LVDS1.32 M1.1 MEM1.A9 MEM1.B1 MEM1.B3 MEM1.B9 MEM1.D1 MEM1.D8 MEM1.E1 MEM1.E2 MEM1.E8 MEM1.F9 MEM1.G1 MEM1.G8 MEM1.G9 MEM1.J2 MEM1.J8 MEM1.M1 MEM1.M9 MEM1.P1 MEM1.P9 MEM1.T1 MEM1.T9 MEM2.A9 MEM2.B1 MEM2.B3 MEM2.B9 MEM2.D1 MEM2.D8 MEM2.E1 MEM2.E2 MEM2.E8 MEM2.F9 MEM2.G1 MEM2.G8 MEM2.G9 MEM2.J2 MEM2.J8 MEM2.M1 MEM2.M9 MEM2.P1 MEM2.P9 MEM2.T1 MEM2.T9 MEM3.A9 MEM3.B1 MEM3.B3 MEM3.B9 MEM3.D1 MEM3.D8 MEM3.E1 MEM3.E2 MEM3.E8 MEM3.F9 MEM3.G1 MEM3.G8 MEM3.G9 MEM3.J2 MEM3.J8 MEM3.M1 MEM3.M9 MEM3.P1 MEM3.P9 MEM3.T1 MEM3.T9 MEM4.A9 MEM4.B1 MEM4.B3 MEM4.B9 MEM4.D1 MEM4.D8 MEM4.E1 MEM4.E2 MEM4.E8 MEM4.F9 MEM4.G1 MEM4.G8 MEM4.G9 MEM4.J2 MEM4.J8 MEM4.M1 MEM4.M9 MEM4.P1 MEM4.P9 MEM4.T1 MEM4.T9 MEMCD1.3 MEMCD1.6 MEMCD1.12 MEMCD1.13 NGFF1.7 NGFF1.18 NGFF1.23 NGFF1.24 NGFF1.29 NGFF1.30 NGFF1.33 NGFF1.36 NGFF1.39 NGFF1.45 NGFF1.57 NGFF1.63 NGFF1.69 NGFF1.75 NGFF1.76 NGFF1.77 ODD1.1 ODD1.4 ODD1.7 ODD1.8 ODD1.9 PC2.1 PC12.2 PC17.2 PC18.2 PC22.2 PC23.1 PC24.2 PC25.2 PC26.2 PC28.1 PC29.2 PC32.2 PC34.2 PC35.2 PC36.2 PC38.1 PC39.2 PC40.2 PC41.2 PC42.2 PC43.2 PC47.2 PC48.2 PC50.2 PC52.2 PC53.2 PC54.2 PC55.2 PC61.2 PC62.1 PC63.2 PC64.2 PC65.2 PC66.2 PC67.2 PC68.2 PC69.2 PC70.2 PC71.2 PC73.1 PR2.2 PR3.2 PR7.2 PR22.2 PR24.2 PR26.2 PR29.1 PR31.2 PR33.2 PR36.2 PR38.2 PR40.2 PR68.2 PR74.1 PR84.2 PR85.2 PR86.2 PR88.2 PSWD1.1 PT1.2 PT2.2 PT3.2 PT4.2 PTC1.2 PTC2.2 PU3.1 PU3.2 PU3.3 PU4.1 PU4.2 PU4.3 PU5.1 PU6.21 PWRCN1.7 Q3.S Q5.1 Q5.2 Q5.3 Q6.1 Q6.2 Q6.3 Q7.E Q9.1 Q9.4 Q11.1 Q11.4 Q13.1 Q13.2 Q13.3 Q14.E Q15.E Q16.1 Q16.2 Q16.3 Q17.1 Q17.2 Q17.3 Q18.1 Q18.2 Q18.3 Q19.E Q20.E Q22.E Q27.1 Q27.2 Q27.3 Q28.1 Q28.2 Q28.3 Q36.E Q38.E Q39.1 Q39.2 Q39.3 Q42.3 Q44.1 Q45.4 Q48.E Q49.S Q54.1 Q54.4 Q55.S Q56.S Q59.E Q60.S Q62.1 Q63.S Q64.1 Q64.2 Q64.3 Q66.1 Q66.4 Q67.E Q68.E Q69.S Q70.E Q71.S Q72.S Q73.S Q74.4 Q76.S Q79.S Q81.1 Q81.2 Q81.3 Q83.S Q85.3 Q86.4 Q87.1 Q89.E Q90.S Q91.S Q97.3 Q98.S Q99.S Q100.S Q101.1 Q103.S Q104.1 Q104.4 Q105.E Q107.S Q108.E Q110.1 Q110.4 Q113.S Q114.E Q118.S Q119.S Q120.S Q121.S Q122.S Q126.E Q127.E Q128.E Q129.S QF1.1 QF1.4 R1.2 R4.2 R18.2 R36.2 R39.2 R51.2 R58.1 R63.2 R64.2 R67.2 R69.2 R70.2 R78.2 R93.2 R95.2 R99.1 R101.2 R102.2 R119.2 R139.2 R145.2 R146.2 R147.2 R156.2 R163.2 R167.2 R175.2 R202.1 R206.2 R213.2 R214.2 R217.2 R218.2 R226.2 R229.1 R231.2 R233.2 R236.2 R243.2 R245.2 R249.1 R252.2 R254.2 R255.2 R274.2 R280.2 R282.1 R294.2 R296.2 R299.1 R304.2 R307.1 R308.1 R314.2 R318.2 R320.1 R321.2 R335.2 R342.2 R343.2 R349.2 R356.2 R362.2 R368.1 R387.1 R394.2 R400.2 R408.1 R412.2 R423.2 R424.2 R425.2 R430.2 R432.2 R433.2 R442.2 R443.2 R444.2 R452.2 R455.2 R458.2 R464.2 R471.1 R474.2 R475.2 R478.2 R489.2 R497.2 R509.1 R519.2 R520.2 R528.2 R542.2 R543.1 R544.2 R552.2 R554.2 R555.1 R557.2 R558.2 R560.1 R561.2 R575.2 R591.2 R597.2 R601.2 R605.1 R606.1 R609.1 R614.1 R635.2 R640.2 R641.2 R643.1 R653.2 R654.2 R655.2 R657.2 R660.2 R662.2 R666.2 R668.2 R688.2 R695.2 R699.1 R700.2 R708.2 R713.2 R718.2 R719.2 R721.2 R722.2 R723.2 R728.2 R731.2 R732.2 R733.2 R734.2 R735.2 R736.2 R748.2 R751.2 R752.2 R753.2 R754.2 R755.2 R758.2 R759.1 R760.2 R765.2 R768.2 R775.2 R776.2 R777.2 R795.2 R796.2 R800.2 R802.2 R804.2 R820.2 R821.2 R822.2 R827.1 R828.2 R829.2 R847.2 R848.2 R851.2 R852.2 R855.2 R858.2 R859.2 R861.1 R870.1 R871.2 R877.2 R886.1 R889.2 R890.2 R891.2 R892.2 R893.2 R899.1 R902.1 R914.1 R915.2 R916.2 R924.1 R936.2 R938.2 R939.2 R940.2 R946.1 R948.2 R951.1 R953.1 R960.1 R961.1 R963.2 R973.2 R977.2 R978.2 R980.2 R981.2 R986.2 R987.2 R990.2 R1008.2 R1025.2 R1029.2 R1041.2 R1042.2 R1052.2 R1055.2 R1058.2 R1064.2 R1066.2 R1069.2 R1070.2 R1072.1 R1075.2 R1079.2 R1137.2 R1149.2 R1157.2 R1158.1 R1185.2 R1190.2 R1191.2 R1193.2 R1197.2 R1198.2 R1201.1 R1205.2 R1206.2 R1207.2 R1208.2 R1209.2 R1210.1 R1220.1 R1230.1 R1231.1 RJ1.15 RJ1.16 RR1.2 SATAP1.2 SATAP1.4 SPK1.5 SPK1.7 SPK1.8 SPR1.1 SRCON1.4 SSUSB1.4 SSUSB1.7 SSUSB1.10 SSUSB1.11 SSUSB2.4 SSUSB2.7 SSUSB2.10 SSUSB2.11 TC1.2 TC2.2 TC3.2 TC4.2 TC5.2 TC6.2 TC7.2 TC8.2 TC9.2 TC10.2 TC11.2 TC12.2 TC13.2 TC14.2 TC15.2 TC16.2 TC18.2 TC19.2 TC20.2 TC21.2 TC22.2 TC23.2 TOUCH1.2 TOUCH2.2 U1.1 U1.2 U1.4 U1.7 U2.1 U2.2 U2.4 U2.7 U3.11 U4.1 U4.4 U5.6 U5.9 U9.22 U9.27 U10.3 U10.8 U11.3 U11.8 U12.4 U13.A3 U13.A30 U13.AA11 U13.AA13 U13.AA16 U13.AA27 U13.AB6 U13.AB10 U13.AB15 U13.AB24 U13.AB32 U13.AC9 U13.AC17 U13.AC24 U13.AC26 U13.AC27 U13.AD6 U13.AD8 U13.AD25 U13.AD32 U13.AE7 U13.AE14 U13.AE27 U13.AF32 U13.AG12 U13.AG27 U13.AH10 U13.AH28 U13.AH32 U13.B6 U13.B8 U13.B10 U13.B12 U13.B14 U13.B16 U13.B18 U13.B20 U13.B22 U13.B24 U13.B26 U13.C1 U13.C32 U13.E28 U13.F2 U13.F6 U13.F8 U13.F10 U13.F12 U13.F14 U13.F16 U13.F18 U13.F20 U13.F22 U13.F24 U13.F26 U13.G8 U13.G10 U13.G27 U13.G31 U13.H2 U13.H6 U13.H14 U13.H17 U13.H20 U13.J7 U13.J27 U13.J31 U13.K2 U13.K6 U13.K11 U13.K22 U13.K28 U13.K32 U13.L27 U13.M6 U13.M12 U13.M32 U13.N11 U13.N13 U13.N16 U13.N18 U13.N21 U13.N25 U13.N27 U13.P6 U13.P9 U13.P25 U13.P32 U13.R11 U13.R12 U13.R15 U13.R17 U13.R20 U13.R27 U13.T6 U13.T11 U13.T13 U13.T16 U13.T18 U13.T21 U13.T25 U13.T32 U13.U9 U13.U15 U13.U17 U13.U20 U13.U25 U13.U27 U13.V11 U13.V13 U13.V16 U13.V18 U13.V32 U13.W25 U13.W26 U13.W27 U13.Y10 U13.Y15 U13.Y17 U13.Y20 U13.Y25 U13.Y32 U14.2 U15.11 U16.49 U17.6 U17.9 U18.1 U20.5 U20.11 U21.4 U22.4 U22.11 U22.18 U23.4 U23.11 U23.18 U24.1 U24.3 U24.17 U24.18 U24.35 U24.40 U24.59 U24.66 U24.82 U24.83 U24.86 U24.88 U24.90 U24.117 U25.8 U25.9 U25.10 U25.17 U25.20 U25.21 U25.24 U25.33 U26.33 U27.3 U27.8 U28.2 U29.A12 U29.A16 U29.A21 U29.A35 U29.AA5 U29.AA8 U29.AA10 U29.AA11 U29.AA12 U29.AA14 U29.AA17 U29.AA22 U29.AA28 U29.AA30 U29.AA34 U29.AB4 U29.AB14 U29.AB28 U29.AC5 U29.AC8 U29.AC30 U29.AC31 U29.AC34 U29.AC38 U29.AD14 U29.AD26 U29.AD28 U29.AE4 U29.AE8 U29.AE12 U29.AE31 U29.AE41 U29.AF3 U29.AF14 U29.AF16 U29.AF17 U29.AF28 U29.AG2 U29.AG4 U29.AG8 U29.AG30 U29.AG34 U29.AG38 U29.AH14 U29.AH16 U29.AJ1 U29.AJ28 U29.AK9 U29.AK24 U29.AK37 U29.AL5 U29.AL11 U29.AL37 U29.AM4 U29.AM6 U29.AM8 U29.AM14 U29.AM16 U29.AM18 U29.AM20 U29.AM24 U29.AM26 U29.AM35 U29.AM38 U29.AN28 U29.AP4 U29.AP9 U29.AR11 U29.AR35 U29.AR37 U29.AT1 U29.AT7 U29.AT8 U29.AT10 U29.AT11 U29.AT14 U29.AT15 U29.AT16 U29.AT18 U29.AT20 U29.AT21 U29.AT23 U29.AT24 U29.AT28 U29.AT29 U29.AT33 U29.AT36 U29.AT38 U29.AT41 U29.AU1 U29.AU3 U29.AU39 U29.AV1 U29.AV2 U29.AV12 U29.AV17 U29.AV21 U29.AV33 U29.AV40 U29.AV41 U29.AW2 U29.AW7 U29.AW30 U29.AW40 U29.B3 U29.B25 U29.B30 U29.B33 U29.B38 U29.B40 U29.B41 U29.C6 U29.C25 U29.C37 U29.C41 U29.D1 U29.D4 U29.D6 U29.D7 U29.D8 U29.D9 U29.D12 U29.D13 U29.D14 U29.D16 U29.D18 U29.D19 U29.D20 U29.D22 U29.D24 U29.D25 U29.D26 U29.D27 U29.D28 U29.D31 U29.D32 U29.D34 U29.D37 U29.D41 U29.E3 U29.E4 U29.E5 U29.E7 U29.E12 U29.E31 U29.E35 U29.E38 U29.F18 U29.F24 U29.F35 U29.F37 U29.F38 U29.G2 U29.H4 U29.H6 U29.H8 U29.H9 U29.H14 U29.H16 U29.H20 U29.H22 U29.H26 U29.H28 U29.H33 U29.H34 U29.H38 U29.J5 U29.J31 U29.J37 U29.K4 U29.K9 U29.K31 U29.L37 U29.L41 U29.M16 U29.M18 U29.M20 U29.M22 U29.M24 U29.M26 U29.M28 U29.N4 U29.N8 U29.N31 U29.N35 U29.N38 U29.R1 U29.R8 U29.R10 U29.R34 U29.T17 U29.T22 U29.T23 U29.T25 U29.T26 U29.T28 U29.U1 U29.U4 U29.U8 U29.U31 U29.U32 U29.V26 U29.V28 U29.V38 U29.V40 U29.W3 U29.W5 U29.W8 U29.W12 U29.W20 U29.W22 U29.W28 U29.Y1 U29.Y41 U30.2 U31.3 U31.8 U33.3 U33.8 U35.33 U37.6 U37.49 U38.6 U38.9 U39.33 U41.2 U41.9 U43.2 U44.2 U46.2 U47.1 U47.2 U49.4 UHS1.7 UHS1.8 USB3.4 USB3.5 USB3.6 USB4.4 USB4.5 USB4.6 USB5.4 USB5.5 USB5.6 USB6.4 USB6.5 USB6.6 VGA1.5 VGA1.6 VGA1.7 VGA1.8 VGA1.10 VGA1.16 VGA1.17 WEBCM1.6 WEBCM1.8 WEBCM1.9 WEBCM1.10 X3.2 X3.4 X4.2 X4.4 X5.2 X5.4 XDPC1.1 XDPC1.2 XDPC1.7 XDPC1.8 XDPC1.13 XDPC1.14 XDPC1.19 XDPC1.20 XDPC1.25 XDPC1.26 XDPC1.31 XDPC1.32 XDPC1.37 XDPC1.38 XDPC1.49 XDPC1.50 XDPC1.59
GND_AUD: C184.1 C187.2 U16.40
V5_ALW_MON: Q104.3 R1022.2 R1025.1 U24.15
V5_ALW_MON_1: Q104.5 Q104.6 R1046.2
V5_ALW_MON_2: C685.1 Q104.2 R1041.1 R1047.2
VBAT1: BT1.1 BTPWR1.2 R1225.1
VBAT1_C: BTPWR1.1 R31.1 R1225.2
VBAT1_R: D1.A D2.2 R31.2 TP1.1
VBAT2: C272.1 D1.K R518.1 U24.21
VCC: C263.1 C264.1 C266.1 C340.2 C402.1 C713.1 C714.2 C715.1 C720.1 D22.A D23.A F1.1 F13.2 F14.2 FANC2.3 LPC1.8 M1.6 PR11.1 PR44.2 PR95.1 Q61.G Q82.1 Q82.2 Q82.3 Q88.G Q111.4 R105.1 R113.2 R150.1 R160.1 R295.1 R311.1 R491.1 R503.1 R504.1 R631.2 R660.1 R689.2 R694.1 R729.1 R896.1 R1221.2 RR1.1 U35.21 U36.1 U36.2 U36.5 U36.6
VCC3: C88.1 C92.2 C93.1 C94.1 C97.2 C100.1 C108.2 C178.1 C182.1 C303.1 C306.2 C310.2 C469.1 C470.1 C472.1 C474.1 C550.1 C560.1 C584.1 C646.1 C647.1 C648.1 C649.1 C650.1 C652.1 C653.1 C655.1 C656.1 C657.1 C660.1 C661.2 C664.1 C666.1 C692.1 C693.1 C704.1 C707.1 C729.1 D5.2 D9.K D11.2 D16.K D20.2 D21.2 DIMM1.199 DIMM2.199 F7.1 L2.1 L4.1 L7.1 L33.1 LPC1.4 PC41.1 PR70.1 PU5.5 PU5.9 Q51.S Q78.1 Q78.2 Q78.3 Q84.G Q109.4 R30.1 R32.1 R33.1 R35.1 R37.1 R44.1 R49.1 R54.1 R60.1 R68.1 R75.1 R83.1 R90.1 R92.1 R152.1 R165.1 R166.1 R171.1 R172.1 R176.1 R186.1 R189.1 R192.2 R205.1 R211.1 R220.2 R222.1 R234.1 R235.1 R237.2 R238.2 R242.1 R247.1 R264.2 R266.2 R268.1 R270.2 R271.2 R272.1 R284.1 R322.1 R334.1 R340.2 R346.1 R350.2 R355.2 R357.2 R361.1 R367.2 R373.2 R374.1 R378.2 R381.1 R384.1 R413.1 R427.1 R437.1 R438.1 R441.1 R450.2 R460.1 R461.2 R470.1 R476.1 R479.1 R483.2 R494.1 R505.2 R508.1 R512.1 R521.2 R534.1 R537.1 R565.1 R566.1 R567.1 R569.2 R574.1 R579.1 R600.2 R623.1 R626.1 R633.1 R642.1 R647.1 R705.1 R726.1 R727.1 R738.2 R811.1 R817.1 R818.1 R819.1 R849.2 R850.1 R863.1 R869.2 R872.1 R888.1 R913.1 R918.2 R919.2 R962.2 R985.1 R991.1 R992.2 R993.1 R995.1 R997.1 R998.1 R1011.1 R1030.1 R1037.1 R1049.1 R1057.1 R1061.1 R1076.1 R1078.2 R1079.1 R1080.2 R1081.1 R1082.1 R1153.2 R1156.1 R1227.2 R1228.2 RN2.5(B) RN2.6(B) RN2.7(B) RN2.8(B) RN6.5(B) RN6.6(B) RN6.7(B) RN6.8(B) RN7.5(B) RN7.6(B) RN7.7(B) RN7.8(B) U1.3 U1.8 U2.3 U2.8 U16.11 U21.6 U22.10 U22.19 U22.24 U23.10 U23.19 U23.24 U24.4 U29.AF26 U29.AG1 U29.AG12 U29.AK11 U29.AM7 U29.AM9 U29.AP5 U29.AP7 U29.AR4 U29.AT5 U29.AV3 U29.AV4 U29.AW3 U29.AW4 U29.AW9 U29.U30 U29.W30 U32.2 U32.5 U34.2 U34.5 U39.10 U39.12 U39.18
VCC3_3SB_EN_2: C679.2 D19.K Q58.G Q125.G R1020.2 R1023.2 R1026.2 R1035.2 R1044.2
VCC3_CAM: C396.1 C397.1 C840.1 F6.2 F7.2 R703.2 R705.2 WEBCM1.3
VCC3_HDD: R284.2 SATAP1.5
VCC5_DDC_HDMI: C335.2 D23.K R583.1 R599.1
VCC5_PANEL: C14.1 C15.1 C17.1 F8.2 LVDS1.28 LVDS1.29 R43.1 R45.1 R46.1 R709.2 R1120.1
VCC5_USB: C292.2 C298.1 C311.1 F3.1 F4.1 F5.1 F11.1 Q75.1 Q75.2 Q75.3 R557.1 R558.1 R575.1 R602.1 R859.1 R1071.2
VCC5SB_EN_2: C681.1 C683.1 Q112.G R1035.1 R1038.2
VCC12: PR72.1 PR92.1 PR109.1 R1223.1 R1224.1
VCC12_FAN: C421.1 F9.2 FANC1.2 R798.2 R806.1
VCC12_HDD: C129.1 F12.2 R193.2 R194.2 SATAP1.1
VCC12_HDD_C: C479.1 F12.1 PR108.2 PR109.2 R193.1 R194.1
VCC12CPU: ATX1.3 ATX1.4 C16.1 C37.1 C45.1 C51.1 C52.1 C56.1 C836.1 Q8.5 Q8.6 Q8.7 Q8.8 Q12.5 Q12.6 Q12.7 Q12.8 Q21.5 Q21.6 Q21.7 Q21.8 Q23.5 Q23.6 Q23.7 Q23.8 Q24.5 Q24.6 Q24.7 Q24.8 Q25.5 Q25.6 Q25.7 Q25.8 R109.2 R110.2 R677.1 R814.2 R815.2 R816.2 R1059.1 TC3.1 TC9.1
VCC_SENSE: CPU1.E40 R71.1 R651.1 R652.1
VCCIO2PCH: CPU1.AB8 R823.2
VCCST: C440.1 C452.1 CPU1.K9 R823.1 R824.2
VCCST_PWRGD: CPU1.Y7 R162.2 R163.1
VDDC_CT: C779.1 C780.1 C781.1 L48.2 U13.AA20 U13.AA21 U13.AB20 U13.AB21
VIN12V_SYS: PC42.1 PC43.1 PC52.1 PC53.1 PC68.1 PC69.1 PC70.1 PC71.1 PL4.2 PL5.2 PL6.2 PL7.2 PR117.1 PU6.11 Q65.5 Q65.6 Q65.7 Q65.8 Q77.5 Q77.6 Q77.7 Q77.8 TC21.1
VIN_DET: C675.2 R1008.1 R1010.2 U24.46
VSS_MECH: U13.A32 U13.AM1 U13.AM32
VSS_SENSE: C375.2 CPU1.F40 R71.2 R653.1 R656.2
0D95V_VGA: PC21.2 PC28.2 PC29.1 PR63.2 PR65.1 PR66.1 PR67.1 Q40.S TC16.1
0D95V_VGA_DRV: PC31.1 PR54.2 PR64.1 U14.5
0D95V_VGA_DRV_1: PC21.1 PR54.1 Q40.G
0D95V_VGA_EN: PC25.1 PR61.2 R1229.2 U14.1
0D95V_VGA_FB: PC27.2 PC30.2 PC31.2 PR68.1 PR69.2 U14.3
0D95V_VGA_FB_1: PC30.1 PR64.2
0D95V_VGA_FB_2: PR62.1 PR63.1 PR69.1
0D95V_VGA_FB_3: PC27.1 PR62.2
0D95V_VGA_S0: C798.1 C799.1 C800.1 C801.1 C802.1 C803.1 C804.1 L51.1 L53.1 PR65.2 PR66.2 PR67.2 R1161.2 R1162.2 U13.L23 U13.L24 U13.L25 U13.L26 U13.M22 U13.N22 U13.N23 U13.N24 U13.R21 U13.R22 U13.T22 U13.U21 U13.U22 U13.V22
0D95V_VGA_SS: PC32.1 U14.4
1D05V_DRVH: R208.2 U15.9
1D05V_DRVH_R: Q41.4 R208.1
1D05V_DRVL: Q39.4 U15.6
1D05V_EN: R207.2 U15.3
1D05V_PWR: C130.1 L11.2 PC33.1 R195.1 R196.1 R197.1 R198.1 R199.1 R212.1 TC14.1
1D05V_RF: R214.1 U15.5
1D05V_SB: C128.1 R187.2
1D05V_SW: C141.1 L11.1 Q39.5 Q39.6 Q39.7 Q39.8 Q41.1 Q41.2 Q41.3 R187.1 U15.8
1D05V_TRIP: R861.2 U15.2
1D05V_V5IIN: C157.1 R210.2 U15.7
1D05V_VBST: R200.1 U15.10
1D05V_VBST_R: C141.2 R200.2
1D05V_VFB: PC33.2 R212.2 R213.1 U15.4
1D5V_VGA_S0: C131.1 C132.1 C142.1 C186.1 C192.1 C211.1 C214.1 C216.1 C223.1 C486.1 C489.1 C500.1 C514.1 C516.1 C540.1 C554.1 C557.1 C583.1 C612.1 C616.1 C623.1 C627.1 C765.1 C766.1 C767.1 C768.1 C769.1 C770.1 C771.1 C772.1 C773.1 C774.1 C775.1 C776.1 C777.1 C778.1 MEM1.A1 MEM1.A8 MEM1.B2 MEM1.C1 MEM1.C9 MEM1.D2 MEM1.D9 MEM1.E9 MEM1.F1 MEM1.G7 MEM1.H2 MEM1.H9 MEM1.K2 MEM1.K8 MEM1.N1 MEM1.N9 MEM1.R1 MEM1.R9 MEM2.A1 MEM2.A8 MEM2.B2 MEM2.C1 MEM2.C9 MEM2.D2 MEM2.D9 MEM2.E9 MEM2.F1 MEM2.G7 MEM2.H2 MEM2.H9 MEM2.K2 MEM2.K8 MEM2.N1 MEM2.N9 MEM2.R1 MEM2.R9 MEM3.A1 MEM3.A8 MEM3.B2 MEM3.C1 MEM3.C9 MEM3.D2 MEM3.D9 MEM3.E9 MEM3.F1 MEM3.G7 MEM3.H2 MEM3.H9 MEM3.K2 MEM3.K8 MEM3.N1 MEM3.N9 MEM3.R1 MEM3.R9 MEM4.A1 MEM4.A8 MEM4.B2 MEM4.C1 MEM4.C9 MEM4.D2 MEM4.D9 MEM4.E9 MEM4.F1 MEM4.G7 MEM4.H2 MEM4.H9 MEM4.K2 MEM4.K8 MEM4.N1 MEM4.N9 MEM4.R1 MEM4.R9 Q57.1 Q57.2 Q57.3 R203.2 R230.2 R309.2 R885.2 R928.2 R945.2 R957.2 R959.2 R1199.1 R1200.1 R1204.1 TC20.1 U13.H13 U13.H16 U13.H19 U13.J9 U13.J10 U13.J23 U13.J24 U13.K9 U13.K10 U13.K23 U13.K24 U13.L11 U13.L12 U13.L13 U13.L20 U13.L21 U13.L22
1D8V_VGA: PC37.2 PC39.1 PC40.1 PR76.1 PR77.2 PU5.3 PU5.4
1D8V_VGA_EN: PC35.1 PR78.2 PU5.8
1D8V_VGA_FB: PC37.1 PR74.2 PR77.1 PU5.2
1D8V_VGA_POK: PU5.7 R427.2
1D8V_VGA_S0: C794.1 C795.1 C796.1 C797.1 L47.1 L48.1 L49.1 L50.1 L52.1 PR76.2 R303.2 R388.2 R935.1 R943.2 R1211.2 U13.AM30
1P05_PCH_EN: PC34.1 PR70.2 Q45.3 R207.1
1P5_PCH_EN: M1.8 R468.1
1P05_PCH_EN_Q48: C154.1 Q44.2 R204.2 R205.2 R206.1
1P05_PCH_EN_Q48_R: PR71.2 Q44.6 Q45.5
1P5_PCH_EN_R: Q100.D R465.2
1P05_PCH_EN_R: Q99.D R1003.2
1P5_PCH_EN_R_1: C257.1 R465.1 R468.2 R470.2
1P5_PCH_FB: C261.2 M1.2 R464.1 R477.1
1P5_PCH_PWR: C261.1 C265.1 C667.1 C673.1 M1.3 M1.4 R462.2 R477.2
1P5_PCH_VCC3: C270.1 M1.5 M1.9 R512.2
3D3V_PWR: PC67.1 PG5.2 PL2.1 PR81.1 PTC1.1 R1000.1 R1002.1 R1005.2 R1013.1
3D3V_VGA_S0: C753.1 C782.1 C783.1 C784.1 PR4.1 PR6.1 PR15.1 PR19.1 PR61.1 PR94.1 PR96.1 PR97.1 PR100.1 PR102.1 PR103.1 PR104.1 Q51.D Q123.2 Q123.5 R302.2 R396.2 R397.2 R398.2 R399.2 R403.1 R1159.2 R1167.1 R1184.1 R1186.1 R1187.1 RN9.3(B) RN9.4(B) U13.AA17 U13.AA18 U13.AB17 U13.AB18 U49.3 U49.7 U49.8
3D3V_VGA_S0_EN: C249.1 Q54.2 R437.2
3D3VSB: PC66.1 PR115.2
100M_DMI_PCH_DN: R977.1 U29.G22
100M_DMI_PCH_DP: R973.1 U29.F22
1589_BOOT: R371.1 U20.1
1589_BT1: C212.1 D18.2 R371.2
1589_COMP: C236.1 Q98.D R417.1 U20.7
1589_CP1: C238.1 R417.2
1589_FB: C236.2 C238.2 C242.2 R412.1 R418.1 U20.8
1589_FB1: C242.1 R420.2
1589_LG: R358.2 R362.1 U20.4
1589_LG12: R358.1 U18.2
1589_LX: C212.2 L14.1 R348.1 R952.1 U18.3 U18.7 U18.8 U20.2
1589_LX1_SNB: C601.1 R952.2
1589_PGOOD: C226.1 R384.2 R590.1 U20.10
1589_UG: R359.2 U20.3
1589_UG1: R348.2 R359.1 U18.4
1589_VCC: C228.1 R979.2 U20.6
1589_VOS: C229.1 R400.1 R410.2 U20.9
2136_HPD_C: R730.2 R738.1 R739.2 R748.1
62882_COMP_R: PC6.2 PR8.1
62882_FB_VSEN: PC11.1 PR20.2
62882_NTC_R: PR5.2 PR60.1
62883AGND: PC5.1 PC9.2 PC20.1 PC56.2 PC57.2 PC58.2 PC60.1 PR1.1 PR2.1 PR5.1 PR9.2 U9.40 U9.41
81102_COMP: C380.2 C382.1 R673.2 U35.28
81102_COMP_1: C378.2 R661.1
81102_COMP_2: C382.2 R670.1 R673.1
81102_CSCCOMP: C383.2 C386.1 R52.2 R675.2 R683.1 U35.24
81102_CSCM_1: R52.1 R683.2 R686.2
81102_CSREF: C389.1 R681.2 R682.2 R684.2 U35.22
81102_CSSUM: C383.1 C386.2 R686.1 R687.2 R692.2 R693.2 U35.23
81102_DIFF: R661.2 R665.2 U35.30
81102_FB: C378.1 C380.1 R665.1 R668.1 R670.2 U35.29
81102_ILIM: R675.1 U35.25
81102_IOUT: C390.1 R688.1 R689.1 U35.26
81102_RAMP: C385.1 R677.2 U35.27
81102_TSENSE: C369.1 R650.1 U35.8
81102_TSENSE_R: R39.1 R635.1 R650.2
81102_VCC: C372.1 R631.1 U35.2
81102_VSN: C377.1 R656.1 U35.31
81102_VSP: C375.1 R651.2 U35.32
+VGA_CORE_PHASE1: PG3.1 PR47.2
A20GATE: R918.1 U24.119 U29.N30
AD+_2: C451.2 R822.1 R825.2 U6.4 U40.4
ADAPTOR_PSID: D5.3 R151.2 R152.2 U29.AV8
ADAPTOR_PSID_R: Q37.S R151.1
AMD_RST#: C752.1 R1160.1 U13.AL27
AMP_SPKR_L: C274.1 R511.2 R1233.1
AMP_SPKR_R: C287.1 R526.2 R1234.1
APL5336_VCNTL: C482.1 R860.1 U41.6
ATX_ON*: ATX2.8 C115.1 R157.2 R159.2
AUD_BEEP_C: C166.2 U16.2
AUD_BEEP_R: C166.1 R227.2 R228.2 R245.1
AUD_DMIC_CLK: C161.1 L54.2 WEBCM1.4
AUD_DMIC_CLK_R: R246.1 U16.12
AUD_DMIC_CLK_R_1: L54.1 R246.2
AUD_DMIC_DATA: C167.2 R263.2 WEBCM1.5
AUD_DMIC_DATA_R: R263.1 U16.13
AUD_DVDD: C164.1 C168.1 R221.2 R222.2 U16.7
AUD_GP3: R247.2 U16.3
AUD_LINK_BCLK: C162.2 R392.1 U16.5
AUD_LINK_BCLK_R: R392.2 U29.AV23
AUD_LINK_RST_N: R375.1 R389.1 U16.6
AUD_LINK_RST_N_2: Q62.4 Q62.6
AUD_LINK_RST_N_R: C219.1 Q49.G R375.2
AUD_LINK_RST_R_N: R389.2 U29.AU24
AUD_LINK_SDIN: R244.1 U29.AT22
AUD_LINK_SDIN_1: R244.2 U16.8
AUD_LINK_SDO: C533.2 Q96.D R395.1 R897.2
AUD_LINK_SDO_1: C533.1 Q96.G R896.2
AUD_LINK_SDO_N: Q96.S R897.1 U16.4
AUD_LINK_SDO_R: Q52.C R395.2 R407.2 R415.2 U29.AU22
AUD_LINK_SDO_R1: MEJ1.2 R407.1
AUD_LINK_SYNC: R379.1 U16.9
AUD_LINK_SYNC_R: R379.2 R383.2 U29.AV24
AUD_REGREF: C165.1 U16.10
BIST_DISABLE: R91.1 R92.2 R93.1 U29.AH26
BIST_DISABLE_1: Q19.B R91.2
BIST_EN: Q14.B Q19.C Q20.C R83.2
BIST_EN_INV: Q14.C Q15.C R70.1 R75.2 U37.2
BIST_ENABLE: R81.1 U29.AC36
BIST_ENABLE_1: Q15.B R78.1 R81.2 R82.2
BKLT_ADJ: C123.1 CONVT1.9 R169.2
BKLT_EN: C124.1 CONVT1.10 Q38.C R172.2 R174.2
BKLT_EN1: Q38.B R173.2
BLUE_CRT: C351.1 L20.2 U43.1 VGA1.3
BOARD_A: R235.2 R236.1 U29.M37
BOARD_B: R231.1 R232.2 U29.AA40
BOARD_C: R334.2 R343.1 U29.AT30
BOOT1_PHASE1: PC19.2 PR43.2
BUZZER_SPKR_R: C278.1 R227.1
CAP_1: C308.1 U24.128
CASA0#: MEM1.K3 MEM3.K3 U13.G19
CASA1#: MEM2.K3 MEM4.K3 U13.G16
CBN: C196.2 U16.21
CBP: C196.1 U16.24
CK_14M_FLEX: R434.2 U29.AU8
CK_14M_PCH: R432.1 U29.AR7
CK_14M_SIO: R446.1 U24.7
CK_14M_TPM: R434.1 U22.13 U23.13
CK_33M_PCI0: C865.2 R439.2 U29.AV5
CK_33M_PCI1: C866.2 R447.2 U29.AV7
CK_33M_PCI2: C867.2 R994.2 U29.AU2
CK_33M_PCI3: C868.2 R989.2 U29.AN9
CK_33M_PCI4: TP25.1 U29.AU5
CK_96M_DREF_DN: R986.1 U29.AP11
CK_96M_DREF_DP: R981.1 U29.AM11
CK_100M_CPU_XDP_DN: R637.1 U29.U6
CK_100M_CPU_XDP_DP: R636.1 U29.U7
CK_CSI_PCH_IN_DN: R980.1 U29.G16
CK_CSI_PCH_IN_DP: R978.1 U29.F16
CK_DP_DN: CPU1.U5 U29.T3
CK_DP_DP: CPU1.U6 U29.T5
CK_DPNS_R_DN: CPU1.W6 U29.W2
CK_DPNS_R_DP: CPU1.W5 U29.U2
CK_GLAN_DN: U26.16 U29.W11
CK_GLAN_DP: U26.15 U29.W10
CK_M_DDR0_A_DN: CPU1.AY16 DIMM1.103
CK_M_DDR0_A_DP: CPU1.AY15 DIMM1.101
CK_M_DDR0_B_DN: CPU1.AM21 DIMM2.103
CK_M_DDR0_B_DP: CPU1.AM20 DIMM2.101
CK_M_DDR1_A_DN: CPU1.AV15 DIMM1.104
CK_M_DDR1_A_DP: CPU1.AW15 DIMM1.102
CK_M_DDR1_B_DN: CPU1.AP21 DIMM2.104
CK_M_DDR1_B_DP: CPU1.AP22 DIMM2.102
CK_P_33M_LPCP80: LPC1.1 R439.1
CK_P_33M_SIO: R989.1 U24.16
CK_P_33M_TPM: R447.1 U22.21 U23.21
CK_PCH_33M_FB: R994.1 U29.AM22
CK_PE_100M_16PORT_DN: U13.AK32 U29.AA3
CK_PE_100M_16PORT_DP: U13.AK30 U29.AA2
CK_PE_100M_MCP_DN: CPU1.V4 U29.R2
CK_PE_100M_MCP_DP: CPU1.V5 U29.T2
CK_SATA_PCH_DN: R939.1 U29.H35
CK_SATA_PCH_DP: R938.1 U29.H36
CK_XDP_S_DN: R637.2 XDPC1.42
CK_XDP_S_DP: R636.2 XDPC1.40
CKEA0: MEM1.K9 MEM3.K9 U13.K20
CKEA1: MEM2.K9 MEM4.K9 U13.J17
CLINK_CLK_LAN: R7.1 U29.U36
CLINK_CLK_LAN_1: NGFF1.42 R7.2
CLINK_DATA_LAN: R5.1 U29.U35
CLINK_DATA_LAN_1: NGFF1.40 R5.2
CLINK_RST_LAN_N: R3.1 U29.U34
CLINK_RST_LAN_N_1: NGFF1.38 R3.2
CLKA0: MEM1.J7 MEM3.J7 R209.1 U13.H26
CLKA0#: MEM1.K7 MEM3.K7 R215.1 U13.H25
CLKA1: MEM2.J7 MEM4.J7 R352.1 U13.G9
CLKA1#: MEM2.K7 MEM4.K7 R341.1 U13.H9
CLKBUF_EN: C248.2 R438.2 U21.2
CLKOUT_PCIE0N: R23.2 U29.AE10
CLKOUT_PCIE0P: R22.2 U29.AE11
CLKOUT_PCIE1N: R26.2 U29.AC6
CLKOUT_PCIE1P: R25.2 U29.AC7
CLKOUT_PCIE4N: U29.Y4 U39.2
CLKOUT_PCIE4P: U29.Y2 U39.3
CLKOUTFLEX1: R446.2 U29.AT9
CLKTESTA: C764.1 U13.K8
CLKTESTA_C: C764.2 R1207.1
CLKTESTB: C763.1 U13.L7
CLKTESTB_C: C763.2 R1206.1
CPU_FAN_CTRL_SIO: R810.1 U24.47
CPU_FAN_TACH_SIO: R807.2 U24.37
CPU_THERMTRIP_N: CPU1.F37 R756.2 R771.2
CPU_VSS_T8: CPU1.T8 TP97.1
CPVEE: C195.1 U16.20
CR_1P2V_LDOIN: C456.1 C458.1 C460.1 L29.2 U39.31 U39.32
CR_1P2V_LDOOUT: C429.1 C434.1 C437.1 L29.1 U39.9 U39.26
CR_3P3V_PECI: C101.1 C102.2 L7.2 U39.1
CR_AUX_CAP: C432.1 U39.11
CR_CLKREQ_N: R833.2 U39.23
CR_IO_CAP: C441.2 C445.1 U39.19
CR_LDOSEL: R817.2 R821.1 U39.16
CR_PE_REXT: R827.2 U39.4
CR_WAKE0_N: R818.2 U39.15
CSA0#_0: MEM1.L2 MEM3.L2 U13.H22
CSA1#_0: MEM2.L2 MEM4.L2 U13.G13
CSN1: C381.2 C384.1 G2.2 R674.1 R682.1 U35.15
CSN2: G4.2 R681.1 R1222.1
CSN2_R: C388.2 C392.1 R679.1 R1221.1 R1222.2 U35.19
CSN3: C387.2 C393.1 G5.2 R678.1 R684.1 U35.17
CSP1: G1.2 R671.2 R687.1
CSP1_R: C381.1 R671.1 R674.2 U35.14
CSP2: G3.2 R691.2 R693.1
CSP2_R: C388.1 R679.2 R691.1 U35.18
CSP3: G6.2 R690.2 R692.1
CSP3_R: C387.1 R678.2 R690.1 U35.16
CTF_TRIP: C755.1 Q48.B R391.2
CTFB: Q48.C R354.2 R360.1
D_RSMRST_N_1: Q105.B R1051.2 R1052.1
D_RSMRST_N_2: Q105.C R1044.1 R1053.2
DCBATOUT_1589: C185.1 C190.1 C197.1 R325.2 R344.2 U18.5 U18.6
DCIN_+12V: ATX2.5 ATX2.6 C451.1 C462.1 C466.1 D3.K R114.1 R122.1 R127.1 R129.1 R825.1 R832.1 R834.1 R836.1 R842.1 R1123.1 R1124.1 R1125.1 R1126.1 U6.1 U6.2 U6.3 U40.1 U40.2 U40.3
DCPSUS: U29.AJ22
DDPB_AUX_DN: C1.1 U29.AK6
DDPB_AUX_DN_C: C1.2 NGFF1.20
DDPB_AUX_DP: C2.1 U29.AK8
DDPB_AUX_DP_C: C2.2 NGFF1.22
DDPB_CTRL_CLK: R995.2 U29.AM1
DDPB_CTRL_DATA: R985.2 U29.AJ5
DDPC_CTRL_CLK: R997.2 U29.AN3 U32.4
DDPC_CTRL_CLK_CONN: C342.1 HDMI1.15 R599.2 U32.3 U33.1 U33.10
DDPC_CTRL_DATA: R998.2 U29.AM2 U32.1
DDPC_CTRL_DATA_CONN: C322.1 HDMI1.16 R583.2 U32.6 U33.2 U33.9
DDPD_CTRL_CLK: R991.2 U29.AN4
DDPD_CTRL_DATA: R993.2 U29.AN2
DDR3_DRAMRST_N: C412.1 CPU1.AK22 R808.1 R809.1
DDR3_DRAMRST_N_A_1: C422.1 DIMM1.30 R808.2
DDR3_DRAMRST_N_B_1: C423.1 DIMM2.30 R809.2
DDR_DRVH: R56.1 U3.9
DDR_DRVH_R: Q10.4 R56.2
DDR_DRVL: Q13.4 Q18.4 U3.6
DDR_EN: C49.1 R104.2 R794.2 U3.3
DDR_PG: R98.2 TP3.1 U3.1
DDR_RCOMP_0: CPU1.R1 R145.1
DDR_RCOMP_1: CPU1.P1 R146.1
DDR_RCOMP_2: CPU1.R2 R147.1
DDR_RF: R102.1 U3.5
DDR_SB: C41.1 R76.2
DDR_SHDN: R103.2 R105.2 R106.2 U4.5 U4.6
DDR_SW: C46.1 L3.1 Q10.1 Q10.2 Q10.3 Q13.5 Q13.6 Q13.7 Q13.8 Q18.5 Q18.6 Q18.7 Q18.8 R76.1 U3.8
DDR_TRIP: R99.2 U3.2
DDR_V5IIN: C416.1 R791.2 U3.7
DDR_VBST: R96.1 U3.10
DDR_VBST_R: C46.2 R96.2
DDR_VFB: PC3.2 R100.1 R101.1 U3.4
DDR_VREF_PWR: C483.1 C484.1 R854.2 TC23.1 U41.4
DDRVTT_REF: C481.1 R857.2 R858.1 U41.3
DDSP_B_HPD: Q88.S U29.AJ2
DDSP_B_HPD_CONN: NGFF1.31 Q88.D R654.1
DDSP_B_TX_DN_0: C5.1 CPU1.F17
DDSP_B_TX_DN_0_C: C5.2 NGFF1.32
DDSP_B_TX_DN_1: C3.1 CPU1.G18
DDSP_B_TX_DN_1_C: C3.2 NGFF1.26
DDSP_B_TX_DN_2: C374.1 CPU1.H19
DDSP_B_TX_DN_2_C: C374.2 NGFF1.25
DDSP_B_TX_DN_3: C368.1 CPU1.G20
DDSP_B_TX_DN_3_C: C368.2 NGFF1.19
DDSP_B_TX_DP_0: C6.1 CPU1.E17
DDSP_B_TX_DP_0_C: C6.2 NGFF1.34
DDSP_B_TX_DP_1: C4.1 CPU1.F18
DDSP_B_TX_DP_1_C: C4.2 NGFF1.28
DDSP_B_TX_DP_2: C376.1 CPU1.G19
DDSP_B_TX_DP_2_C: C376.2 NGFF1.27
DDSP_B_TX_DP_3: C373.1 CPU1.F20
DDSP_B_TX_DP_3_C: C373.2 NGFF1.21
DDSP_C_HPD: Q84.S R600.1 U29.AH5
DDSP_C_HPD_CONN: HDMI1.19 Q84.D R614.2 U33.4 U33.7
DDSP_C_TX_DN_0: C323.2 CPU1.E19
DDSP_C_TX_DN_1: C337.2 CPU1.D20
DDSP_C_TX_DN_2: C324.2 CPU1.E21
DDSP_C_TX_DN_3: C339.2 CPU1.D22
DDSP_C_TX_DP_0: C318.2 CPU1.D19
DDSP_C_TX_DP_1: C334.2 CPU1.C20
DDSP_C_TX_DP_2: C320.2 CPU1.D21
DDSP_C_TX_DP_3: C336.2 CPU1.C22
DDSP_D_TX_N0: Q113.D R1091.2 R1092.2 R1094.2 R1097.2 R1101.2 R1103.2 R1105.2 R1109.2
DDSP_D_TX_N2: Q113.G R1081.2
DGPU_PWROK: PR6.2 PR14.2 PR75.1 PR78.1 R1229.1
DGPU_PWROK_1D5V: PC36.1 PR75.2 Q55.G
DIMM_CA_CPU_VREF_A: C413.1 CPU1.AB38 R740.1 R741.1
DIMM_CA_CPU_VREF_RC: C413.2 R758.1
DIMM_CA_VREF_A: C110.1 C832.1 DIMM1.126 R141.2 R740.2
DIMM_CA_VREF_A_L: R138.2 R139.1 R141.1
DIMM_CA_VREF_B: C468.1 C834.1 DIMM2.126 R741.2 R845.2
DIMM_CA_VREF_B_L: R845.1 R846.2 R847.1
DIMM_DQ_CPU_VREF_A: C39.1 C417.1 CPU1.AB39 R793.1
DIMM_DQ_CPU_VREF_A_1: C417.2 R795.1
DIMM_DQ_CPU_VREF_B: C40.1 C420.1 CPU1.AB40 R792.1
DIMM_DQ_CPU_VREF_B_1: C420.2 R796.1
DIMM_DQ_VREF_A: C419.1 C831.1 DIMM1.1 R793.2 R799.2
DIMM_DQ_VREF_A_L: R799.1 R802.1 R803.2
DIMM_DQ_VREF_B: C418.1 C833.1 DIMM2.1 R792.2 R797.2
DIMM_DQ_VREF_B_L: R797.1 R800.1 R801.2
DIMM_TMPIN2+: C114.1 Q35.B Q35.C R153.2
DIMM_TMPIN2-: C114.2 Q35.E R154.2
DISP_UTIL_CPU: CPU1.E16 R714.2
DMI_IT_MR_DN0: CPU1.T3 U29.C20
DMI_IT_MR_DN1: CPU1.V1 U29.D21
DMI_IT_MR_DN2: CPU1.V2 U29.B22
DMI_IT_MR_DN3: CPU1.W3 U29.A24
DMI_IT_MR_DP0: CPU1.U3 U29.B20
DMI_IT_MR_DP1: CPU1.U1 U29.B21
DMI_IT_MR_DP2: CPU1.W2 U29.C22
DMI_IT_MR_DP3: CPU1.Y3 U29.B24
DMI_MT_IR_DN0: CPU1.AA5 U29.L24
DMI_MT_IR_DN1: CPU1.AB4 U29.G24
DMI_MT_IR_DN2: CPU1.AC4 U29.F26
DMI_MT_IR_DN3: CPU1.AC2 U29.K26
DMI_MT_IR_DP0: CPU1.AA4 U29.K24
DMI_MT_IR_DP1: CPU1.AB3 U29.H24
DMI_MT_IR_DP2: CPU1.AC5 U29.G26
DMI_MT_IR_DP3: CPU1.AC1 U29.L26
DMICOMP: R411.2 U29.C13
DMIRCOMP: R382.2 U29.B19
DPD_AUXN: C415.1 U29.AG11
DPD_AUXP: C414.1 U29.AG10
DPD_HPD: R730.1 U29.AJ4
DPD_LANE0N: C407.1 CPU1.C15
DPD_LANE0P: C406.1 CPU1.B15
DPD_LANE1N: C409.1 CPU1.B16
DPD_LANE1P: C408.1 CPU1.A16
DPD_LANE2N: CPU1.C17 TP6.1
DPD_LANE2P: CPU1.B17 TP7.1
DPD_LANE3N: CPU1.B18 TP4.1
DPD_LANE3P: CPU1.A18 TP5.1
DPLL_PVDD: C827.1 C829.1 C830.1 L52.2 U13.AF14
DPLL_VDDC: C825.1 C826.1 C828.1 L53.2 U13.AD14
DPLVDS_AUXN: C404.2 U37.3
DPLVDS_AUXN_1: C404.1 C415.2 R759.2 R762.2
DPLVDS_AUXP: C405.2 U37.4
DPLVDS_AUXP_1: C405.1 C414.2 R760.1 R763.1
DPLVDS_BL_EN: R177.1 U37.44
DPLVDS_EDIDCLK: C19.1 R49.2 R50.1 U37.46
DPLVDS_EDIDCLK_C: R50.2 U1.6
DPLVDS_EDIDSDA: C21.1 R53.1 R54.2 U37.45
DPLVDS_EDIDSDA_C: R53.2 U1.5
DPLVDS_FWCLK: C31.1 R66.1 R68.2 U37.48
DPLVDS_FWCLK_C: R66.2 U2.6
DPLVDS_FWSDA: C28.1 R60.2 R65.1 U37.47
DPLVDS_FWSDA_C: R65.2 U2.5
DPLVDS_HPD: R739.1 U37.1
DPLVDS_ISPCLK: Q95.S R725.2 U37.13
DPLVDS_ISPDAT: Q94.S R724.2 U37.14
DPLVDS_PANEL_VCC: R48.1 U37.20
DPLVDS_PIN12: R69.1 U37.12
DPLVDS_PIN16: R67.1 U37.16
DPLVDS_PWMIN: R713.1 R714.1 R715.1 R717.2 U37.21
DPLVDS_PWMOUT: R170.1 U37.19
DQMA0: MEM3.E7 U13.E32
DQMA1: MEM3.D3 U13.E30
DQMA2: MEM1.D3 U13.A21
DQMA3: MEM1.E7 U13.C21
DQMA4: MEM4.E7 U13.E13
DQMA5: MEM2.D3 U13.D12
DQMA6: MEM2.E7 U13.E3
DQMA7: MEM4.D3 U13.F4
DRAM_RST: C839.1 R1202.1 R1205.1 U13.L10
DRAM_RST_R: C762.1 R1202.2 R1203.1
DRVON: C379.1 R112.2 R701.1 R750.1 U35.13
DRX0N: C407.2 U37.8
DRX0P: C406.2 U37.7
DRX1N: C409.2 U37.10
DRX1P: C408.2 U37.9
DSWVRMEN: R281.2 U29.AM41
EAPD_DEPOP: R484.1 U16.14
EAPD_DEPOP_1: R483.1 R484.2 R485.1
EAPD_DEPOP_2: Q62.2 R485.2
FAN_CTL3: R533.1 U24.48
FAN_TAC3: R488.2 U24.38
FDI_COMP: CPU1.R4 R830.2
FDI_CSYNC: CPU1.D16 U29.L2
FDI_INT: CPU1.D18 U29.L3
FDI_RCOMP: R988.2 U29.K2
FDI_TX_DN0: CPU1.B14 U29.N1
FDI_TX_DN1: CPU1.C13 U29.P2
FDI_TX_DP0: CPU1.A14 U29.N2
FDI_TX_DP1: CPU1.B13 U29.P3
FP_CBL_DET: R458.1 U24.50
FP_RST_PCH_N: R744.1 R869.1 U29.N36
FWH_ID0: LPC1.6 R509.2
G_H_DDCDA_1: C722.1 R1114.1 R1115.2 U34.3
G_H_DDCSCL_1: C727.1 R1116.2 R1117.1 U34.6
GPIO17_THERMAL_INT: R345.2 R1183.2 R1186.2 U13.R6
GPIO19_CTF: R329.2 R1185.1 U13.M2
GPIO19_CTF_R: D7.3 R329.1 R345.1 R356.1 R391.1
GPIO_8_ROMSO: R1169.1 U13.P10
GPIO_9_ROMSI: R1171.2 U13.P4
GPIO_10_ROMSCK: R1170.2 U13.P2
GPIO_22_ROMCS#: R1168.1 U13.N8
GPIO_SVC: TP165.1 U13.AJ11
GPIO_SVD: TP163.1 U13.AK12
GPIO_SVT: TP164.1 U13.AL11
GPIO_VGA_03_DATA: Q123.4 R1165.1 RN9.2(A)
GPIO_VGA_03_DATA_R: R1165.2 U13.U8
GPIO_VGA_04_CLK: Q123.1 R1166.1 RN9.1(A)
GPIO_VGA_04_CLK_R: R1166.2 U13.U7
GPU_CLKA0_T: C158.2 R209.2 R215.2
GPU_CLKA1_T: C207.1 R341.2 R352.2
GPU_DMINUS: C245.2 C255.2 Q53.E U13.T2 U24.42
GPU_DPLUS: C245.1 C255.1 Q53.B Q53.C U13.T4 U24.41
GPU_GPIO16: TP155.1 U13.M4
GPU_SCL: TP149.1 U13.R1
GPU_SDA: TP150.1 U13.R3
GPU_THERM_SHUTDOWN*: PR18.1 R354.1
GPU_THERMAL_INT: R1183.1 R1184.2 U24.87
GPU_VREFG: C558.1 R1210.2 R1211.1 U13.AC16
GPU_WAKEB: R1187.2 U13.AJ27
GPU_XO_IN: R1190.1 U13.AC22
GPU_XO_IN2: R1191.1 U13.AB22
GPUPG_1: Q55.D Q56.G R428.2 R433.1
GPUPG_2: Q56.D R422.2 R423.1 R426.1
GPUPG_3: C239.1 Q57.4 R426.2
GREEN_CRT: C349.1 L21.2 U43.3 VGA1.2
H_CPURST_N: C38.1 CPU1.M39 R61.1 R63.1 R72.2
H_CPURST_SIO_N: Q102.E R1032.2
H_CPURST_SIO_N_1: Q102.B R1017.1
H_DRAMPWRGD: R757.2 R764.1 R765.1 U29.AE38
H_DRAMPWRGD_CPU: CPU1.AK21 R764.2
H_PECI: CPU1.N37 R269.2 R473.1
H_PM_SYNC_0: CPU1.P36 U29.F40
H_PRDY_N: CPU1.L39 XDPC1.5
H_PREQ_N: CPU1.L37 XDPC1.3
H_PROCHOT_N: R451.1 R630.1 R743.1
H_PROCHOT_N_R: C371.1 R630.2 U35.3
H_PROCHOT_R_N: CPU1.K38 R743.2 R774.2 R1147.2
H_PWRGD: C26.1 CPU1.AB35 R58.2 R696.1 U29.D40
H_RSTOUT_XDP_N: R638.2 XDPC1.46
H_SKTOCC_N: CPU1.D38 R912.2
H_SKTOCC_R_N: R912.1 R926.1 U29.AE34
H_TCK: CPU1.D39 R699.2 XDPC1.57
H_TDI: CPU1.F38 R644.2 XDPC1.56
H_TDO: CPU1.F39 R639.2 R640.1 R641.1 R642.2 XDPC1.52
H_THERMTRIP_N: R360.2 R771.1 U29.C40
H_TMS: CPU1.E39 R645.2 XDPC1.58
H_TRST_N: CPU1.E37 R643.2 XDPC1.54
H_VID0: PR39.1 PR40.1 PR104.2 U13.T8
H_VID1: PR37.1 PR38.1 PR103.2 U13.N1
H_VID2: PR35.1 PR36.1 PR102.2 U13.P8
H_VID3: PR32.1 PR33.1 PR100.2 U13.AK10
H_VID4: PR30.1 PR31.1 PR97.2 U13.AM10
H_VID5: PR25.1 PR26.1 PR96.2 U13.T9
H_VID6: PR23.1 PR24.1 PR94.2
H_VIDALERT_N: R742.2 R746.1 R749.2
H_VIDALERT_N_1: CPU1.B37 R746.2 R768.1
H_VIDALERT_N_VR: R649.2 R742.1 U35.5
H_VIDSCK: CPU1.C38 R745.2 R767.2
H_VIDSCK_VR: R648.2 R745.1 U35.6
H_VIDSOUT: CPU1.C37 R769.2 R770.2
H_VIDSOUT_VR: R629.2 R770.1 U35.4
HDD_LED_5V: PWRCN1.1 R503.2
HDMI_LANE0_DN: HDMI1.3 TR4.2 U27.2 U27.9
HDMI_LANE0_DN_C: C323.1 R1094.1 TR4.1
HDMI_LANE0_DP: HDMI1.1 TR4.3 U27.1 U27.10
HDMI_LANE0_DP_C: C318.1 R1091.1 TR4.4
HDMI_LANE1_DN: HDMI1.6 TR6.2 U27.5 U27.6
HDMI_LANE1_DN_C: C337.1 R1105.1 TR6.1
HDMI_LANE1_DP: HDMI1.4 TR6.3 U27.4 U27.7
HDMI_LANE1_DP_C: C334.1 R1101.1 TR6.4
HDMI_LANE2_DN: HDMI1.9 TR5.2 U31.4 U31.7
HDMI_LANE2_DN_C: C324.1 R1097.1 TR5.1
HDMI_LANE2_DP: HDMI1.7 TR5.3 U31.5 U31.6
HDMI_LANE2_DP_C: C320.1 R1092.1 TR5.4
HDMI_LANE3_DN: HDMI1.12 TR7.2 U31.1 U31.10
HDMI_LANE3_DN_C: C339.1 R1109.1 TR7.1
HDMI_LANE3_DP: HDMI1.10 TR7.3 U31.2 U31.9
HDMI_LANE3_DP_C: C336.1 R1103.1 TR7.4
HPOL_CON: C170.1 Q97.1 R261.2 R262.1 R265.2 R1121.2 UHS1.1
HPOR_CON: C210.1 Q97.2 R324.2 R337.1 R351.2 R1122.2 UHS1.2
HPOUT-JD: R332.1 UHS1.6
HPOUT-L: R261.1 U16.26
HPOUT-R: R351.1 U16.27
HSI_C_DN5: C644.2 U39.8
HSI_C_DP5: C643.2 U39.7
HSI_DN2: R664.2 U29.F14
HSI_DN3: R685.2 U29.F11
HSI_DN5: C644.1 U29.G9
HSI_DP2: R659.2 U29.G14
HSI_DP3: R680.2 U29.H11
HSI_DP5: C643.1 U29.F9
HSI_LAN_DN4: C285.2 U29.J11
HSI_LAN_DN4_R: C285.1 U26.18
HSI_LAN_DP4: C286.2 U29.L11
HSI_LAN_DP4_R: C286.1 U26.17
HSO_C_DN2: C635.1 R672.2
HSO_C_DN3: C641.1 R27.2
HSO_C_DN5: C244.1 U39.5
HSO_C_DP2: C634.1 R669.2
HSO_C_DP3: C642.1 R24.2
HSO_C_DP5: C243.1 U39.6
HSO_C_LAN_DN4: C295.1 U26.14
HSO_C_LAN_DP4: C300.1 U26.13
HSO_DN2: C635.2 U29.D11
HSO_DN3: C641.2 U29.B9
HSO_DN4: C295.2 U29.B8
HSO_DN5: C244.2 U29.B7
HSO_DP2: C634.2 U29.C11
HSO_DP3: C642.2 U29.A9
HSO_DP4: C300.2 U29.C8
HSO_DP5: C243.2 U29.A7
HSW_PCUDEBUG_0: CPU1.AA37 R776.1 XDPC1.9
HSW_PCUDEBUG_1: CPU1.Y38 R754.1 XDPC1.11
HSW_PCUDEBUG_2: CPU1.AA36 R735.1 XDPC1.15
HSW_PCUDEBUG_3: CPU1.W38 R646.2 R722.1 XDPC1.17
HSW_PCUDEBUG_4: CPU1.V39 R777.1 XDPC1.27
HSW_PCUDEBUG_5: CPU1.U39 R755.1 XDPC1.29
HSW_PCUDEBUG_6: CPU1.U40 R736.1 XDPC1.33
HSW_PCUDEBUG_7: CPU1.V38 R723.1 XDPC1.35
HSW_PCUDEBUG_8: CPU1.T40 R752.1 XDPC1.10
HSW_PCUDEBUG_9: CPU1.Y35 R718.1 XDPC1.12
HSW_PCUDEBUG_10: CPU1.AA34 R731.1 XDPC1.16
HSW_PCUDEBUG_11: CPU1.V37 R751.1 XDPC1.18
HSW_PCUDEBUG_12: CPU1.Y34 R775.1 XDPC1.28
HSW_PCUDEBUG_13: CPU1.U38 R720.1 XDPC1.30
HSW_PCUDEBUG_14: CPU1.W34 R734.1 XDPC1.34
HSW_PCUDEBUG_15: CPU1.V35 R721.1 XDPC1.36
HSW_PCUSTB_0_DN: CPU1.Y37 R732.1 XDPC1.6
HSW_PCUSTB_0_DP: CPU1.Y36 R719.1 XDPC1.4
HSW_PCUSTB_1_DN: CPU1.W36 R733.1 XDPC1.24
HSW_PCUSTB_1_DP: CPU1.V36 R753.1 XDPC1.22
HSW_STRAP_13: QF1.3 R720.2
HSW_XDP_MBP_0: CPU1.G39 XDPC1.21
HSW_XDP_MBP_1: CPU1.J39 XDPC1.23
HSYNC_3P3V: C352.1 L23.2 U44.3 VGA1.13
IGC_EN_N: R877.1 R879.1 U29.AC40
INA99B_OUT: R1142.1 U47.6
INA991_IN_N: C733.2 R1151.1 U47.5
INA991_IN_P: C733.1 R1150.1 U47.4
INIT_3V: LPC1.2 R508.2
INTRUDER_DET: INTRU1.3 R936.1 R937.1 U29.W34
INV_DET*: CONVT1.7 R165.2 U29.R31
IO_SMI_N: R276.2 U24.126 U29.AF40
ISP_CLK1: Q93.D Q95.D R727.2
ISP_DAT1: Q92.D Q94.D R726.2
JACK_PSID: L8.1 R157.1
JDREF: R333.1 U16.35
JTAG_TCK_VGA: R963.1 U13.L3
JTAG_TDI_VGA: R397.1 U13.L5
JTAG_TDO_VGA: R399.1 U13.K4
JTAG_TMS_VGA: R398.1 U13.L1
JTAG_TRST#_VGA: R396.1 U13.L6
KBRST_N: R919.1 U24.118 U29.K36
KCLK: RN5.4(A) U24.113
KDAT: RN5.3(A) U24.114
L_AD0: LPC1.5 R372.1 R373.1 U22.26 U23.26 U24.8
L_AD0_R: R372.2 U29.AN24
L_AD1: LPC1.7 R353.1 R355.1 U22.23 U23.23 U24.9
L_AD1_R: R353.2 U29.AP26
L_AD2: LPC1.9 R377.1 R378.1 U22.20 U23.20 U24.10
L_AD2_R: R377.2 U29.AJ24
L_AD3: LPC1.11 R347.1 R350.1 U22.17 U23.17 U24.11
L_AD3_R: R347.2 U29.AN26
L_BKLTEN: TP146.1 U29.AT2
L_FRAME_N: LPC1.13 R366.1 R367.1 U22.22 U23.22 U24.12
L_FRAME_N_R: R366.2 U29.AP24
L_PWRDWN_N: R476.2 U22.28 U23.28
L_VDD_EN: TP28.1 U29.AP1
LAN_1P05_OUT: C284.1 L15.1 R522.1 U26.24
LAN_DISABLE_N: R225.1 R226.1 R1104.1 U29.AL40
LAN_DISABLE_N_1: C716.1 Q126.B R1104.2 R1226.1
LAN_DISABLE_N_2: Q114.B Q126.C R1090.2 R1226.2
LAN_DISABLE_N_3: Q114.C Q127.C R1096.2 R1107.1
LAN_DISABLE_N_4: C718.1 PC72.2 Q80.G R1107.2
LAN_DISABLE_V3: C863.1 Q127.B R1227.1
LAN_LEDACT_R#: R524.2 RJ1.11
LAN_MDI0_DN: RJ1.2 U26.2 U28.1
LAN_MDI0_DP: RJ1.1 U26.1 U28.6
LAN_MDI1_DN: RJ1.4 U26.5 U28.4
LAN_MDI1_DP: RJ1.3 U26.4 U28.3
LAN_MDI2_DN: RJ1.8 U26.7 U30.1
LAN_MDI2_DP: RJ1.7 U26.6 U30.6
LAN_MDI3_DN: RJ1.10 U26.10 U30.4
LAN_MDI3_DP: RJ1.9 U26.9 U30.3
LAN_P5_CN: C719.2 RJ1.5 RJ1.6
LAN_RSET: R555.2 U26.31
LAN_XTALI: C288.1 R546.2 U26.28 X4.1
LAN_XTALO: C299.1 R546.1 U26.29 X4.3
LANCLK_REQ_N: R255.1 R256.1 R559.2 U29.AA39
LANCLK_REQ_U_N: R559.1 U26.12
LDO_3D3V: PG1.2 TP33.1
LDO_5V: PC45.1 PG6.2 PR83.2 R550.1
LED_5VSB: LED1.A R1074.2
LED_V_5P0_A: LED2.A R1087.2
LINE2-VREFO: R323.1 R336.1 U16.29
LINEOUT-JD: LOUT1.Q R331.1
LINEOUT-L: R624.1 U16.19
LINEOUT-R: R625.1 U16.18
LINEOUT_C-L: L25.1 R624.2
LINEOUT_C-R: L26.1 R625.2
LINEOUT_CON-L: C355.1 L25.2 LOUT1.4 Q85.1
LINEOUT_CON-R: C356.1 L26.2 LOUT1.1 Q85.2
LINK_ACTIVITY_N: C282.1 D8.K R524.1 U26.27
LMV393IN+: R1142.2 R1143.2 U46.1
LMV393IN-: R1141.2 R1157.1 U46.3
LPC_DRQ1_N: R962.1 TP127.1 U29.AK26
LPC_PME_N: R277.2 U24.75 U29.AG40
LVDS_BL_ADJ: R167.1 R168.1 R169.1 R170.2 R171.2
LVDS_DET_A*: LVDS1.14 R32.2 U29.L40
LVDS_DET_B*: Q129.D R44.2 U29.H41
LVDS_DET_B_R: C869.1 LVDS1.30 Q129.G
LVDS_PU_4: LVDS1.27 R43.2
LVDS_PU_5: LVDS1.26 R46.2
LVDS_PU_6: LVDS1.25 R1120.2
LVDS_PU_24: LVDS1.7 R45.2
M1_SMB_CLK: NGFF1.60 R14.2
M1_SMB_DATA: NGFF1.58 R12.2
M_CAS_A_N: CPU1.AU9 DIMM1.115
M_CAS_B_N: CPU1.AP16 DIMM2.115
M_DATA_A0: CPU1.AD38 DIMM1.5
M_DATA_A1: CPU1.AD39 DIMM1.7
M_DATA_A2: CPU1.AF38 DIMM1.15
M_DATA_A3: CPU1.AF39 DIMM1.17
M_DATA_A4: CPU1.AD37 DIMM1.4
M_DATA_A5: CPU1.AD40 DIMM1.6
M_DATA_A6: CPU1.AF37 DIMM1.16
M_DATA_A7: CPU1.AF40 DIMM1.18
M_DATA_A8: CPU1.AH40 DIMM1.21
M_DATA_A9: CPU1.AH39 DIMM1.23
M_DATA_A10: CPU1.AK38 DIMM1.33
M_DATA_A11: CPU1.AK39 DIMM1.35
M_DATA_A12: CPU1.AH37 DIMM1.22
M_DATA_A13: CPU1.AH38 DIMM1.24
M_DATA_A14: CPU1.AK37 DIMM1.34
M_DATA_A15: CPU1.AK40 DIMM1.36
M_DATA_A16: CPU1.AM40 DIMM1.39
M_DATA_A17: CPU1.AM39 DIMM1.41
M_DATA_A18: CPU1.AP38 DIMM1.51
M_DATA_A19: CPU1.AP39 DIMM1.53
M_DATA_A20: CPU1.AM37 DIMM1.40
M_DATA_A21: CPU1.AM38 DIMM1.42
M_DATA_A22: CPU1.AP37 DIMM1.50
M_DATA_A23: CPU1.AP40 DIMM1.52
M_DATA_A24: CPU1.AV37 DIMM1.57
M_DATA_A25: CPU1.AW37 DIMM1.59
M_DATA_A26: CPU1.AU35 DIMM1.67
M_DATA_A27: CPU1.AV35 DIMM1.69
M_DATA_A28: CPU1.AT37 DIMM1.56
M_DATA_A29: CPU1.AU37 DIMM1.58
M_DATA_A30: CPU1.AT35 DIMM1.68
M_DATA_A31: CPU1.AW35 DIMM1.70
M_DATA_A32: CPU1.AY6 DIMM1.129
M_DATA_A33: CPU1.AU6 DIMM1.131
M_DATA_A34: CPU1.AV4 DIMM1.141
M_DATA_A35: CPU1.AU4 DIMM1.143
M_DATA_A36: CPU1.AW6 DIMM1.130
M_DATA_A37: CPU1.AV6 DIMM1.132
M_DATA_A38: CPU1.AW4 DIMM1.140
M_DATA_A39: CPU1.AY4 DIMM1.142
M_DATA_A40: CPU1.AR1 DIMM1.147
M_DATA_A41: CPU1.AR4 DIMM1.149
M_DATA_A42: CPU1.AN3 DIMM1.157
M_DATA_A43: CPU1.AN4 DIMM1.159
M_DATA_A44: CPU1.AR2 DIMM1.146
M_DATA_A45: CPU1.AR3 DIMM1.148
M_DATA_A46: CPU1.AN2 DIMM1.158
M_DATA_A47: CPU1.AN1 DIMM1.160
M_DATA_A48: CPU1.AL1 DIMM1.163
M_DATA_A49: CPU1.AL4 DIMM1.165
M_DATA_A50: CPU1.AJ3 DIMM1.175
M_DATA_A51: CPU1.AJ4 DIMM1.177
M_DATA_A52: CPU1.AL2 DIMM1.164
M_DATA_A53: CPU1.AL3 DIMM1.166
M_DATA_A54: CPU1.AJ2 DIMM1.174
M_DATA_A55: CPU1.AJ1 DIMM1.176
M_DATA_A56: CPU1.AG1 DIMM1.181
M_DATA_A57: CPU1.AG4 DIMM1.183
M_DATA_A58: CPU1.AE3 DIMM1.191
M_DATA_A59: CPU1.AE4 DIMM1.193
M_DATA_A60: CPU1.AG2 DIMM1.180
M_DATA_A61: CPU1.AG3 DIMM1.182
M_DATA_A62: CPU1.AE2 DIMM1.192
M_DATA_A63: CPU1.AE1 DIMM1.194
M_DATA_B0: CPU1.AE34 DIMM2.5
M_DATA_B1: CPU1.AE35 DIMM2.7
M_DATA_B2: CPU1.AG35 DIMM2.15
M_DATA_B3: CPU1.AH35 DIMM2.17
M_DATA_B4: CPU1.AD34 DIMM2.4
M_DATA_B5: CPU1.AD35 DIMM2.6
M_DATA_B6: CPU1.AG34 DIMM2.16
M_DATA_B7: CPU1.AH34 DIMM2.18
M_DATA_B8: CPU1.AL34 DIMM2.21
M_DATA_B9: CPU1.AL35 DIMM2.23
M_DATA_B10: CPU1.AK31 DIMM2.33
M_DATA_B11: CPU1.AL31 DIMM2.35
M_DATA_B12: CPU1.AK34 DIMM2.22
M_DATA_B13: CPU1.AK35 DIMM2.24
M_DATA_B14: CPU1.AK32 DIMM2.34
M_DATA_B15: CPU1.AL32 DIMM2.36
M_DATA_B16: CPU1.AN34 DIMM2.39
M_DATA_B17: CPU1.AP34 DIMM2.41
M_DATA_B18: CPU1.AN31 DIMM2.51
M_DATA_B19: CPU1.AP31 DIMM2.53
M_DATA_B20: CPU1.AN35 DIMM2.40
M_DATA_B21: CPU1.AP35 DIMM2.42
M_DATA_B22: CPU1.AN32 DIMM2.50
M_DATA_B23: CPU1.AP32 DIMM2.52
M_DATA_B24: CPU1.AM29 DIMM2.57
M_DATA_B25: CPU1.AM28 DIMM2.59
M_DATA_B26: CPU1.AR29 DIMM2.67
M_DATA_B27: CPU1.AR28 DIMM2.69
M_DATA_B28: CPU1.AL29 DIMM2.56
M_DATA_B29: CPU1.AL28 DIMM2.58
M_DATA_B30: CPU1.AP29 DIMM2.68
M_DATA_B31: CPU1.AP28 DIMM2.70
M_DATA_B32: CPU1.AR12 DIMM2.129
M_DATA_B33: CPU1.AP12 DIMM2.131
M_DATA_B34: CPU1.AL13 DIMM2.141
M_DATA_B35: CPU1.AL12 DIMM2.143
M_DATA_B36: CPU1.AR13 DIMM2.130
M_DATA_B37: CPU1.AP13 DIMM2.132
M_DATA_B38: CPU1.AM13 DIMM2.140
M_DATA_B39: CPU1.AM12 DIMM2.142
M_DATA_B40: CPU1.AR9 DIMM2.147
M_DATA_B41: CPU1.AP9 DIMM2.149
M_DATA_B42: CPU1.AR6 DIMM2.157
M_DATA_B43: CPU1.AP6 DIMM2.159
M_DATA_B44: CPU1.AR10 DIMM2.146
M_DATA_B45: CPU1.AP10 DIMM2.148
M_DATA_B46: CPU1.AR7 DIMM2.158
M_DATA_B47: CPU1.AP7 DIMM2.160
M_DATA_B48: CPU1.AM9 DIMM2.163
M_DATA_B49: CPU1.AL9 DIMM2.165
M_DATA_B50: CPU1.AL6 DIMM2.175
M_DATA_B51: CPU1.AL7 DIMM2.177
M_DATA_B52: CPU1.AM10 DIMM2.164
M_DATA_B53: CPU1.AL10 DIMM2.166
M_DATA_B54: CPU1.AM6 DIMM2.174
M_DATA_B55: CPU1.AM7 DIMM2.176
M_DATA_B56: CPU1.AH6 DIMM2.181
M_DATA_B57: CPU1.AH7 DIMM2.183
M_DATA_B58: CPU1.AE6 DIMM2.191
M_DATA_B59: CPU1.AE7 DIMM2.193
M_DATA_B60: CPU1.AJ6 DIMM2.180
M_DATA_B61: CPU1.AJ7 DIMM2.182
M_DATA_B62: CPU1.AF6 DIMM2.192
M_DATA_B63: CPU1.AF7 DIMM2.194
M_DQS_A_DN0: CPU1.AE38 DIMM1.10
M_DQS_A_DN1: CPU1.AJ38 DIMM1.27
M_DQS_A_DN2: CPU1.AN38 DIMM1.45
M_DQS_A_DN3: CPU1.AU36 DIMM1.62
M_DQS_A_DN4: CPU1.AW5 DIMM1.135
M_DQS_A_DN5: CPU1.AP2 DIMM1.152
M_DQS_A_DN6: CPU1.AK2 DIMM1.169
M_DQS_A_DN7: CPU1.AF2 DIMM1.186
M_DQS_A_DP0: CPU1.AE39 DIMM1.12
M_DQS_A_DP1: CPU1.AJ39 DIMM1.29
M_DQS_A_DP2: CPU1.AN39 DIMM1.47
M_DQS_A_DP3: CPU1.AV36 DIMM1.64
M_DQS_A_DP4: CPU1.AV5 DIMM1.137
M_DQS_A_DP5: CPU1.AP3 DIMM1.154
M_DQS_A_DP6: CPU1.AK3 DIMM1.171
M_DQS_A_DP7: CPU1.AF3 DIMM1.188
M_DQS_B_DN0: CPU1.AF34 DIMM2.10
M_DQS_B_DN1: CPU1.AK33 DIMM2.27
M_DQS_B_DN2: CPU1.AN33 DIMM2.45
M_DQS_B_DN3: CPU1.AN29 DIMM2.62
M_DQS_B_DN4: CPU1.AN13 DIMM2.135
M_DQS_B_DN5: CPU1.AR8 DIMM2.152
M_DQS_B_DN6: CPU1.AM8 DIMM2.169
M_DQS_B_DN7: CPU1.AG6 DIMM2.186
M_DQS_B_DP0: CPU1.AF35 DIMM2.12
M_DQS_B_DP1: CPU1.AL33 DIMM2.29
M_DQS_B_DP2: CPU1.AP33 DIMM2.47
M_DQS_B_DP3: CPU1.AN28 DIMM2.64
M_DQS_B_DP4: CPU1.AN12 DIMM2.137
M_DQS_B_DP5: CPU1.AP8 DIMM2.154
M_DQS_B_DP6: CPU1.AL8 DIMM2.171
M_DQS_B_DP7: CPU1.AG7 DIMM2.188
M_MAA_A0: CPU1.AU13 DIMM1.98
M_MAA_A1: CPU1.AV16 DIMM1.97
M_MAA_A2: CPU1.AU16 DIMM1.96
M_MAA_A3: CPU1.AW17 DIMM1.95
M_MAA_A4: CPU1.AU17 DIMM1.92
M_MAA_A5: CPU1.AW18 DIMM1.91
M_MAA_A6: CPU1.AV17 DIMM1.90
M_MAA_A7: CPU1.AT18 DIMM1.86
M_MAA_A8: CPU1.AU18 DIMM1.89
M_MAA_A9: CPU1.AT19 DIMM1.85
M_MAA_A10: CPU1.AW11 DIMM1.107
M_MAA_A11: CPU1.AV19 DIMM1.84
M_MAA_A12: CPU1.AU19 DIMM1.83
