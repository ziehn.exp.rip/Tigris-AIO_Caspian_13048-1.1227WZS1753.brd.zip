# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TP_PCH_B1: length 4.6
  TOP w0.102: TP30.1 125.95,59.89 U29.B1
TP_PCH_B2: length 4.3
  TOP w0.102: U29.B2 125.53,64.46 125.53,61.11 TP27.1
TP_PCH_K16: length 1.7
  TOP w0.102: v4(130.46,71.82) 130.46,72.11 U29.K16
  BOTTOM w0.102: TP136.1 130.46,72.57 v4(130.46,71.82)
TP_PCH_K22: length 2.1
  TOP w0.102: U29.K22 130.12,75.77 v4(130.48,76.13)
  BOTTOM w0.102: v4(130.48,76.13) 129.79,75.45 TP134.1
TP_PCH_K33: length 2.2
  TOP w0.102: U29.K33 130.53,80.92 130.58,80.86 v4(130.58,80.86)
  BOTTOM w0.102: TP124.1 131.19,79.57 130.58,80.17 v4(130.58,80.86)
TP_PCH_K34: length 2.2
  TOP w0.102: v4(130.03,81.89) 130.26,81.89 U29.K34
  BOTTOM w0.102: v4(130.03,81.89) 129.89,81.75 129.89,80.37 TP122.1
TP_PCH_L16: length 1.7
  TOP w0.102: U29.L16 131.13,72.16 v4(131.13,71.96)
  BOTTOM w0.102: TP138.1 131.67,71.96 v4(131.13,71.96)
TP_PCH_L22: length 1.4
  TOP w0.102: v4(131.14,76.02) 131.14,75.82 U29.L22
  BOTTOM w0.102: v4(131.14,76.02) 131.29,75.87 TP132.1
TP_PCH_N12: length 1.9
  TOP w0.102: v4(130.74,70.6) 131.5,70.6 131.69,70.41 U29.N12
  BOTTOM w0.102: TP139.1 130.68,70.6 v4(130.74,70.6)
TP_PCH_P19: length 1.7
  TOP w0.102: U29.P19 132.14,73.84 v4(132.03,73.96)
  BOTTOM w0.102: TP135.1 131.01,73.96 v4(132.03,73.96)
TP_PCH_PWM0: length 5.8
  TOP w0.102: U29.AL31 141.08,79.69 v4(141.07,79.69)
  BOTTOM w0.102: v4(141.07,79.69) 141.63,80.25 144.01,80.25 144.08,80.18 145.68,80.18 TP123.1
TP_PCH_PWM1: length 7.4
  TOP w0.102: U29.AM31 142.01,80.14 141.5,80.65 141.5,80.7 v4(141.45,80.76)
  BOTTOM w0.102: v4(141.45,80.76) 141.87,81.18 142.68,81.18 142.99,81.5 143.94,81.5 144.25,81.81 146.08,81.81 TP119.1
TP_PCH_PWM2: length 7.7
  TOP w0.102: v4(142.29,80.71) 142.29,80.65 142.79,80.14 U29.AP31
  BOTTOM w0.102: v4(142.29,80.71) 142.55,80.98 142.76,80.98 143.07,81.29 144.02,81.29 144.33,81.6 147.15,81.6 TP118.1
TP_PCH_PWM3: length 4.7
  TOP w0.102: U29.AV30 145.54,80.06 145.91,79.69 147.41,79.69 147.72,79.38 148.87,79.38 TP12.1
TP_PCH_R12: length 1.6
  TOP w0.102: v4(133.55,70.04) 133.4,70.04 U29.R12
  BOTTOM w0.102: TP140.1 134.12,70.04 v4(133.55,70.04)
TP_PCH_U10: length 2.7
  TOP w0.102: v4(134.68,68.7) 134.32,69.05 U29.U10
  BOTTOM w0.102: TP142.1 134.21,67.3 134.21,68.23 v4(134.68,68.7)
TP_PCH_U11: length 2.7
  TOP w0.102: U29.U11 134.27,69.76 134.61,69.43 134.69,69.43 v4(134.7,69.41)
  BOTTOM w0.102: TP143.1 135.13,68.18 135.13,68.91 134.72,69.31 134.72,69.39 v4(134.7,69.41)
TP_PEG_A4: length 2
  TOP w0.102: v3(61.22,150.45) 61.63,150.86 CPU1.A4
  BOTTOM w0.102: v3(61.22,150.45) 61.11,150.35 TP102.1
TP_PEG_B3: length 2.1
  TOP w0.102: CPU1.B3 62.61,149.95 v3(61.94,149.28)
  BOTTOM w0.102: TP104.1 61.89,149.23 v3(61.94,149.28)
TP_PEG_C2: length 2.8
  TOP w0.102: v3(62.69,148.67) 63.33,148.67 CPU1.C2
  BOTTOM w0.102: TP103.1 62.42,148.94 v3(62.69,148.67)
TP_PEG_D1: length 3.4
  TOP w0.102: v3(62.81,146.91) 63.39,146.91 CPU1.D1
  BOTTOM w0.102: v3(62.81,146.91) 62.81,147.38 TP106.1
TP_RSVD_AB6: length 1.8
  TOP w0.102: v3(80.61,153.15) CPU1.AB6
  BOTTOM w0.102: TP101.1 81.29,153.83 v3(80.61,153.15)
TP_RSVD_AB33: length 2.1
  TOP w0.102: v3(82.44,179.12) CPU1.AB33
  BOTTOM w0.102: TP61.1 82.08,179.12 v3(82.44,179.12)
TP_RSVD_AB36: length 7.4
  TOP w0.102: v3(80.83,188.01) 80.83,187.98 80.99,187.82 80.99,185.39 81.62,184.76 81.62,182.68 CPU1.AB36
  BOTTOM w0.102: TP40.1 81.07,188.26 v3(80.83,188.01)
TP_RSVD_AC8: length 1.8
  TOP w0.102: v3(82.44,154.98) CPU1.AC8
  BOTTOM w0.102: TP93.1 83.21,155.75 v3(82.44,154.98)
TP_RSVD_AK20: length 1.7
  TOP w0.102: v4(88.86,167.22) 89.29,167.65 CPU1.AK20
  BOTTOM w0.102: v4(88.86,167.22) 88.79,167.29 TP70.1
TP_RSVD_AT40: length 2.2
  TOP w0.102: v4(94.34,185.51) 94.78,185.96 CPU1.AT40
  BOTTOM w0.102: v4(94.34,185.51) 94.84,186.02 TP48.1
TP_RSVD_AU1: length 2.6
  TOP w0.102: CPU1.AU1 94.78,147.24 v4(95.33,146.69)
  BOTTOM w0.102: v4(95.33,146.69) 95.31,146.67 TP108.1
TP_RSVD_AU27: length 1.8
  TOP w0.102: v4(95.21,174.57) 95.69,174.09 CPU1.AU27
  BOTTOM w0.102: TP66.1 95.59,174.19 v4(95.21,174.57)
TP_RSVD_AU39: length 2.3
  TOP w0.102: CPU1.AU39 95.69,185.07 v4(95.24,185.52)
  BOTTOM w0.102: TP49.1 96.14,186.42 v4(95.24,185.52)
TP_RSVD_AV1: length 2.7
  TOP w0.102: CPU1.AV1 95.96,148.39 v4(96.37,148.39)
  BOTTOM w0.102: TP109.1 96.12,148.13 v4(96.37,148.39)
TP_RSVD_AV2: length 4
  TOP w0.102: v4(95.21,149.53) 95.69,149.05 CPU1.AV2
  BOTTOM w0.102: TP107.1 97.08,148.29 96.81,148.57 96.55,148.82 95.8,148.82 95.21,149.41 v4(95.21,149.53)
TP_RSVD_AV20: length 3
  TOP w0.102: CPU1.AV20 96.81,167.69 96.96,167.84 96.98,167.84 97.42,168.29 97.42,168.3 97.52,168.4 v4(98.23,168.4)
  BOTTOM w0.102: v4(98.23,168.4) 98.41,168.22 TP71.1
TP_RSVD_AV24: length 2.7
  TOP w0.102: CPU1.AV24 96.13,171.83 v4(95.21,171.83)
  BOTTOM w0.102: TP67.1 95.26,171.77 v4(95.21,171.83)
TP_RSVD_AV29: length 1.9
  TOP w0.102: CPU1.AV29 96.61,176 v4(97.02,176.41)
  BOTTOM w0.102: v4(97.02,176.41) 96.98,176.45 TP64.1
TP_RSVD_AW2: length 2.3
  TOP w0.102: CPU1.AW2 96.66,149.03 v4(97.09,149.45)
  BOTTOM w0.102: TP105.1 98.12,148.42 v4(97.09,149.45)
TP_RSVD_AW12: length 4.7
  TOP w0.102: v4(99.75,159.93) 99.75,160.94 99.45,161.24 99.08,161.24 98.64,160.81 97.95,160.81 CPU1.AW12
  BOTTOM w0.102: TP81.1 99.8,159.88 v4(99.75,159.93)
TP_RSVD_AW23: length 1.7
  TOP w0.102: CPU1.AW23 97.53,170.44 v4(97.99,170.9)
  BOTTOM w0.102: TP69.1 97.78,170.69 v4(97.99,170.9)
TP_RSVD_AW24: length 1.7
  TOP w0.102: CPU1.AW24 97.52,171.42 v4(97.95,171.85)
  BOTTOM w0.102: TP68.1 98.09,171.72 v4(97.95,171.85)
TP_RSVD_AW27: length 2.2
  TOP w0.102: CPU1.AW27 97.52,174.02 v4(97.11,173.61)
  BOTTOM w0.102: TP65.1 98,174.5 v4(97.11,173.61)
TP_RSVD_AY18: length 1.7
  TOP w0.102: CPU1.AY18 98.44,165.9 v4(98.91,166.38)
  BOTTOM w0.102: TP72.1 98.99,166.3 v4(98.91,166.38)
TP_RSVD_C39: length 3.3
  TOP w0.102: CPU1.C39 64.44,185.07 63.55,185.96 v3(63.55,186.16)
  BOTTOM w0.102: v3(63.55,186.16) 64.62,185.09 TP58.1
TP_RSVD_H12: length 3.4
  TOP w0.102: v3(68.72,158.63) CPU1.H12
  BOTTOM w0.102: v3(68.72,158.63) 68.23,158.15 67.99,158.15 67.98,158.15 67.63,158.15 67.62,158.15 67.07,158.15 67.07,158.15 66.71,158.15 66.71,158.15 66.26,158.15 TP86.1
TP_RSVD_H14: length 4.8
  TOP w0.102: CPU1.H14 v3(68.72,160.46)
  BOTTOM w0.102: TP77.1 66.27,160.49 66.68,160.9 68.29,160.9 v3(68.72,160.46)
TP_RSVD_H15: length 2.9
  TOP w0.102: v3(67.81,161.38) CPU1.H15
  BOTTOM w0.102: TP76.1 66.6,161.83 67.35,161.83 v3(67.81,161.38)
TP_RSVD_H16: length 2
  TOP w0.102: CPU1.H16 v3(67.81,162.29)
  BOTTOM w0.102: v3(67.81,162.29) TP75.1
TP_RSVD_J8: length 1.6
  TOP w0.102: CPU1.J8 v3(68.72,154.98)
  BOTTOM w0.102: v3(68.72,154.98) 68.68,154.94 TP100.1
TP_RSVD_J9: length 4.1
  TOP w0.102: CPU1.J9 v3(69.63,155.89)
  BOTTOM w0.102: v3(69.63,155.89) 69.17,155.43 67.64,155.43 66.96,154.74 TP98.1
TP_RSVD_J10: length 3.8
  TOP w0.102: CPU1.J10 v3(68.72,155.89)
  BOTTOM w0.102: v3(68.72,155.89) 67.8,155.89 67.26,155.35 66.12,155.35 66.05,155.28 TP94.1
TP_RSVD_J13: length 3.7
  TOP w0.102: v3(68.72,159.55) CPU1.J13
  BOTTOM w0.102: TP79.1 66.24,160 68.27,160 v3(68.72,159.55)
TP_RSVD_J15: length 1.6
  TOP w0.102: v3(69.63,161.38) CPU1.J15
  BOTTOM w0.102: TP78.1 69.78,161.24 v3(69.63,161.38)
TP_RSVD_J16: length 1.6
  TOP w0.102: v3(68.72,162.29) CPU1.J16
  BOTTOM w0.102: TP74.1 68.73,162.3 v3(68.72,162.29)
TP_RSVD_J17: length 2.8
  TOP w0.102: v3(68.72,163.21) CPU1.J17
  BOTTOM w0.102: v3(68.72,163.21) 69.15,163.64 69.15,164.69 TP73.1
TP_RSVD_J40: length 2.5
  TOP w0.102: CPU1.J40 70.09,186.1 v3(69.2,186.99)
  BOTTOM w0.102: v3(69.2,186.99) 69.2,187.87 TP42.1
TP_RSVD_K8: length 1.7
  TOP w0.102: v3(69.63,154.06) CPU1.K8
  BOTTOM w0.102: v3(69.63,154.06) 69.7,154.13 TP99.1
TP_RSVD_K12: length 5.9
  TOP w0.102: v3(69.63,157.72) CPU1.K12
  BOTTOM w0.102: v3(69.63,157.72) 69.17,157.25 65.15,157.25 TP87.1
TP_RSVD_K13: length 2.8
  TOP w0.102: v3(69.63,159.55) CPU1.K13
  BOTTOM w0.102: v3(69.63,159.55) 69.63,159.55 69.17,159.08 68.18,159.08 TP82.1
TP_RSVD_L10: length 4.5
  TOP w0.102: v3(70.55,155.89) CPU1.L10
  BOTTOM w0.102: TP92.1 67.29,156.16 68.1,156.16 68.3,156.37 70.08,156.37 v3(70.55,155.89)
TP_RSVD_L12: length 2.6
  TOP w0.102: v3(71.46,157.72) CPU1.L12
  BOTTOM w0.102: v3(71.46,157.72) 71.93,158.19 TP80.1
TP_RSVD_M10: length 4.4
  TOP w0.102: v3(71.46,155.89) CPU1.M10
  BOTTOM w0.102: v3(71.46,155.89) 71.46,156.17 73.71,158.42 TP83.1
TP_RSVD_M11: length 2.6
  TOP w0.102: v3(71.46,156.81) CPU1.M11
  BOTTOM w0.102: v3(71.46,156.81) 72.49,157.84 TP85.1
TP_RSVD_N38: length 2
  TOP w0.102: CPU1.N38 v3(73.29,184.61)
  BOTTOM w0.102: TP55.1 72.92,185.25 72.92,184.98 v3(73.29,184.61)
TP_RSVD_P33: length 2
  TOP w0.102: CPU1.P33 v3(74.21,179.12)
  BOTTOM w0.102: v3(74.21,179.12) 75.08,178.25 TP63.1
TP_RSVD_P37: length 6.1
  TOP w0.102: v3(74.21,182.78) CPU1.P37
  BOTTOM w0.102: TP47.1 74.25,187.49 74.25,186.32 74.73,185.83 74.73,183.31 v3(74.21,182.78)
TP_RSVD_R33: length 1.8
  TOP w0.102: CPU1.R33 v3(75.12,179.12)
  BOTTOM w0.102: TP62.1 76.01,179.12 v3(75.12,179.12)
TP_RSVD_R34: length 6.2
  TOP w0.102: v3(76.04,180.95) CPU1.R34
  BOTTOM w0.102: v3(76.04,180.95) 76.52,181.43 76.52,184.79 TP52.1
TP_RSVD_R36: length 5.6
  TOP w0.102: v3(75.12,182.78) CPU1.R36
  BOTTOM w0.102: v3(75.12,182.78) 75.12,183 75.35,183.23 75.35,186.7 75.57,186.92 TP45.1
TP_RSVD_T34: length 5.4
  TOP w0.102: v3(76.95,180.95) CPU1.T34
  BOTTOM w0.102: TP56.1 77.43,185.46 77.43,181.43 v3(76.95,180.95)
TP_RSVD_U8: length 3.5
  TOP w0.102: v3(76.95,154.06) CPU1.U8
  BOTTOM w0.102: TP91.1 78.34,156.16 77.66,155.48 77.66,154.66 77.06,154.06 v3(76.95,154.06)
TP_RSVD_V7: length 2.2
  TOP w0.102: v3(77.86,154.06) CPU1.V7
  BOTTOM w0.102: v3(77.86,154.06) 77.89,154.06 TP95.1
TP_RSVD_W8: length 3.3
  TOP w0.102: v3(78.78,154.06) CPU1.W8
  BOTTOM w0.102: v3(78.78,154.06) 79.63,154.91 TP90.1
TP_RSVD_Y8: length 2.2
  TOP w0.102: v3(79.69,154.06) CPU1.Y8
  BOTTOM w0.102: v3(79.69,154.06) 80.7,155.07 TP96.1
TP_SLP_LAN_N_C: length 6.6
  TOP w0.102: TP11.1 149.73,85.96 148.76,85.96 146.26,83.47 144.93,83.47 U29.AU36
TP_TPM_PIN6: length 4.1
  TOP w0.102: U22.6 U23.6 144.01,33.64 144.27,33.37 144.27,32.37 TP144.1
TP_TPM_PIN7: length 4.7
  TOP w0.102: U22.7 U23.7 144.66,33.13 145.8,31.99 TP145.1
TP_VCC12: length 3
  TOP w0.508: 19.63,67.06 TOUCH2.1 ; TOUCH2.1 18.64,68.05 ; TOUCH2.1 19.63,69.04
  vias: v1(25.58,63.2)
TP_VCC12_C:
  vias: v1(28.73,70.8)
TPA3113_SD: length 9.2
  TOP w0.254: v1(146.43,55.79) 146.43,54.91 R466.2 147.19,54.15 147.19,52.43 146.45,51.69 Q62.3 146.46,51.36 Q63.G 148.24,50.82 R486.1
TPA3113_SD1#: length 43.4
  TOP w0.102: v3(165.88,46.09) 165.86,46.1 165.86,46.21 161.47,50.61 159.16,50.61 158.09,51.67 154.76,51.67 v1(154.69,51.6) 154.58,51.6 153.72,50.74 153.72,50.52 153.45,50.25 153.05,50.25 152.78,50.52 152.63,50.52 152.51,50.4 R487.2 152.4,50.4 151.94,50.86 151.26,50.86 151.06,50.66 151.05,50.66 151,50.61 149.75,50.61 149.65,50.71 149.65,52 149.68,52.03 149.22,52.48 Q63.D 149.22,54.26 C258.1 ; v3(165.99,32.5) 165.16,33.32 R541.1 164.25,33.32 164.08,33.49 164.08,34.27 163.45,34.91 U25.29
  BOTTOM w0.102: v3(165.99,32.5) 165.99,45.98 v3(165.88,46.09)
TPA3131_BSNL: length 4.5
  TOP w0.254: C301.1 158.75,29.13 v1(159.8,28.08)
  TOP w0.305: U25.19 158.76,30.09 C301.1
TPA3131_BSNR: length 3.4
  TOP w0.254: v1(160.66,29.02) 160.15,29.52 C302.1
  TOP w0.305: C302.1 160.26,30.2 U25.22
TPA3131_BSPL: length 4.9
  TOP w0.305: C294.1 154.31,31.48 v1(154.69,31.86) 156.23,33.41 U25.15
TPA3131_BSPR: length 3.4
  TOP w0.305: U25.26 162.79,33.41 v1(163.68,32.52) 164.47,31.73 C296.1
TPA3131_FAULT#: length 4.3
  TOP w0.102: v1(165.86,34.21) R541.2 164.52,34.21 163.32,35.41 U25.30
TPA3131_GAIN: length 4.2
  TOP w0.203: 160.69,38.89 160.69,39.96 R515.1 R516.2 ; 160.69,38.89 v1(160.67,38.89) ; 160.69,38.89 160.69,38.79 160.26,38.36 U25.3
TPA3131_LINN: length 2.8
  TOP w0.203: C275.2 159.13,39 v1(159.16,38.97) 159.26,38.87 U25.5
TPA3131_LINN_1: length 2.9
  TOP w0.203: R499.2 159.11,43.34 159.77,42.68 v1(159.77,42.53) 159.13,41.89 C275.1
TPA3131_MUTE: length 20.7
  TOP w0.203: R486.2 150.77,49.17 150.79,49.17 151.64,48.32 151.64,46.47 v1(151.51,46.34) 151.76,46.08 151.76,40.31 R520.1 152.53,38.34 153.42,37.45 154.56,37.45 154.81,37.7 154.81,38.15 156.1,39.43 156.77,39.43 158.26,37.94 U25.7
TPA3131_PLIMIT: length 8
  TOP w0.203: R500.2 163.07,42.21 C269.1 R517.1 163.44,40.57 163.44,40.57 163.58,40.44 163.58,40.43 163.65,40.36 163.65,40.29 163.65,39.66 163.2,39.2 v1(163.2,38.93) 163.2,38.72 161.72,37.25 U25.1
TPA3131_RINN: length 5.1
  TOP w0.203: U25.32 162.1,36.74 163.86,38.49 163.86,38.74 v1(164.47,39.35) C277.2
TPA3131_RINN_1: length 2.6
  TOP w0.203: v1(166.24,43.04) 165.99,42.78 R506.2 C277.1
TPA3131_SYNC: length 4.7
  TOP w0.203: U25.11 156.35,35.41 155.57,36.18 155.57,38.08 TP32.1
TPEV_CFG_RCOMP: length 25.6
  TOP w0.305: v3(66.17,205.85) 67.44,204.58 67.44,201.97 67.84,201.56 67.84,200.82 70.95,197.71 70.95,189.64 68.67,187.36 68.67,186.49 CPU1.H40
  BOTTOM w0.305: v3(66.17,205.85) 66.55,206.23 R728.1 67.5,207.06 v2(67.69,206.87)
TRST_N: length 6.4
  TOP w0.203: U24.124 58.07,35.38 58.67,34.78 60.5,34.78 60.62,34.65 61.29,34.65 v1(61.65,34.3) 61.47,34.12 R560.2
TS#_DIMM0_1: length 22.5
  TOP w0.203: DIMM1.198 171,126.2 v4(170.89,126.09) ; DIMM2.198 155.29,126.2 154.94,126.55 v4(154.94,126.6)
  BOTTOM w0.203: v4(170.89,126.09) 170.65,125.85 R849.1 169.68,125.85 169.21,125.38 167.89,125.38 165.13,128.15 161.8,128.15 v2(161.54,128.41) 161.39,128.25 158.5,128.25 157.1,126.86 155.19,126.86 v4(154.94,126.6)
TSVDD: length 9.2
  TOP w0.254: U13.AD17 86.15,88.85 v4(86.56,89.26)
  BOTTOM w0.254: v4(86.56,89.26) 87.17,88.66 88.7,88.66 88.75,88.6 89.35,88.6 89.64,88.32 89.64,88.05 v2(90.75,86.93) 91.58,86.93 C759.1 C758.1 93.6,87.04 L47.2
USB3_RX1_DN: length 178.1
  TOP w0.102: 185.83,123.36 185.1,123.36 184.4,124.06 182.19,124.06 181.8,124.46 181.8,124.86 182.07,125.13 182.32,125.13 182.42,125.03 182.42,124.76 182.52,124.66 L10.1 ; 185.83,123.36 186.41,123.36 186.51,123.47 186.51,123.86 186.61,123.96 v3(186.84,123.96) ; 185.83,123.36 v1(185.83,123.73) ; U29.F20 127.99,74.44 128.3,74.13 v4(128.32,74.13)
  L3 w0.127: v4(128.32,74.13) 128.44,74.13 128.69,74.38 128.69,74.68 128.57,74.8 126.96,74.8 124.93,72.78 120.55,72.78 119.25,71.48 119.25,70.72 119.09,70.56 119.09,70.56 115.06,66.53 115.06,59.01 115.28,58.79 115.34,58.73 115.66,58.41 122.53,51.54 125.2,48.87 138.24,48.87 140.44,51.08 142.1,51.08 142.96,51.94 145.71,51.94 149.48,55.71 159.46,55.71 163.65,59.9 164.11,59.9 165.54,61.33 165.54,67.04 170.17,71.66 170.17,73.05 169.96,73.25 169.96,92.35 170.5,92.88 175.71,92.88 177.56,94.74 185.56,94.74 186.66,95.84 187.3,95.84 190.22,98.76 190.22,119.39 186.93,122.68 186.58,122.68 186.37,122.88 186.37,123.85 186.49,123.96 v3(186.84,123.96)
USB3_RX1_DP: length 178.1
  TOP w0.102: v4(128.99,74.08) 128.98,74.08 128.7,74.37 U29.G20 ; v1(181.23,124.7) 181.58,124.7 ; 181.58,124.7 181.58,124.95 181.98,125.34 L10.4 ; 181.58,124.7 181.58,124.37 182.1,123.85 184.32,123.85 185.01,123.15 v3(186.84,123.15)
  L3 w0.127: v4(128.99,74.08) 128.96,74.11 128.96,74.79 128.68,75.07 126.85,75.07 124.82,73.04 120.44,73.04 118.99,71.59 118.99,70.83 118.98,70.83 114.8,66.64 114.8,58.9 122.34,51.35 123.01,50.69 125.09,48.61 138.35,48.61 140.55,50.81 142.21,50.81 143.07,51.67 145.82,51.67 149.59,55.44 159.57,55.44 163.76,59.64 164.22,59.64 165.81,61.22 165.81,66.93 170.43,71.55 170.43,73.16 170.23,73.36 170.23,92.24 170.61,92.62 175.82,92.62 177.67,94.47 185.67,94.47 186.77,95.58 187.41,95.58 190.49,98.65 190.49,119.5 186.84,123.15 v3(186.84,123.15)
USB3_RX2_DN: length 139.4
  TOP w0.102: U29.G18 128.7,73.52 128.96,73.26 v4(128.96,72.99) ; L13.1 189.07,101.85 189.3,101.62 189.56,101.62 189.79,101.39 189.79,100.2 189.44,99.84 188.71,99.84 v3(188.39,99.52)
  L3 w0.127: v3(188.39,99.52) 188.1,99.81 187.32,99.81 185.8,98.28 185.8,97.14 184.53,95.87 177.1,95.87 175.24,94.01 169.95,94.01 168.66,92.73 168.66,73.46 164.27,69.08 164.27,68.3 162.47,66.5 162.47,61.58 157.73,56.84 148.93,56.84 145.21,53.12 142.54,53.12 141.63,52.21 139.97,52.21 137.84,50.08 125.59,50.08 116.59,59.08 116.59,65.87 122.96,72.25 126.33,72.25 126.64,72.55 128.52,72.55 v4(128.96,72.99)
  BOTTOM w0.102: v2(189.11,99.12) 188.79,99.12 v3(188.39,99.52)
USB3_RX2_DP: length 138.6
  TOP w0.102: v3(188.39,100.38) 188.71,100.06 189.35,100.06 189.58,100.29 189.58,101.3 189.47,101.4 189.3,101.4 189.07,101.17 L13.4 ; v4(129.69,73) 129.41,73.28 U29.H18
  L3 w0.127: v3(188.39,100.38) 188.08,100.07 187.21,100.07 185.53,98.39 185.53,97.25 184.42,96.13 176.99,96.13 175.13,94.28 169.83,94.28 168.39,92.84 168.39,73.57 164.01,69.19 164.01,68.41 162.2,66.61 162.2,61.69 157.62,57.11 148.82,57.11 145.1,53.39 142.43,53.39 141.52,52.47 139.86,52.47 137.73,50.35 125.7,50.35 116.85,59.2 116.85,65.76 123.07,71.98 126.44,71.98 126.75,72.29 128.97,72.29 v4(129.69,73)
  BOTTOM w0.102: v2(187.58,100.52) 188.26,100.52 v3(188.39,100.38)
USB3_TX1_C_DN: length 168.8
  TOP w0.102: v3(120.52,72.12) 120.82,72.12 120.9,72.2 120.9,72.67 121.11,72.88 124.09,72.88 124.37,73.16 125.17,73.16 125.22,73.11 125.74,73.11 U29.B18 ; v1(182.17,122.84) 182.17,122.49 ; 182.17,122.49 181.03,122.49 179.75,123.76 179.75,124.17 C120.1 ; 182.17,122.49 184.23,122.49 v3(184.53,122.79)
  L3 w0.127: v3(184.53,122.79) 184.77,122.55 185.69,122.55 185.94,122.3 189.79,118.45 189.79,98.94 187.25,96.4 186.61,96.4 185.38,95.17 177.39,95.17 175.53,93.32 170.23,93.32 169.35,92.44 169.35,73.14 165.11,68.9 165.11,61.51 163.96,60.36 163.49,60.36 159.28,56.14 149.22,56.14 145.49,52.41 142.82,52.41 141.92,51.51 140.27,51.51 138.06,49.3 125.38,49.3 115.89,58.8 115.89,66.75 120.75,71.61 120.75,71.89 v3(120.52,72.12)
USB3_TX1_C_DP: length 168.4
  TOP w0.102: U29.C18 126.26,73.2 125.96,72.89 125.13,72.89 125.08,72.95 124.46,72.95 124.18,72.67 121.2,72.67 121.11,72.58 121.11,72.37 v3(121.36,72.12) ; 183.51,122.27 184.16,122.27 v3(184.53,121.9) ; 183.51,122.27 180.94,122.27 179.53,123.67 179.53,124.17 C119.1 ; 183.51,122.27 v1(183.51,121.9)
  L3 w0.127: v3(184.53,121.9) 184.91,122.28 185.58,122.28 187.37,120.5 189.52,118.34 189.52,99.05 187.14,96.67 186.5,96.67 185.27,95.44 177.27,95.44 175.42,93.58 170.12,93.58 169.09,92.55 169.09,73.25 164.85,69.01 164.85,61.62 163.85,60.62 163.38,60.62 159.17,56.41 149.11,56.41 145.38,52.68 142.71,52.68 141.81,51.77 140.15,51.77 137.95,49.57 125.49,49.57 116.16,58.91 116.16,66.64 121.02,71.5 121.02,72.02 121.12,72.12 v3(121.36,72.12)
USB3_TX1_EMI_DN: length 5.4
  TOP w0.102: 179.75,126.35 179.75,126.73 180.07,127.05 182.28,127.05 182.51,126.82 L9.1 ; 179.75,126.35 v1(180.11,126.35) ; 179.75,126.35 179.75,125.73 C120.2
USB3_TX1_EMI_DP: length 5.7
  TOP w0.102: 181.23,127.27 182.28,127.27 182.51,127.5 L9.4 ; 181.23,127.27 179.98,127.27 179.53,126.82 179.53,125.73 C119.2 ; 181.23,127.27 v1(181.23,127.62)
USB3_TX2_C_DN: length 131.7
  TOP w0.102: v3(123.06,71.23) 123.41,71.57 123.58,71.57 123.85,71.84 124.87,71.84 125.01,71.98 125.7,71.98 U29.B15 ; v3(185.04,100.67) 185.06,100.67 185.71,101.31 185.71,102.65 185.35,103 184.7,103 C143.1
  L3 w0.127: v3(123.06,71.23) 123.06,70.77 121.54,69.25 120.95,69.25 117.29,65.58 117.29,59.37 125.88,50.78 137.55,50.78 139.68,52.9 141.34,52.9 142.29,53.86 144.93,53.86 149.34,58.27 158.17,58.27 161.77,61.87 161.77,66.79 163.58,68.59 163.58,69.47 167.33,73.22 167.33,79.54 167.96,80.17 167.96,93.01 169.66,94.71 174.95,94.71 176.81,96.57 183.07,96.57 183.51,97.01 183.51,100.44 184.02,100.95 184.76,100.95 v3(185.04,100.67)
  BOTTOM w0.102: v3(185.04,100.67) 184.58,101.13 184.3,101.13 v2(184.05,101.38)
USB3_TX2_C_DP: length 130.7
  TOP w0.102: C144.1 184.7,102.78 185.26,102.78 185.49,102.56 185.49,101.4 185.36,101.27 185.21,101.27 v3(184.96,101.53) ; U29.B16 126.25,72.04 125.97,71.76 125.09,71.76 124.96,71.62 123.94,71.62 123.83,71.52 123.83,71.25 v3(123.85,71.23)
  L3 w0.127: v3(184.96,101.53) 184.65,101.22 183.91,101.22 183.25,100.55 183.25,97.12 182.96,96.83 176.7,96.83 174.84,94.98 169.54,94.98 167.69,93.13 167.69,80.28 167.06,79.65 167.06,73.33 163.31,69.58 163.31,68.7 161.51,66.9 161.51,61.98 158.06,58.53 149.23,58.53 144.82,54.12 142.18,54.12 141.23,53.17 139.57,53.17 137.44,51.05 125.99,51.05 117.55,59.49 117.55,65.47 121.07,68.98 121.65,68.98 123.58,70.92 123.58,70.96 v3(123.85,71.23)
  BOTTOM w0.102: v2(185.79,101.78) 185.54,101.53 v3(184.96,101.53)
USB3_TX2_EMI_DN: length 5
  TOP w0.102: v1(182.78,104.1) 182.43,104.1 ; 182.43,104.1 182.43,105.04 182.78,105.39 183.12,105.39 183.35,105.15 L12.1 ; 182.43,104.1 182.43,103.45 182.89,102.99 183.13,102.99 C143.2
USB3_TX2_EMI_DP: length 5.7
  TOP w0.102: 182.49,105.4 182.69,105.6 183.12,105.6 183.35,105.84 L12.4 ; 182.49,105.4 182.21,105.13 182.21,103.37 182.42,103.16 182.42,103.16 182.8,102.77 183.15,102.77 C144.2 ; 182.49,105.4 v1(182.25,105.65)
USB_EN: length 9.4
  TOP w0.102: Q75.4 109.42,35.34 C292.1 109.07,35.7 v1(108.08,35.7) C293.1 107.01,37.02 108.05,38.06 108.05,40.41 R529.2
USB_EN1: length 13.5
  TOP w0.102: Q71.G 109.89,38.34 Q72.D 111.11,38.12 111.11,37.85 112.16,36.79 113.32,36.79 113.54,37.02 113.54,37.19 114.05,37.7 114.18,37.7 R542.1 114.43,38.02 v1(115.44,39.03) 115.03,39.45 115.03,41.28 114.7,41.61 114.15,41.61 R531.2
USB_EN2: length 7.8
  TOP w0.102: Q71.D 107,39.44 107.38,39.82 R528.1 107.38,41.36 107.58,41.56 v3(108.05,41.56) 108.79,41.56 109.28,41.07 R529.1 R530.2
  BOTTOM w0.102: v3(108.05,41.56) 108.05,40.9 v2(108.31,40.65)
USB_OC1_R_N: length 12.3
  TOP w0.102: v4(139.37,84.44) 138.83,83.89 U29.AF37
  BOTTOM w0.102: v4(139.37,84.44) 139.34,84.47 139.34,87.22 140.44,88.32 140.44,89.33 140.84,89.73 140.84,90.36 v2(141.69,91.2) 141.71,91.22 141.71,91.27 143.84,93.4 R908.1
USB_OC2_R_N: length 10.9
  TOP w0.102: v1(137.99,94.34) 137.92,94.34 137.03,93.45 R257.1 136.58,93.05 136.58,92.67 136.57,92.66 136.57,92.2 136.58,92.2 136.58,92.19 136.8,91.96 136.8,90.43 137.41,89.83 137.41,86.47 137.45,86.43 137.45,85.58 137.41,85.54 137.41,85.26 137.54,85.06 U29.AD39
USB_PCH_DN0: length 93.8
  TOP w0.102: v3(155.16,62.98) 154.84,62.66 154.28,62.66 147.63,69.3 145.55,69.3 145.55,69.31 U29.AV10 ; TR2.4 181.56,117.85 181.46,117.75 181.46,117.49 181.36,117.38 181.05,117.38 180.92,117.51 180.92,119.41 181.02,119.52 181.51,119.52 181.61,119.41 v3(181.61,119.11) 181.97,119.11 v1(182.5,119.64)
  L3 w0.127: v3(155.16,62.98) 155.5,62.63 156.04,62.63 156.24,62.82 156.24,67.66 160.15,71.57 160.15,79.11 163.88,82.85 163.88,90.61 164.64,91.37 164.64,94.37 170.97,100.69 178.6,100.69 183.81,105.9 183.81,118.18 182.5,119.49 181.99,119.49 v3(181.61,119.11)
USB_PCH_DN1: length 97.6
  TOP w0.102: v1(178.59,120.23) 178.94,120.23 ; 178.94,120.23 178.94,116.85 180.91,114.88 182.05,114.88 TR3.1 ; 178.94,120.23 178.94,121.03 179.17,121.26 180.2,121.26 v3(180.21,121.27) ; v3(153.61,64.03) 153.61,64.34 153.42,64.53 153.11,64.53 153.05,64.59 153.04,64.59 148.07,69.57 145.81,69.57 145.44,69.94 U29.AV11
  L3 w0.127: v3(180.21,121.27) 180.38,121.1 180.82,121.1 181.1,120.82 181.1,118.73 183.38,116.45 183.38,106.08 178.48,101.19 170.85,101.19 164.21,94.55 164.21,91.55 163.45,90.79 163.45,83.02 159.72,79.29 159.72,71.75 155.69,67.72 155.69,64.6 155.24,64.15 153.73,64.15 v3(153.61,64.03)
USB_PCH_DN3: length 201.7
  TOP w0.102: TR1.4 178.8,223.57 179.03,223.8 180.79,223.8 181.18,224.19 ; 181.18,224.19 182.12,225.14 183.17,225.14 v3(183.5,224.81) ; 181.18,224.19 v1(181.43,223.94) ; v4(140.26,71.82) 140.28,71.82 140.41,71.95 U29.AJ16
  L3 w0.127: v3(183.5,224.81) 183.23,224.54 183.23,224.27 184.32,223.18 184.32,187.93 178.14,181.76 178.14,150.93 177.81,150.6 177.81,122.03 176.45,120.68 176.45,117.94 179.97,114.43 179.97,106.18 177.27,103.48 170.19,103.48 168.68,101.96 166.91,101.96 161.83,96.88 160.4,96.88 157.98,94.46 157.98,92.21 160.95,89.24 160.95,85.39 156.34,80.78 156.34,75.79 151.4,70.84 151.4,69.09 150.12,67.81 146.92,67.81 145.42,69.31 144.23,69.31 142.36,71.18 140.9,71.18 v4(140.26,71.82)
USB_PCH_DN3_NN: length 8.7
  TOP w0.102: 173.33,222.75 173.67,222.75 174.51,223.59 174.72,223.8 176.26,223.8 176.49,223.57 TR1.3 ; 173.33,222.75 v1(173.33,222.39) ; 173.33,222.75 171.51,222.75 171.11,223.16 171.11,223.5 171.01,223.61 170.85,223.61 170.74,223.71 170.74,224.65 WEBCM1.2
USB_PCH_DN4: length 211.6
  TOP w0.102: TR13.4 13.3,26.01 13.53,26.24 13.89,26.24 14.3,26.65 14.3,27.7 ; U29.AU15 144.93,71.84 145.34,71.43 145.64,71.43 145.94,71.73 146.43,71.73 v4(146.63,71.52) ; v3(15.19,29.3) 14.99,29.5 14.5,29.5 14.3,29.3 14.3,27.7 ; 14.3,27.7 v1(14.64,27.7)
  L4 w0.127: v4(146.63,71.52) 147.12,72.01 147.89,72.01 150.19,69.71 150.19,68.69 149.3,67.8 149.3,65.09 148.36,64.15 148.36,61.31 148.65,61.02 148.65,54.58 147.66,53.59 147.66,46.61 147.94,46.32 147.94,43.38 150.47,40.85 150.47,38.57 146.97,35.06 146.97,30.9 143.48,27.42 143.48,24.47 136.08,17.06 131.71,17.06 131.53,17.24 129.27,17.24 127.2,15.17 120.61,15.17 118.54,17.24 116.06,17.24 115.14,16.32 106.75,16.32 105.83,17.24 102.68,17.24 101.85,16.41 93.43,16.41 92.6,17.24 91.14,17.24 88.06,14.17 79.98,14.17 79.23,14.92 74.17,14.92 73.73,15.36 70.77,15.36 70.66,15.36 70.45,15.15 70.13,14.83 66.2,14.83 65.04,15.99 60.51,15.99 59.55,15.03 57.52,15.03 54.69,17.86 49.31,17.86 47.98,16.53 46.85,16.53 45.36,15.04 43.21,15.04 41,17.26 40.85,17.26 36.9,21.21 33.52,21.21 28.44,26.29 28.44,28.47 26.36,30.55 16.98,30.55 16,29.57 15.47,29.57 v3(15.19,29.3)
USB_PCH_DN4_NN: length 12.3
  TOP w0.102: v1(12.5,24.88) 12.5,25.38 11.87,26.01 TR13.3 10.99,26.01 10.75,26.24 10.34,26.24 C708.1 9.64,26.27 5.66,26.27 5.03,25.64 5.03,24.01 5.49,23.55 TOUCH1.4
USB_PCH_DN5: length 260.9
  TOP w0.102: U29.AU12 144.77,70.65 145.1,70.65 145.2,70.64 145.25,70.68 arc(145.32,70.71) 145.4,70.73 145.62,70.73 145.85,70.69 146.18,70.69 146.3,70.81 147.16,70.81 147.28,70.69 147.28,70.45 v4(147.08,70.24) ; v3(104.13,243.92) 104.34,243.92 104.43,244.01 104.43,244.36 104.53,244.46 104.9,244.46 105,244.36 105,244.09 105.11,243.99 TR12.1
  L3 w0.127: v3(104.13,243.92) 104.5,243.92 104.62,244.05 104.62,244.29 104.75,244.42 106.04,244.42 106.33,244.13 116.39,244.13 116.9,243.61 116.9,226.49 120.28,223.11 155.46,223.11 158.37,220.2 158.37,204.94 163.25,200.06 166.86,196.45 171.16,196.45 177.15,190.46 177.15,151.3 177,151.15 176.85,151 176.85,122.43 171.49,117.08 166.55,117.08 161.18,111.7 161.18,104.75 160.15,103.73 160.15,97.99 157.01,94.86 157.01,91.81 159.97,88.85 159.97,86.83 159.93,86.79 159.93,85.74 155.37,81.18 155.37,76.19 150.8,71.61 148.09,71.61 147.45,70.97 147.45,70.61 v4(147.08,70.24)
  BOTTOM w0.102: v2(104.98,244.41) 104.62,244.41 v3(104.13,243.92)
USB_PCH_DN5_NN: length 12.6
  TOP w0.102: v1(108.1,243.95) 108.1,244.34 ; 108.1,244.34 107.56,244.34 107.2,243.99 TR12.2 ; 108.1,244.34 114.42,244.34 116.12,246.05 116.72,246.05 116.97,245.8 NGFF1.5
USB_PCH_DN8: length 114.4
  TOP w0.102: TR8.4 100.37,21.08 100.37,21.58 100.03,21.92 99.9,21.92 99.9,21.92 99.85,21.92 99.85,21.92 98.97,21.92 98.51,21.46 98.51,18.18 98.13,17.8 97.87,17.8 97.74,17.92 97.74,18.32 97.61,18.44 v3(97.43,18.44) ; U29.AW16 146,72.59 146.17,72.59 146.35,72.41 147.16,72.41 149.26,70.31 149.26,70.3 149.43,70.14 149.48,70.09 149.48,69.94 149.4,69.86 148.85,69.86 v3(148.84,69.87)
  L4 w0.127: v3(148.84,69.87) 148.84,69.01 148.45,68.62 148.45,65.45 147.54,64.54 147.54,60.94 147.69,60.79 147.69,54.98 146.63,53.92 146.63,46.12 146.98,45.77 146.98,42.98 148.18,41.77 148.18,37.75 146,35.57 146,31.32 136.2,21.52 131.58,21.52 126.62,16.57 122.86,16.57 122.24,17.19 120.66,17.19 118.44,19.41 116,19.41 114.3,17.72 107.33,17.72 105.9,19.15 102.56,19.15 101.25,17.85 98.04,17.85 97.92,17.97 97.92,18.32 97.79,18.44 v3(97.43,18.44)
  BOTTOM w0.102: v2(98.81,19.14) 98.11,18.44 v3(97.43,18.44)
USB_PCH_DN9: length 96.8
  TOP w0.102: v4(142.25,71.88) 142.54,72.17 U29.AN16 ; TR10.4 100.59,17.13 100.49,17.23 100.23,17.23 100.13,17.33 100.13,17.44 103.1,20.41 103.1,20.63 v3(103.45,20.99)
  L4 w0.127: v4(142.25,71.88) 142.68,71.45 142.68,71.1 143.82,69.96 143.82,69.17 143.5,68.85 143.5,68.02 144.95,66.57 144.95,65.91 143.32,64.28 143.32,58.34 145.22,56.44 145.22,55.57 144.53,54.87 144.53,51.4 143.9,50.77 143.9,48.33 143.95,48.29 143.95,47.26 143.69,47 143.69,46.08 143.1,45.5 143.1,43.43 143.78,42.75 143.78,34.95 139.29,30.46 137.45,30.46 128.26,21.28 105.12,21.28 104.06,20.23 103.23,20.23 103.06,20.39 103.06,20.86 103.19,20.99 v3(103.45,20.99)
  BOTTOM w0.102: v3(103.45,20.99) 103.45,21.44 103.48,21.46 103.48,22.13 v2(103.61,22.26)
USB_PCH_DN10: length 87.3
  TOP w0.102: v3(122.56,18.02) 122.56,19.21 123.46,20.11 124.21,20.11 124.85,19.47 TR9.4 ; U29.AJ18 140.41,73.3 v4(140.72,72.99)
  L4 w0.127: v4(140.72,72.99) 141.22,73.48 141.55,73.48 141.78,73.72 143.28,73.72 145.9,71.1 145.9,70.11 146.51,69.5 146.51,68.51 147.43,67.59 147.43,65 147.29,64.86 147.29,62.67 145.3,60.67 145.3,58.95 146.99,57.26 146.99,54.97 146.19,54.18 146.19,46.56 145.44,45.8 145.44,43.14 147.74,40.84 147.74,37.92 145.57,35.74 145.57,33.95 141.14,29.52 141.14,28.3 135.54,22.7 132.15,22.7 126.45,17 123.06,17 122.68,17.38 122.68,17.89 v3(122.56,18.02)
  BOTTOM w0.102: v2(123.57,16.75) 122.56,17.76 v3(122.56,18.02)
USB_PCH_DN11: length 75.1
  TOP w0.102: v4(143.02,73.01) 143.31,73.3 U29.AP18 ; TR11.1 125.69,16.67 125.93,16.9 125.93,19.8 v3(125.7,20.02)
  L4 w0.127: v4(143.02,73.01) 143.9,72.12 143.9,71.07 145.82,69.15 145.82,65.13 146.69,64.27 146.69,62.87 144.4,60.59 144.4,58.81 146.2,57 146.2,55.18 145.5,54.47 145.5,48.98 145.5,46.92 144.74,46.17 144.74,34.5 138.03,27.78 136.24,27.78 127.37,18.92 126.31,18.92 125.95,19.28 125.95,19.78 v3(125.7,20.02)
  BOTTOM w0.102: v2(125.22,21.02) 125.7,20.53 v3(125.7,20.02)
USB_PCH_DP0: length 94.9
  TOP w0.102: v3(155.19,62.09) 154.84,62.44 154.19,62.44 147.54,69.09 145.55,69.09 145.47,69.01 144.9,69.01 U29.AU10 ; TR2.1 180.96,117.17 180.71,117.42 180.71,118.22 ; v1(180.31,118.22) 180.71,118.22 ; 180.71,118.22 180.71,119.5 180.93,119.73 181.34,119.73 v3(181.61,120)
  L3 w0.127: v3(181.61,120) 181.85,119.76 182.61,119.76 184.07,118.29 184.07,105.79 178.71,100.43 171.08,100.43 164.91,94.26 164.91,91.26 164.15,90.5 164.15,82.74 160.41,79 160.41,71.46 156.5,67.55 156.5,62.71 156.16,62.37 155.47,62.37 v3(155.19,62.09)
USB_PCH_DP1: length 96.1
  TOP w0.102: v3(153.7,64.89) 153.56,64.74 153.2,64.74 149.93,68.01 ; v3(180.21,120.38) 179.86,120.38 179.76,120.48 179.76,120.94 179.65,121.04 179.26,121.04 179.16,120.94 179.16,116.94 181,115.1 181.33,115.1 181.43,115.2 181.43,115.46 181.53,115.56 TR3.4 ; U29.AW11 146.1,69.79 148.16,69.79 149.93,68.01 ; 149.93,68.01 v1(150.2,68.28)
  L3 w0.127: v3(153.7,64.89) 153.7,64.6 153.88,64.42 155.13,64.42 155.42,64.71 155.42,67.83 159.45,71.86 159.45,79.4 163.18,83.14 163.18,90.9 163.94,91.66 163.94,94.66 170.74,101.46 178.37,101.46 183.11,106.19 183.11,116.34 180.84,118.62 180.84,120.71 180.71,120.84 180.47,120.84 180.21,120.58 v3(180.21,120.38)
USB_PCH_DP3: length 201.7
  TOP w0.102: 182.4,225.35 183.19,225.35 v3(183.52,225.68) ; 182.4,225.35 v1(182.4,225.71) ; 182.4,225.35 182.03,225.35 180.7,224.02 179.03,224.02 178.8,224.25 TR1.1 ; v4(140.92,71.89) 141.12,72.09 U29.AK16
  L3 w0.127: v4(140.92,71.89) 140.92,71.54 141.01,71.45 142.47,71.45 144.34,69.58 145.53,69.58 147.03,68.08 150.01,68.08 151.13,69.2 151.13,70.96 156.07,75.9 156.07,80.89 160.68,85.5 160.68,89.13 157.71,92.1 157.71,94.57 160.29,97.15 161.72,97.15 166.8,102.23 168.57,102.23 170.08,103.74 177.16,103.74 179.71,106.29 179.71,114.32 176.19,117.83 176.19,120.79 177.55,122.15 177.55,150.71 177.88,151.04 177.88,181.87 184.05,188.04 184.05,223.07 182.96,224.16 182.96,225.12 v3(183.52,225.68)
USB_PCH_DP3_PP: length 8.7
  TOP w0.102: 174.36,223.75 v1(174.09,224.01) ; 174.36,223.75 173.58,222.97 171.6,222.97 171.32,223.25 171.32,223.5 171.42,223.61 171.89,223.61 172,223.71 WEBCM1.1 ; 174.36,223.75 174.63,224.02 176.26,224.02 176.49,224.25 TR1.2
USB_PCH_DP4: length 209.9
  TOP w0.102: TR13.1 13.3,26.69 13.53,26.46 13.8,26.46 14.08,26.74 14.08,28.64 ; v1(13.74,28.64) 14.08,28.64 ; 14.08,28.64 14.08,29.39 14.41,29.71 15,29.71 15.19,29.91 v3(15.19,30.16) ; v4(147.33,71.52) 146.9,71.94 145.51,71.94 U29.AV15
  L4 w0.127: v4(147.33,71.52) 147.55,71.74 147.78,71.74 149.92,69.6 149.92,68.8 149.03,67.91 149.03,65.2 148.09,64.26 148.09,61.2 148.39,60.91 148.39,54.69 147.39,53.7 147.39,46.5 147.68,46.21 147.68,43.27 150.2,40.74 150.2,38.68 146.7,35.17 146.7,31.01 143.22,27.53 143.22,24.58 135.97,17.33 131.82,17.33 131.64,17.51 129.16,17.51 127.09,15.44 120.72,15.44 118.65,17.51 115.95,17.51 115.03,16.59 106.86,16.59 105.94,17.51 102.57,17.51 101.74,16.68 93.54,16.68 92.71,17.51 91.03,17.51 87.95,14.44 80.09,14.44 79.34,15.19 74.28,15.19 73.84,15.63 70.89,15.63 70.88,15.63 70.55,15.63 70.19,15.26 70.02,15.1 66.31,15.1 65.15,16.25 64.93,16.25 60.4,16.25 59.44,15.3 57.63,15.3 54.8,18.12 49.2,18.12 49.04,17.97 47.87,16.8 46.74,16.8 45.25,15.31 43.32,15.31 41.11,17.52 40.96,17.52 37.01,21.47 33.63,21.47 28.7,26.4 28.7,28.58 26.47,30.82 16.87,30.82 15.89,29.84 15.51,29.84 v3(15.19,30.16)
USB_PCH_DP4_PP: length 13.7
  TOP w0.102: TOUCH1.3 6.62,22.56 6.44,22.74 6.32,22.74 5.73,23.33 5.4,23.33 4.81,23.92 4.81,25.73 5.57,26.49 9.58,26.49 C711.1 10.47,26.46 10.75,26.46 10.99,26.69 TR13.2 11.52,27.63 v1(11.94,28.05)
USB_PCH_DP5: length 261
  TOP w0.102: v3(104.11,244.69) 104.13,244.67 TR12.4 ; v4(147.71,70.26) 147.48,70.49 147.48,70.77 147.25,71.01 146.6,71.01 146.21,71.01 146.09,70.89 145.87,70.89 145.64,70.93 145.4,70.93 arc(145.26,70.91) 145.13,70.85 145.1,70.85 144.57,70.85 144.13,70.71 U29.AT12
  L3 w0.127: v3(104.11,244.69) 106.15,244.69 106.44,244.4 116.5,244.4 117.17,243.72 117.17,226.6 120.39,223.38 155.57,223.38 158.64,220.31 158.64,205.05 161.04,202.65 166.97,196.72 171.27,196.72 177.42,190.57 177.42,151.19 177.11,150.89 177.11,122.32 171.6,116.81 166.66,116.81 161.44,111.59 161.44,104.64 160.41,103.62 160.41,97.88 157.28,94.75 157.28,91.92 160.24,88.96 160.24,86.72 160.2,86.68 160.2,85.63 155.64,81.07 155.64,76.07 150.91,71.35 148.2,71.35 147.71,70.86 v4(147.71,70.26)
  BOTTOM w0.102: v2(103.5,245.22) 104.04,244.69 v3(104.11,244.69)
USB_PCH_DP5_PP: length 12.3
  TOP w0.102: 110.03,244.56 114.33,244.56 116.03,246.26 116.93,246.26 116.97,246.3 NGFF1.3 ; 110.03,244.56 107.49,244.56 107.38,244.67 TR12.3 ; 110.03,244.56 v3(110.03,244.87)
USB_PCH_DP8: length 114.1
  TOP w0.102: v3(149.48,69.41) 149.48,69.63 149.69,69.85 149.69,70.18 149.48,70.39 149.48,70.4 147.25,72.62 146.44,72.62 146.26,72.81 145.73,72.81 145.39,72.47 U29.AV16 ; TR8.1 100.15,21.09 100.15,21.49 99.94,21.7 99.06,21.7 98.73,21.37 98.73,18.09 98.22,17.58 v3(97.43,17.58)
  L4 w0.127: v3(149.48,69.41) 149.11,69.04 149.11,68.9 148.72,68.51 148.72,65.34 147.8,64.43 147.8,61.05 147.96,60.9 147.96,54.87 146.89,53.81 146.89,46.23 147.24,45.88 147.24,43.09 148.45,41.88 148.45,37.64 146.27,35.46 146.27,31.21 136.31,21.26 131.69,21.26 126.73,16.3 122.75,16.3 122.13,16.93 120.55,16.93 118.33,19.15 116.11,19.15 114.41,17.45 107.22,17.45 105.79,18.89 102.67,18.89 101.37,17.58 v3(97.43,17.58)
  BOTTOM w0.102: v3(97.43,17.58) 98.44,17.58 v2(98.58,17.71)
USB_PCH_DP9: length 96.6
  TOP w0.102: U29.AP16 143.26,72.22 v4(142.95,71.92) ; v3(102.59,20.99) 102.88,20.7 102.88,20.5 99.91,17.53 TR10.1
  L4 w0.127: v4(142.95,71.92) 142.95,71.21 144.08,70.08 144.08,69.06 143.76,68.74 143.76,68.13 145.21,66.68 145.21,65.8 143.59,64.17 143.59,58.45 145.49,56.55 145.49,55.46 144.8,54.76 144.8,51.29 144.17,50.66 144.17,48.44 144.22,48.4 144.22,47.15 143.95,46.89 143.95,45.97 143.37,45.39 143.37,43.54 144.04,42.86 144.04,34.84 139.4,30.2 137.56,30.2 128.37,21.02 105.23,21.02 104.17,19.96 103.12,19.96 102.79,20.28 102.79,20.79 v3(102.59,20.99)
  BOTTOM w0.102: v2(101.65,20.94) 101.7,20.99 v3(102.59,20.99)
USB_PCH_DP10: length 85
  TOP w0.102: v4(141.48,73.04) 141.22,73.04 141.12,73.14 U29.AK18 ; TR9.1 124.17,19.03 124.27,19.14 124.53,19.14 124.64,19.24 124.64,19.38 124.12,19.9 123.55,19.9 122.77,19.12 122.77,18.45 123.2,18.02 v3(123.44,18.02)
  L4 w0.127: v3(123.44,18.02) 123.22,18.02 122.95,17.75 122.95,17.49 123.17,17.27 126.33,17.27 132.04,22.97 135.43,22.97 140.87,28.41 140.87,29.63 145.3,34.06 145.3,35.86 147.47,38.03 147.47,40.73 145.18,43.03 145.18,45.91 145.93,46.67 145.93,54.29 146.72,55.09 146.72,57.15 145.03,58.84 145.03,60.78 147.03,62.78 147.03,64.97 147.17,65.11 147.17,67.48 146.24,68.4 146.24,69.39 145.63,70 145.63,70.99 143.17,73.45 141.89,73.45 141.74,73.3 141.74,73.29 v4(141.48,73.04)
  BOTTOM w0.102: v3(123.44,18.02) 124.21,18.02 v2(124.46,18.27)
USB_PCH_DP11: length 75
  TOP w0.102: U29.AN18 142.54,73.3 v4(142.25,73.01) ; v3(126.47,20.02) 126.32,20.02 126.14,19.85 126.14,16.81 125.91,16.58 125.91,16.24 126.01,16.14 126.27,16.14 126.38,16.04 TR11.4
  L4 w0.127: v4(142.25,73.01) 142.69,72.58 143.07,72.58 143.64,72.01 143.64,70.96 145.55,69.04 145.55,65.02 146.42,64.16 146.42,62.98 144.13,60.7 144.13,58.7 145.94,56.89 145.94,55.29 145.23,54.58 145.23,49.09 145.23,47.03 144.48,46.28 144.48,34.61 137.92,28.05 136.13,28.05 127.26,19.19 126.42,19.19 126.21,19.39 126.21,19.77 v3(126.47,20.02)
  BOTTOM w0.102: v2(126.92,20.94) 126.47,20.48 v3(126.47,20.02)
USB_PWR_CRL1: length 100.1
  TOP w0.102: U29.V41 134.44,86.4 133.75,87.09 133.75,87.86 132.89,88.72 132.89,89.65 131.98,90.56 131.98,91.12 131.5,91.59 131.5,94.83 129.38,96.96 129.31,96.96 128.21,98.05 v3(128,98.05)
  L3 w0.127: v3(109.37,57.57) 109.5,57.57 111,59.07 111,65.83 113.16,67.99 113.16,68.88 118.45,74.16 119.49,74.16 119.7,74.38 124.03,74.38 125.96,76.31 125.96,79.87 125.07,80.76 125.07,81.85 125.36,82.14 125.36,84.81 124.19,85.98 124.19,86.83 124.59,87.23 125.81,87.23 126.98,88.4 127.31,88.4 127.99,89.09 127.99,92.26 127.29,92.96 127.29,94.16 127.93,94.79 127.93,97.98 v3(128,98.05)
  BOTTOM w0.102: R1056.1 106.76,38.71 106.76,39.52 R1045.1 107.29,41.46 v2(106.82,41.92) 106.82,44.51 111.94,49.62 113.95,51.63 113.95,54.47 111.41,57.01 109.85,57.01 109.37,57.49 v3(109.37,57.57) ; R892.1 129.03,96.95 129.03,97.77 128.75,98.05 v3(128,98.05) 127.99,98.06 R868.1 R867.1
USB_PWR_CRL1_B1: length 2.6
  BOTTOM w0.102: Q108.B 108.66,37.23 R1056.2 v2(106.43,37.23)
USBOC01*: length 79.1
  TOP w0.102: U29.AE40 138.2,85.34 138.02,85.54 137.86,85.71 137.86,86.6 137.82,86.64 137.82,89.26 137.82,89.26 137.82,90.13 137.41,90.53 v4(137.41,90.79)
  L4 w0.127: v4(137.41,90.79) 137.79,90.79 138.16,91.16 138.16,91.18 138.44,91.46 138.44,93.26 138.44,93.26 138.44,93.65 138.44,93.65 138.44,95.91 138.6,96.06 138.6,96.09 138.87,96.36 138.93,96.36 139.02,96.45 139.26,96.45 139.72,96.91 139.72,97.52 139.56,97.67 139.56,98.3 140.57,99.31 140.96,99.31 141.24,99.04 141.24,98.29 142.88,96.65 144.71,94.81 149.06,94.81 151.08,96.83 151.43,96.83 151.85,97.25 164.58,97.25 v3(165.48,98.15)
  BOTTOM w0.102: v3(165.48,98.15) 165.48,98.97 169.2,102.69 179.29,102.69 180.44,103.84 v2(180.44,105.27) 180.44,115.1 181.29,115.95 R856.2 R855.1 C480.1
USBOC89*: length 90.8
  TOP w0.102: C304.1 R554.1 118.22,34.32 R556.2 118.24,34.78 v3(119.13,35.67) ; R260.1 140.56,93.83 140.56,92.41 v1(140.46,92.31) 140.46,92.01 139.8,91.35 139.75,91.35 139.73,91.33 139.07,91.33 138.91,91.17 138.91,90.43 139.14,90.2 139.14,89.82 138.73,89.42 138.73,88.02 v4(138.76,87.99) 139.04,87.72 139.04,86.47 139.02,86.45 139.02,85.62 139.13,85.5 139.13,84.83 U29.AF39
  L3 w0.127: v3(134.16,44.66) 134.01,44.81 132.04,44.81 131.98,44.87 127.45,44.87 127.39,44.86 127.37,44.85 120.36,44.85 120.33,44.85 119.75,44.28 117.46,44.28 116.58,43.4 116.58,38.78 119.13,36.24 v3(119.13,35.67)
  L4 w0.127: v3(134.16,44.66) 134.15,44.68 134.15,49.38 135.64,50.87 135.64,58.66 137.18,60.2 137.18,65.47 137.2,65.49 137.2,73.46 136.89,73.77 136.89,77.3 136.89,77.31 136.89,77.65 135.82,78.72 135.25,78.72 134.2,79.78 134.2,83.03 137.44,86.27 137.44,86.68 v4(138.76,87.99)
USBOC1011*: length 126.7
  TOP w0.102: v4(135.38,91.04) 135.38,90.92 135.89,90.41 135.89,89.39 136.97,88.31 U29.AC41 ; R592.2 R591.1 104.01,28.15 104.23,28.37 C321.1 102.13,28.69 100.58,30.24 v3(100.58,31.23)
  L3 w0.127: v3(100.58,31.23) 100.58,32.93 102.3,34.64 102.3,39.55 99.2,42.65 99.2,50.68 100.18,51.66 107.84,51.66 113.46,46.03 v3(114.27,46.03)
  L4 w0.127: v4(135.38,91.04) 135.04,90.7 135.04,88 134.16,87.12 128.31,87.12 125.76,84.58 118.97,84.58 113.59,79.19 113.59,78.94 106.72,72.07 103.5,72.07 v3(102.97,71.54)
  BOTTOM w0.102: v3(102.97,71.54) 103,71.51 103,69.2 103.99,68.21 103.99,65.28 115.7,53.57 115.7,51.93 116.2,51.42 116.2,47.99 v2(115.7,47.48) 114.27,46.06 v3(114.27,46.03)
USBP0N_EXT: length 25
  TOP w0.102: SSUSB1.2 192.58,126.59 192.58,126.11 192.25,125.78 191.2,125.78 190.87,125.45 190.87,124.82 191.57,124.12 192.69,124.12 193.6,125.04 194.35,125.04 194.45,124.94 194.45,121.87 190.31,117.74 187.38,117.74 186.65,117.01 186,117.01 D6.4 185.5,117.01 184.87,117.01 184.5,117.38 184,117.38 183.9,117.49 183.9,117.75 183.79,117.85 TR2.3
USBP0P_EXT: length 23.1
  TOP w0.102: TR2.2 184.41,117.17 184.78,116.8 186.74,116.8 187.47,117.52 188.19,117.52 188.44,117.27 D6.3 188.46,117.27 188.71,117.52 190.4,117.52 194.67,121.78 194.67,125.03 194.44,125.26 193.52,125.26 192.6,124.34 191.66,124.34 191.08,124.91 191.08,125.36 191.29,125.56 191.61,125.56 191.75,125.42 191.79,125.38 SSUSB1.3
USBP1N_EXT: length 22.3
  TOP w0.102: TR3.2 184.29,114.88 185.02,115.62 185.5,115.62 D6.6 186,115.62 186.7,115.62 187.44,114.88 189.51,114.88 195.35,109.04 195.35,106.43 194.89,105.98 193.24,105.98 192.53,105.27 192.24,105.27 192.12,105.39 SSUSB2.2
USBP1P_EXT: length 23.6
  TOP w0.102: SSUSB2.3 192.12,104.95 192.22,105.05 192.62,105.05 193.33,105.76 194.98,105.76 195.57,106.34 195.57,109.13 189.6,115.1 188.71,115.1 D6.1 188.18,115.1 187.53,115.1 186.79,115.83 184.93,115.83 184.2,115.1 184,115.1 183.9,115.2 183.9,115.46 183.79,115.56 TR3.3
USBP8N_EXT: length 20.7
  TOP w0.102: USB3.2 92.24,12.21 92.78,12.75 93.99,12.75 97.7,9.04 98.76,9.04 99.14,9.42 99.14,11.14 98.41,11.86 98.41,12.68 D14.3 98.41,13.19 98.41,16.61 100.5,18.69 100.5,18.92 100.59,19.02 TR8.3
USBP8P_EXT: length 20.7
  TOP w0.102: USB3.3 92.24,13.31 92.58,12.97 94.08,12.97 97.79,9.25 98.67,9.25 98.92,9.51 98.92,9.99 D14.4 98.92,10.5 98.92,11.05 98.2,11.77 98.2,16.7 100.28,18.78 100.28,18.91 100.18,19.01 100.01,19.01 99.91,19.11 TR8.2
USBP9N_EXT: length 19.4
  TOP w0.102: TR10.3 100.59,14.92 100.49,14.82 100.23,14.82 100.13,14.72 100.13,14.18 100.3,14 100.3,13.2 D14.1 100.3,12.67 100.3,11.76 101.04,11.02 101.04,9.51 102.48,8.07 105.96,8.07 106.46,8.58 106.46,12.25 105.71,13 105.28,13 105.14,12.86 USB4.2
USBP9P_EXT: length 19.4
  TOP w0.102: USB4.3 106.68,12.34 106.68,8.49 106.05,7.86 102.39,7.86 100.83,9.42 100.83,9.99 D14.6 100.83,10.5 100.83,10.93 100.09,11.67 100.09,13.92 99.91,14.09 TR10.2
USBP10N_EXT: length 22.2
  TOP w0.102: TR9.3 124.85,17.31 124.85,16.11 124.47,15.73 124.38,15.73 122.71,15.73 121.86,14.88 121.86,14.69 121.86,13.81 122.39,13.28 123.79,13.28 124.19,12.88 124.19,12.43 D15.6 124.19,11.92 124.19,11.35 124.92,10.63 124.92,8.73 124.54,8.35 121.83,8.35 119.5,10.69 119.5,11.68 119.29,11.88 USB5.2
USBP10P_EXT: length 23.9
  TOP w0.102: USB5.3 118.04,13.03 118.29,12.79 119.48,12.79 119.71,12.55 119.71,10.78 121.92,8.57 124.45,8.57 124.7,8.82 124.7,9.23 D15.1 124.7,9.74 124.7,10.54 123.98,11.26 123.98,12.79 123.7,13.06 122.3,13.06 121.64,13.72 121.64,14.97 122.62,15.95 124.38,15.95 124.64,16.2 124.64,16.57 124.54,16.67 124.27,16.67 124.17,16.77 TR9.2
USBP11N_EXT: length 15.7
  TOP w0.102: TR11.2 125.69,14.06 125.93,13.83 125.93,13.61 126.66,12.88 126.66,12.48 D15.4 126.66,11.87 126.66,11.25 125.88,10.47 125.88,8.85 126.45,8.28 127.85,8.28 128.6,9.03 128.6,12.33 128.91,12.64 130.18,12.64 USB6.2
USBP11P_EXT: length 15.7
  TOP w0.102: TR11.3 126.38,14.06 126.14,13.83 126.14,13.7 126.87,12.97 126.87,11.16 126.1,10.39 126.1,9.84 126.35,9.59 D15.3 126.14,9.27 126.14,8.9 126.54,8.49 127.76,8.49 128.38,9.12 128.38,12.42 128.82,12.85 130.43,12.85 130.94,13.36 USB6.3
USBRBIAS_PCH: length 11.9
  TOP w0.102: U29.AU20 U29.AV20 145.61,74.17 145.61,73.58 145.77,73.42 146.17,73.42 146.33,73.58 146.69,73.58 150.36,69.91 v1(151.38,69.91) 151.38,69.55 152.06,68.88 R408.2
USBVCC01: length 9.1
  TOP w0.508: D6.5 v3(186.94,116.32) ; 192.12,109.44 SSUSB2.1 191.23,108.55 ; 192.12,130.44 SSUSB1.1 191.23,129.55
  BOTTOM w0.508: 186.33,113.29 186.36,113.26 187.02,113.26 187.73,113.98 v2(187.73,115.33) 187.73,115.53 v3(186.94,116.32)
  vias: v5(181.94,113.52) v5(181.94,112.53) v5(182.52,128.61) v5(183.51,128.61)
USBVCC89: length 16.7
  TOP w0.508: USB3.1 92.24,10.41 ; USB3.1 91.21,9.38 ; USB3.1 93.27,9.38 ; D14.5 99.62,9.46 99.9,9.18 C363.2 99.34,8.34 98.87,7.87 C362.2 97.14,7.87 v3(95.38,9.64)
  BOTTOM w0.508: USB4.1 105.14,10.41 ; USB4.1 104.11,9.38 ; USB4.1 106.17,9.38 ; 91.21,9.38 USB3.1 ; USB3.1 93.27,9.38 ; USB3.1 92.24,10.41
  vias: v2(114.55,21.04) v5(116.87,26.7) v5(117.45,25.99) v5(118.11,26.73) v5(118.85,26.02)
USBVCC1011: length 24
  TOP w0.508: v3(123.44,13.94) C354.2 125.4,13.05 D15.5 ; 105.16,25.33 R592.1 ; TC22.1 115.73,24.52 ; TC22.1 114.67,23.46 ; TC22.1 113.62,24.52
  TOP w1.27: F5.2 106.18,24.31 105.16,25.33 ; C360.2 131.07,9.51 USB6.1
  BOTTOM w0.508: 117.01,9.38 USB5.1 ; USB5.1 118.04,10.41 ; USB5.1 119.07,9.38 ; USB6.1 130.94,10.41 ; USB6.1 131.97,9.38 ; USB6.1 129.91,9.38
  vias: v2(125.17,13.62) v5(113.79,14.69) v5(113.79,13.7) v5(114.81,14.69) v5(114.81,13.7)
USBVCCTP: length 2.4
  TOP w0.508: TOUCH1.5 7.34,24.33
  TOP w1.016: TOUCH1.5 7.97,25.05 7.98,25.05
  vias: v2(11.35,25) v3(9.04,25.49) v3(9.09,24.65)
V_1P5_DAC_FB: length 5
  TOP w0.305: U29.AF2 138.71,64.61 138.71,63.2 v3(138.94,62.98)
  BOTTOM w0.508: v3(138.94,62.98) 138.99,62.93 138.99,62.05 138.96,62.02 v2(138.96,61.97) 138.96,61.91 138.67,61.61 C658.1 R996.2
V_1P5_DAC_FB_R: length 6.8
  BOTTOM w0.508: L40.2 v2(142.11,56.29) 142.49,56.67 142.49,57.28 142.12,57.65 C663.1 139.62,59.1 C662.1 R996.1
V_1P05_DSW_INT_C: length 2.2
  TOP w0.508: R289.2 152.13,88.81 v1(152.9,88.81) 153,88.9 C183.1
V_1P05_DSW_INT_R: length 7.9
  TOP w0.381: U29.AU41 144.64,85.68 U29.AU40
  TOP w0.508: R289.1 150.36,88.88 v1(149.61,88.12) 149.6,88.13 146.77,88.13 144.81,86.17 U29.AU41
V_1P05_LAN: length 11.2
  TOP w0.203: v3(28.07,39.48) 28.07,39.35 28.18,39.24 U26.22 ; v3(25.37,35.67) 25.39,35.67 25.4,35.68 U26.30 ; v3(27.94,33) 28.18,33.24 U26.3 ; U26.8 30.18,33.79 30.61,33.36 v3(30.61,33)
  L4 w0.762: v3(25.65,44.56) 26.8,43.42 26.8,42.26 26.9,42.16 26.9,40.65 v3(28.07,39.48)
  vias: v2(25.83,37.12)
V_1P05_ME: length 157.4
  TOP w0.356: 136.05,77.07 136.47,76.65 ; 136.05,77.07 U29.AA25 ; 136.05,77.07 136.06,77.07 v4(136.47,77.48) ; 136.47,76.65 136.86,76.26 U29.AB23 ; 136.47,76.65 136.08,76.26 U29.AA23 ; 136.47,76.65 136.89,77.07 U29.AB25 ; v4(136.47,77.48) 136.87,77.87 U29.AB26 ; v4(136.47,77.48) 136.08,77.87 U29.AA26 U29.W26 ; v4(136.47,77.48) U29.AB25 ; U29.AD17 U29.AD19 U29.AD20 U29.AD22 U29.AD23 137.72,76.26 v4(137.31,76.68) ; v4(137.31,76.68) 136.92,77.07 U29.AB25 ; v4(137.31,76.68) 136.89,76.26 U29.AB23 ; v4(137.31,76.68) 137.7,77.07 U29.AD25 U29.AF25 ; U29.AB23 U29.AB22
  L4 w0.254: v4(136.47,77.48) 136.37,77.59 128.66,77.59
  L4 w0.508: 128.66,77.59 124.12,73.04 119.27,73.04 109.61,63.38 92.15,63.38 90.5,61.73 86.74,61.73 85.92,62.56 77.53,62.56 72,57.03 62.18,57.03 61.65,56.5 49.87,56.5 48.7,57.67 47.1,57.67 46.71,57.28 46.71,57.06 46.02,56.37 45.02,56.37 44.1,55.46 42.7,55.46 41.3,54.06 41.3,52.72 35.3,46.72 35.3,44.48 34.64,43.81 34.64,41.9 34.94,41.6 34.94,41.57 36,40.5 36,38.19 37.64,36.56 43.93,36.56 45.1,37.73 v3(47.17,37.73)
  BOTTOM w0.381: v3(47.17,37.73) 47.02,37.73 47.01,37.72 Q109.1
  BOTTOM w0.508: 136.46,77.49 v2(134.75,77.49) C613.1 ; 136.46,77.49 135.38,78.58 C609.1 ; 136.46,77.49 v4(136.47,77.48) ; v4(137.31,76.68) 137.52,76.89 R970.2
V_1P5_PCH: length 127.1
  TOP w0.254: 124.6,73.91 124.64,73.87 U29.A19 ; v4(132.47,70.81) 132.61,70.95 133.04,70.95 U29.T14
  TOP w0.292: U29.K1 130.33,63.99 129.87,63.53 128.86,63.53 v3(128.52,63.86)
  TOP w0.305: U29.N10 131.34,68.57 v4(131.12,68.57) ; U29.B13 125.59,70.91 124.84,70.91 124.59,71.16
  TOP w0.356: U29.N10 U29.N11
  TOP w0.381: 124.6,73.91 124,73.91 123.79,73.69 121.23,73.69 120.65,74.28 120.27,74.28
  TOP w0.508: v3(179.45,97.43) 179.13,97.75 R221.1
  L3 w0.508: v4(131.12,68.57) 131.16,68.53 131.18,68.53 131.67,68.03 131.67,67.46 131.73,67.41 131.73,66.61 132.35,65.98 132.35,65.42 131.98,65.05 131.98,61.23 137.42,55.79 139.44,55.79 v3(139.83,55.4)
  BOTTOM w0.508: v3(128.52,63.86) 128.52,64.25 129.03,64.75 C645.1 129.09,65.55 130.04,65.55 R988.1 130.08,65.78 130.75,66.46 131.37,66.46 131.73,66.81 131.73,67.64 131.7,67.67 131.7,68.56 R982.1 131.81,68.91 132.83,69.93 C640.1 132.83,70.45 v4(132.47,70.81) ; R1003.1 141.07,52.18 L40.1 v3(139.83,55.4)
  BOTTOM w0.635: v3(179.45,97.43) 179.45,98.5 178.27,99.68 175.54,99.68 174.52,98.66 170.21,98.66 v2(167.74,96.19) 167.03,95.48 167.03,92.95 166.77,92.69 166.48,92.4 166.48,87.17 166.48,87.17 166.48,86 166.48,85.4 166.48,85.4 166.48,84.99 168.83,82.64 168.83,81.88 169.07,81.64 169.07,75.77 168.22,74.92 167.93,74.63 167.93,74.38 166.39,72.85 166.39,72.61 165.77,71.99 165.77,63.7 164.16,62.08 163.56,62.08 163.13,61.66 163.13,60.05 161.49,58.42 158.48,58.42 157.82,59.08 151.17,59.08 144.78,52.69 142.4,52.69 141.73,52.03 R1003.1
V_1P05_PCH: length 429.1
  TOP w0.178: U29.AB2 136.48,64.82 136.48,62.35 v4(136.34,62.21)
  TOP w0.203: v3(59.89,47.79) 59.89,49.02 60.05,49.18 U24.29
  TOP w0.305: v4(136.5,70.96) 136.66,70.96 U29.AC12
  TOP w0.356: v4(134.77,73.44) 135.18,73.03 U29.W17 ; v4(134.77,73.44) 134.37,73.84 ; v4(134.77,73.44) 134.37,73.03 U29.V17 ; v4(134.77,73.44) 135.18,73.84 ; U29.P14 U29.P16 132.56,72.32 132.56,72.94 U29.P17 133.02,73.39 133.07,73.39 133.51,73.82 U29.T19 133.49,73.84 v4(133.08,74.24) 133.49,74.65 ; v4(134.77,76.66) 135.18,77.07 U29.W25 ; v4(134.77,76.66) 135.18,76.26 ; v4(134.77,76.66) 134.37,77.07 U29.V25 ; v4(134.77,76.66) 134.37,76.26 134.37,76.26 ; U29.AA20 U29.AA19 136.07,73.84 v4(136.48,73.43) ; U29.AA20 136,74.65 U29.W19 135.18,73.84 ; U29.AA20 U29.AB20 U29.AB19 136.89,73.84 v4(136.48,73.43) ; v4(132.03,71.57) 131.71,71.25 U29.M14 ; U29.P28 132.68,78.68 v4(133.09,78.27) 132.7,77.87 U29.P26 U29.P25 132.68,77.07 v4(133.08,76.67) 132.66,76.26 ; 135.18,73.84 v4(134.77,74.24) ; 135.18,76.26 v4(134.77,75.86) ; 135.18,76.26 U29.W23 ; U29.V19 134.37,73.84 ; 134.37,73.84 134.37,73.84 v4(134.77,74.24) ; v4(134.77,74.24) 134.37,74.65 U29.V20 134.75,75.05 v4(134.77,75.05) 134.37,75.45 ; U29.V16 U29.T16 133.5,72.23 v4(133.1,72.63) ; 133.49,74.65 U29.T20 ; 133.49,74.65 133.47,74.65 U29.P22 132.68,75.45 v4(133.08,75.86) 132.68,76.26 132.66,76.26 ; v4(134.77,75.86) 134.37,75.45 134.37,75.45 ; v4(134.77,75.86) 134.37,76.26 ; U29.V14 134.25,71.42 v4(133.53,70.7) 133.86,70.7 U29.U12 ; 134.37,75.45 U29.V22 ; U29.P23 132.66,76.26 ; U29.V23 134.37,76.26 ; v4(136.48,73.43) 136.88,73.03 U29.AB17 U29.AB16 U29.AD16 ; U29.AF19 138.63,73.84 v4(139.01,74.22) U29.AF20 U29.AF22 U29.AF23 ; v4(142.88,75.04) 143.25,75.42 U29.AP22 ; U29.W14 135.16,71.42 v4(134.77,71.03) ; U29.AA16 U29.W16 135.18,72.23 v4(134.77,71.82)
  TOP w0.508: v3(68.58,44.66) 68.91,44.99 68.91,46.71 69.22,47.01 69.22,52.23 72.09,55.1 91.41,55.1 92.79,56.47 96.54,56.47 96.95,56.07 107.52,56.07 v3(107.95,56.5) ; v3(68.58,208.26) 68.96,207.88 R73.1
  L3 w0.381: 75.82,151.37 75.88,151.37 76.61,150.64 76.61,149.49 75.82,148.7
  L3 w0.508: v3(59.89,47.79) 61.06,46.62 61.06,46.06 61.14,45.99 61.14,36.88 61.16,36.86 v3(61.18,36.86) ; v4(133.53,70.7) 133.36,70.7 132.74,70.09 132.74,68.35 132.92,68.17 132.92,66.81 133.75,65.97 133.75,64.15 135.69,62.21 v4(136.34,62.21) ; 75.82,148.7 74.88,147.76 74.88,145.57 75.56,144.89 v3(75.56,142.73) 66.09,142.73 62.57,146.25 62.53,146.25 62.15,146.64 62.15,146.67 52.02,156.8 52.02,197.55 59.31,204.83 66.95,204.83 68.58,206.47 v3(68.58,208.26) ; v3(75.56,134.86) 76.61,135.9 82.69,135.9 87.88,130.71 109.85,130.71 115.46,125.1 125.04,125.1 125.29,124.86 125.44,124.86 125.76,124.55 126.23,124.55 126.62,124.16 126.62,123.68 126.87,123.43 v3(129.03,123.43) ; 75.82,151.37 75.4,151.79 75.4,154.33 77.3,156.23 v3(81.25,156.23)
  L4 w0.508: v3(61.18,36.86) 61.14,36.86 61.14,36.89 59.71,35.46 59.18,35.46 58.12,34.4 57.86,34.4 57.78,34.48 57.23,34.48 57.16,34.4 55.58,34.4 54.66,35.32 51.56,35.32 50.7,34.45 v3(50.7,34.42) ; v3(136.62,99.97) 137,100.34 137,102.76 136.53,103.23 136.53,107.59 137,108.06 137,120.03 133.6,123.43 v3(129.03,123.43) ; v3(68.58,44.66) 64.21,44.66 63.52,45.35 62.45,45.35 60.52,47.28 60.4,47.28 v3(59.89,47.79) ; v3(135.08,57.08) 134.82,56.83 134.82,50.99 130.15,46.31 v3(128.4,46.31) 128.4,52.59 126.39,54.59 123.37,54.59 120.17,57.79 114.83,57.79 113.92,56.88 108.33,56.88 v3(107.95,56.5)
  BOTTOM w0.254: Q111.1 v3(50.7,34.42)
  BOTTOM w0.508: R999.1 135.5,56.43 135.08,56.85 v3(135.08,57.08) 135.36,57.36 v2(135.36,58.91) 135.36,61.44 C654.1 135.85,61.67 136.25,62.06 136.25,62.09 136.34,62.19 v4(136.34,62.21) 136.32,62.24 C651.1 ; C628.1 136.53,73.49 v4(136.48,73.43) 136.54,73.37 136.9,73.37 137.11,73.17 137.11,72.95 C636.1 ; v4(134.77,76.66) 134.82,76.7 C619.1 ; C631.1 138.98,74.25 v4(139.01,74.22) 139.19,74.4 139.19,74.91 138.74,75.37 R970.1 ; R772.1 68.83,202 69.32,202.48 69.32,203.29 69.79,203.76 R756.1 ; v3(75.56,142.73) v3(75.56,134.86) ; R1004.1 58.12,50.8 58.12,49.24 R1017.2 59.37,49.2 60.07,48.5 60.52,48.5 C674.1 60.64,48.18 60.25,47.79 v3(59.89,47.79) ; v4(142.88,75.04) 143,74.91 C870.1 ; R1018.1 130.98,46.54 128.63,46.54 v3(128.4,46.31) ; C625.1 133.1,75.83 v4(133.08,75.86) ; v4(136.5,70.96) 136.72,70.96 138.08,72.32 C638.1 ; C632.1 134.71,74.17 v4(134.77,74.24) ; v3(81.25,156.23) 82.38,156.23 82.82,156.67 R826.1 ; v4(134.77,71.03) 134.36,71.03 C639.1
  BOTTOM w0.559: v3(68.58,208.26) 68.58,207.04 69.98,205.64 R756.1
  vias: v5(150.98,103.18) v5(151.99,103.18) v5(153.01,103.18) v5(154.03,103.18)
