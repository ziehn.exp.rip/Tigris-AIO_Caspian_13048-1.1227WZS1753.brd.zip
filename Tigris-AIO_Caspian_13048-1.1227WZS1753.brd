# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_GP8: length 6.6
  BOTTOM w0.102: R878.2 143.78,97.19 R879.2 142.64,97.24 R873.1 140.53,98.34 v2(139.83,99.04) 140.2,99.42 R863.2
PCH_GP27_PU: length 9.6
  TOP w0.102: R321.1 151.7,83.3 R313.1 151.51,83.74 v1(150.77,83.74) 150.3,83.74 149.82,83.25 148.89,83.25 148.7,83.07 148.17,83.07 147.19,82.09 146.09,82.09 146.03,82.16 145.69,82.16 145.58,82.27 144.98,82.27 144.68,81.96 U29.AU34
PCH_GP33_PU: length 21.8
  TOP w0.102: 162.49,72 R387.2 ; 162.49,72 162.19,72 v1(160.76,73.44) 160.2,74 157.33,74 156.26,75.07 154.74,75.07 154.36,74.69 153.26,74.69 152.62,75.32 152.18,75.32 151.54,74.69 149.13,74.69 146.66,77.15 145.92,77.15 145.64,77.43 145.19,77.43 145.09,77.53 U29.AV26 ; 162.49,72 R381.2
PCH_GPIO20: length 24.3
  TOP w0.102: v1(119.2,99.5) 119.21,99.49 R220.1 121.07,99.49 121.11,99.53 121.85,99.53 122.33,99.04 122.99,99.04 124.71,97.32 124.71,95.07 125.76,94.03 126.6,94.03 127.05,93.58 127.05,92.19 127.08,92.16 127.08,91.96 128.25,90.78 128.59,90.78 130.28,89.1 130.48,89.1 132.38,87.19 132.38,86.17 132.39,86.16 132.39,85.62 132.35,85.58 132.35,85.24 132.39,85.2 132.39,85.19 132.91,84.67 132.91,84.36 132.6,84.06 U29.P37
PCH_INTRUDER_L: length 326.4
  TOP w0.102: R279.2 150.91,91.69 151.99,92.77 v3(151.99,93.58)
  L4 w0.127: v3(151.99,93.58) 155.69,93.58 161.04,88.23 161.04,80.13 165.74,75.43 165.74,69.04 166.39,68.39 167.8,68.39 168.87,67.31 168.87,65.7 168.02,64.85 168.02,58.98 166.87,57.83 165.29,57.83 164.88,57.43 164.88,55.93 164.87,55.92 164.87,55.73 164.28,55.14 162.56,53.42 162.56,28.53 152.81,18.78 150.7,18.78 148.98,17.07 146.75,17.07 144.14,14.46 139.19,14.46 133.36,8.64 133.36,8.6 131.96,7.2 123.44,7.2 122.77,7.86 119.85,7.86 118.99,7.01 109.83,7.01 108.98,7.86 106.92,7.86 106.2,7.15 96.69,7.15 95.98,7.86 94.27,7.86 93.61,7.2 90.95,7.2 90.45,7.69 88.06,7.69 87.46,7.1 80.22,7.1 79.45,6.32 74.53,6.32 72.61,8.24 65.54,8.24 65.29,8 62.9,8 61.32,9.58 58.49,9.58 56.91,8 39.66,8 39.17,8.49 38.67,8.49 35.39,11.77 35.39,13.34 31.47,17.26 31.47,19.82 30.85,20.44 29.63,20.44 26.63,23.44 25.58,23.44 24.57,24.44 24.57,24.49 23.91,25.16 18.9,25.16 18.54,25.51 16.11,25.51 11.23,30.4 11.23,32.46 10.07,33.61 10.07,41.69 11.05,42.67 11.05,45.2 14.22,48.37 14.22,94.11 INTRU1.1
PCH_INTRUDER_N: length 10.7
  TOP w0.102: U29.AR41 143.45,86.27 143.64,86.46 143.64,86.81 145.64,88.82 145.64,89.19 146.44,89.99 v1(146.53,89.99) 146.96,89.99 147.07,90.09 148.7,90.09 149.2,90.58 149.2,91.07 148.97,91.3 R273.2 149.3,91.51 R279.1
PCH_INTVRMEN: length 10
  TOP w0.102: U29.AV36 145.47,83.25 146.37,83.25 147.6,84.49 147.6,84.49 148.03,84.92 148.04,84.92 148.78,85.67 151.62,85.67 R298.2 151.7,85.49 R307.2 152.78,84.41 v1(153.6,84.41)
PCH_JTAG_PWR: length 4.7
  BOTTOM w0.508: R866.1 130.12,99.75 131.16,99.75 R865.1 ; R865.1 131.26,99.75 132.23,99.75 R864.1 132.79,100.31 132.84,100.31 v2(132.84,100.69) ; R865.1 131.21,100.36 R862.2
PCH_JTAG_RST_R: length 25.9
  TOP w0.102: U29.W37 134.82,84.32 134.77,84.98 134.69,85.16 134.68,85.23 134.68,85.66 134.72,85.7 134.72,86.43 133.96,87.19 133.96,87.95 133.1,88.81 133.1,89.73 132.18,90.64 132.18,91.2 131.73,91.65 131.73,95.4 v1(131.02,96.11) 129.94,97.19 129.4,97.19 129.13,97.46 129.13,98.45 R217.1 C160.1 128.96,99.55 128.35,98.94 R218.1 125.69,98.49 124.51,98.49 v3(124.13,98.87) 123.85,98.87 123.23,99.49 R216.2
PCH_JTAG_TCK: length 11
  TOP w0.102: U29.Y40 135.96,85.21 135.96,86.39 136.08,86.51 136.14,86.57 136.14,87.02 135.45,87.7 135.45,88.56 134.11,89.9 134.11,90.41 134.11,90.41 134.11,91.41 C173.1 ; C173.1 133.77,91.75 v3(133.17,91.75) ; C173.1 134.47,92.02 134.47,92.76 133.85,93.37 R254.1
PCH_JTAG_TDI: length 20.4
  TOP w0.102: v3(129.59,97.65) 130.33,97.65 131.25,96.72 131.31,96.72 131.96,96.08 131.96,91.71 132.38,91.28 132.38,90.73 132.91,90.2 132.93,90.2 134.57,88.56 134.57,86.88 134.92,86.53 134.92,85.52 134.88,85.48 134.88,85.31 134.92,85.2 U29.W39
  BOTTOM w0.102: R891.1 130.58,97.35 TP112.1 130.58,98.4 R866.2 129.59,98.43 v3(129.59,97.65)
PCH_JTAG_TDO: length 21.7
  TOP w0.102: U29.Y38 135.44,84.42 135.44,84.72 135.37,84.79 135.37,85.05 135.49,85.17 135.49,85.54 135.33,85.7 135.33,86.75 135.25,86.83 135.25,88.46 133.05,90.66 133.04,90.66 132.79,90.91 132.79,91.45 132.44,91.81 132.44,98.18 133.22,98.96 v3(133.22,98.99)
  BOTTOM w0.102: R864.2 133.14,98.91 v3(133.22,98.99) 133.23,98.98 133.72,98.98 TP110.1 133.88,98.41 133.82,98.41 131.95,96.54 R889.1
PCH_JTAG_TMS: length 17.3
  TOP w0.102: U29.W40 135.13,85.42 135.13,86.63 135.05,86.71 135.05,88.37 133.01,90.41 132.99,90.41 132.59,90.81 132.59,91.37 132.19,91.77 132.19,96.43 v3(131.44,97.18)
  BOTTOM w0.102: R890.1 130.81,96.55 v3(131.44,97.18) 131.82,97.18 TP111.1 131.32,98.91 R865.2
PCH_LVDS_BL_ADJ: length 276.6
  TOP w0.165: v3(123.45,214.84) 123.35,214.94 123.29,214.94 122.89,215.35 122.58,215.35 121.77,216.16 v1(121.77,216.7) 121.77,224.8 122.5,225.54 v3(122.68,225.54) ; v3(175.51,116.06) 175.51,117.2 177.29,118.98 v3(178.31,118.98) ; U29.AP2 143.25,64.88 142.9,64.54 142.9,64.07 142.96,64.01 142.96,62.58 v4(142.43,62.05)
  L3 w0.165: v3(165.43,96.81) 164.48,96.81 163.45,95.78 163.45,91.81 162.73,91.09 162.73,83.32 158.95,79.54 158.95,72 151.94,64.99 147.99,64.99 145.34,62.34 142.72,62.34 v4(142.43,62.05) ; v3(178.31,118.98) 178.31,119.11 179.6,120.4 179.6,148.72 180.54,149.66 180.54,152.07 180.8,152.34 180.8,156.11 180.03,156.88 180.03,157.29 180.94,158.2 180.94,160.35 181.1,160.51 181.1,161.58 180.18,162.5 180.18,180.17 184.21,184.2 184.21,185.09 184.78,185.66 185.67,185.66 186.18,186.17 186.18,226.18 184.18,228.18 168.88,228.18 168.64,227.94 161.97,227.94 160.1,226.07 123.22,226.07 v3(122.68,225.54)
  L4 w0.165: v3(175.51,116.06) 176.03,115.55 176.03,109.72 177.17,108.58 177.17,102.4 176.6,101.83 170.65,101.83 165.62,96.81 v3(165.43,96.81)
  BOTTOM w0.165: R715.2 123.79,214.84 v3(123.45,214.84)
PCH_MEPWROK_R: length 24.7
  TOP w0.102: U29.AA32 136.33,81.05 136.62,80.77 v4(136.62,80.66) ; R287.2 v3(149.16,89.87)
  L4 w0.127: v4(136.75,89.14) 136.75,89.14 136.83,89.22 137.12,89.22 138.73,90.83 143.18,90.83 143.57,90.43 145.56,90.43 146.73,89.26 148.54,89.26 v3(149.16,89.87)
  BOTTOM w0.102: v4(136.75,89.14) 136.75,89.14 136.75,89.12 136.95,88.92 136.95,86.26 v2(136.4,85.71) 136.06,85.38 136.06,85.36 136.02,85.32 136.02,81.25 v4(136.62,80.66)
PCH_PCIECLKRQ1_N: length 130
  TOP w0.102: U29.P39 132.21,84.92 132.21,85.08 132.19,85.11 132.19,85.12 132.15,85.16 132.15,85.66 132.19,85.7 132.19,86.08 132.18,86.09 132.18,87.11 130.4,88.89 130.2,88.89 128.51,90.58 128.17,90.58 126.87,91.87 126.87,91.97 126.76,92.09 126.76,93.48 126.49,93.75 125.64,93.75 124.31,95.08 124.31,97.09 123.75,97.65 v3(123.6,97.65) 123.16,98.08 123.16,98.08 v1(122.88,98.36) 122.56,98.68 121.87,98.68 R1153.1
  L3 w0.127: v3(170.99,122.56) 170.85,122.42 170.85,122.22 169.88,121.24 164.8,121.24 159.92,116.37 155.91,116.37 153.89,114.35 153.89,111.86 152.39,110.37 152.39,109.31 152.4,109.3 152.4,108.21 151.51,107.32 141.71,107.32 139.93,105.55 136.58,105.55 132.92,101.89 132.92,101.43 132.35,100.86 132.35,100.83 131.36,99.84 126.3,99.84 125.21,98.76 125.21,98.75 124.1,97.65 v3(123.6,97.65)
  L4 w0.127: v3(170.99,122.56) 173.02,124.6 173.02,127.52 v3(173.83,128.33)
  BOTTOM w0.102: R833.1 189.74,155.18 190.53,154.39 190.53,152.68 184.61,146.77 175.68,146.77 174.65,145.74 174.65,129.63 173.83,128.81 v3(173.83,128.33)
PCH_PCIECLKRQ5_N: length 314.6
  TOP w0.102: Q1.D 94.15,241.83 94.87,242.55 v3(97.59,242.55) ; R223.1 137.62,98.03 v3(137.27,97.68) ; v4(136.63,82.77) 136.5,82.77 U29.AA36
  L3 w0.127: v3(183.39,217.1) 183.39,220.23 180.95,222.67 159.92,222.67 159.86,222.6 157.04,222.6 155.83,223.81 121.16,223.81 120.68,224.29 120.5,224.29 v3(120.47,224.27)
  L4 w0.127: v3(183.39,217.1) 184.68,215.81 184.68,197.06 184.84,196.9 184.84,188.35 184.23,187.74 184.23,187.66 183.85,187.28 183.85,184.39 183.91,184.33 183.91,183.69 182.4,182.18 181.89,182.18 179.64,179.94 179.64,176.16 182.47,173.34 184.1,173.34 187.72,169.72 187.72,166.87 187.45,166.61 187.45,144.46 179.04,136.05 179.04,123.78 176.12,120.86 176.12,120.33 170.68,114.89 166.2,114.89 163.28,111.97 163.04,111.97 159.22,108.15 158.94,108.15 158.85,108.06 150.59,108.06 148.97,106.44 148.97,105.68 150.14,104.5 154.02,104.5 155,103.52 155,100.24 154.62,99.86 154.62,99.74 154.35,99.46 153.63,99.46 151.31,97.14 147.63,97.14 146.8,96.31 146.8,95.65 146.52,95.37 144.59,95.37 144.28,95.67 144.28,96.42 141.68,99.02 141.09,99.62 139.21,99.62 v3(137.27,97.68)
  BOTTOM w0.102: v3(120.47,224.27) 119.51,225.23 118.88,225.23 117.98,226.13 117.98,245.78 116.59,247.18 115.49,247.18 113.89,245.58 107.68,245.58 107.42,245.31 107.42,244.71 106.15,243.44 104.69,243.44 104.43,243.19 104.24,243.19 102.89,241.84 98.3,241.84 v3(97.59,242.55) ; v3(137.27,97.68) 136.91,97.31 136.91,97.14 v2(136.7,96.94) 136.7,96.45 136.6,96.35 136.6,96.05 136.78,95.87 136.78,95.83 137.12,95.49 137.12,94.74 137.01,94.63 137.01,90.05 137.36,89.7 137.36,85.54 136.43,84.61 136.43,84.28 137.02,83.69 137.02,83.16 v4(136.63,82.77)
PCH_PCIECLKRQ5_N_1: length 29.4
  TOP w0.102: v3(94.01,242.48) 93.16,241.63 Q1.S 92.43,242.3 v1(91.59,242.3) 91.61,242.29 R2.2
  L3 w0.127: v3(113.16,231.25) 113.16,231.81 105,239.98 96.51,239.98 v3(94.01,242.48)
  BOTTOM w0.102: v3(113.16,231.25) 113.73,231.82 R676.2
PCH_PCIECLKRQ6_N: length 193.9
  TOP w0.102: U29.W32 135.12,81.05 v4(134.62,80.55) ; Q2.D 93.56,235.73 93.22,235.39 v3(93.22,235.37) ; v3(116.71,213.04) 116.59,212.91 116.59,208.92 116.81,208.69 118.56,206.94 118.86,206.94 118.86,206.94 120.47,206.94 122.1,205.32 123.64,205.32 125.2,203.76 125.2,202.8 125.98,202.01 125.98,193.41 124.21,191.63 124.21,123.82 124.26,123.77 124.26,122.65 125.77,121.14 126.82,121.14 v3(126.87,121.19)
  L4 w0.127: v3(133.78,99.52) 134.56,100.3 134.64,100.3 134.91,100.58 134.91,107.18 135.17,107.43 135.2,108.71 135.2,112.87 v3(126.87,121.19) ; v3(116.71,213.04) 116.07,213.69 115.37,213.69 115.24,213.56 109.18,213.56 108.5,213.56 107.44,214.61 98.42,214.61 v3(94.61,218.42)
  BOTTOM w0.102: v3(94.61,218.42) 94.61,224.13 94.03,224.71 94.03,225.09 94.23,225.29 v2(94.23,232.14) 94.23,233.36 94.54,233.66 94.54,234.04 94.11,234.47 94.11,234.48 v3(93.22,235.37) ; v3(133.78,99.52) 133.93,99.52 134.62,98.83 134.62,98.39 134.31,98.08 133.92,98.08 133.27,97.43 133.27,95.25 R905.1 134.53,94.41 134.85,94.09 134.85,93.02 135.08,92.8 135.08,91.84 134.67,91.42 134.03,91.42 133.88,91.28 133.88,90.4 135.51,88.77 135.51,87.65 136.14,87.02 136.14,86.59 135.62,86.07 135.62,81.55 v4(134.62,80.55)
PCH_PCIECLKRQ6_N_1: length 19.3
  TOP w0.102: R17.1 103.53,228.71 102.54,229.7 v3(102.54,230.87) ; v3(95.12,234.93) 95.12,235.95 93.44,237.64 Q2.S 93.16,237.54 92.75,237.13 R6.2
  BOTTOM w0.102: v3(102.54,230.87) 102.31,231.1 97.26,231.1 95.12,233.23 v2(95.12,233.89) v3(95.12,234.93)
PCH_RI: length 13.5
  TOP w0.102: v4(138.83,82.69) 138.71,82.69 U29.AE36
  BOTTOM w0.102: R911.1 141.99,92.76 v2(141.99,92.44) 140.77,91.22 140.77,90.78 140.64,90.65 140.64,89.82 140.23,89.41 140.23,88.86 139.06,87.69 139.06,84.7 138.97,84.61 138.97,84.14 138.37,83.55 138.37,83.14 v4(138.83,82.69)
PCH_RSMRST_N: length 15.4
  TOP w0.102: R275.2 149.64,95.69 148.73,95.69 v1(148.72,95.68) 148.38,95.68 147.81,95.11 146.96,95.11 146.66,94.8 146.66,93.86 144.91,92.1 144.91,91.69 143.64,90.43 143.64,90.26 R280.1 143.38,89.55 142.16,88.33 142.16,86.47 141.84,86.14 141.84,85.24 U29.AM40
PCH_RTCRST_DOWN: length 25.1
  TOP w0.102: v3(156.11,94.24) 156.11,92.97 154.91,91.78 R314.1
  BOTTOM w0.102: v3(156.11,94.24) 155.22,95.13 155.22,100.67 155.19,100.69 154.94,100.95 154.94,101.2 154.94,101.21 154.94,105.01 153.55,106.4 v2(151.96,106.4) 150.11,108.24 150.11,108.58 148.09,110.6 BTRST1.1
PCH_RTCRST_PULLUP: length 45.7
  TOP w0.102: v3(144.78,87.06) 144.98,87.06 146.58,88.66 149.34,88.66 149.71,89.02 149.71,89.79 150.44,90.53 150.44,90.67 153.38,93.6 R297.1 154.27,94.88 R306.2 C189.1 155.52,96.15 v3(156.26,95.41) ; v4(142.39,83.32) 142.49,83.42 142.49,83.94 142.73,84.18 U29.AR38
  BOTTOM w0.102: v4(142.39,83.32) 142.39,83.88 142.65,84.13 142.65,84.3 144.78,86.43 v3(144.78,87.06) ; v3(156.26,95.41) 156.26,97.37 155.83,97.8 155.83,100.92 155.61,101.15 155.55,101.2 155.55,105.26 153.79,107.02 v2(153.31,107.02) 152.63,107.02 152.61,107.01 152.24,107.01 152.22,107.02 152.2,107.02 150.72,108.49 150.72,109.98 150.47,110.23 150.47,110.24 BTRST1.2
PCH_RTCX1: length 19.3
  TOP w0.102: v3(152.61,87.64) 153.43,88.46 153.44,88.46 153.71,88.73 C205.1 154.23,88.73 R312.1 155.76,87.2 X1.4 ; U29.AN40 142.88,86.6 v3(143,86.72)
  BOTTOM w0.102: v3(143,86.72) 142.82,86.9 142.82,87.79 143.08,88.05 146.99,88.05 147.45,88.5 149.61,88.5 149.89,88.78 v2(150.77,88.78) 151.89,88.78 152.61,88.07 v3(152.61,87.64)
PCH_RTCX2: length 19.4
  TOP w0.102: U29.AN39 142.81,84.88 142.57,85.12 142.57,86.93 v3(143.26,87.61) ; R300.2 155.42,84.86 R312.2 155.42,86.32 C191.1 153.85,87.18 v3(151.94,87.18)
  BOTTOM w0.102: v3(143.26,87.61) 143.41,87.77 147,87.77 147.29,88.05 151.31,88.05 151.94,87.42 v3(151.94,87.18) 151.94,86.29 v2(152.02,86.22)
PCH_SATA_LED_1: length 10.3
  TOP w0.254: Q68.C 16.76,42.08 Q67.B 14.01,42.73 12.95,43.79 12.95,45.32 v1(12.73,45.55) 12.51,45.77 R504.2
PCH_SATA_LED_2: length 8.8
  TOP w0.762: Q67.C 12.13,43.04 Q70.C 11.49,40.12 10.16,40.12 9.09,39.05 PWRCN1.3
PCH_SATA_LED_N: length 152.3
  TOP w0.254: U29.J39 129.6,84.53 v4(129.46,84.39) ; R271.1 122.19,90.99 123.71,90.99 124.05,90.64 124.05,90.47 v3(124.41,90.11) ; v3(16.48,45.58) R507.1
  L4 w0.254: v4(129.46,84.39) 128.06,84.39 127.13,83.45 124.03,83.45 123.91,83.58 119.89,83.58 115.4,79.08 115.4,77.17 108.6,70.37 95.25,70.37 95.08,70.53 87,70.53 84.65,68.18 76.43,68.18 75.87,67.62 72.71,67.62 68.63,63.54 60.52,63.54 60.18,63.89 42.79,63.89 32.72,53.81 32.72,48.8 v3(34.54,46.97)
  BOTTOM w0.254: v3(16.48,45.58) v2(17.6,46.69) 18.64,47.74 31.47,47.74 32.77,46.44 33.81,46.44 34.22,46.85 34.42,46.85 v3(34.54,46.97) ; v3(124.41,90.11) 124.53,90 125.5,90 127.73,87.78 129.01,87.78 129.35,87.44 129.35,84.5 v4(129.46,84.39)
PCH_SATA_LED_R: length 2.7
  TOP w0.254: Q68.B 17.75,45.15 R507.2 v1(19.08,45.58)
PCH_SLP_M_N: length 3.1
  TOP w0.102: U29.AN37 143.15,83.83 143.2,83.87 143.49,83.87 144.03,84.41 v4(144.03,84.55)
  BOTTOM w0.102: TP117.1 145.34,84.55 v4(144.03,84.55)
PCH_SRTCRSTB_PULLUP: length 20.5
  TOP w0.102: v3(154.46,92.97) 154.27,93.16 R297.2 ; v3(150.5,94.12) 149.8,93.42 R305.2 149.07,93.42 R296.1 148.29,93.48 148.29,92.74 C188.1 147.45,91.8 145.95,90.31 145.95,89.78 145.44,89.27 145.44,88.9 143.43,86.89 143.43,86.55 143.11,86.22 143.11,85.72 143.18,85.65 143.18,85.08 U29.AR39
  BOTTOM w0.102: v3(150.5,94.12) 151.63,95.25 152.87,95.25 v2(153.74,94.38) 154.46,93.66 v3(154.46,92.97)
PCH_SYSPWROK: length 19.9
  TOP w0.102: v4(134.65,79.92) 134.7,79.92 135.12,80.34 U29.W31
  BOTTOM w0.102: v4(134.65,79.92) 135.82,81.08 135.82,85.89 136.47,86.54 136.47,88.56 134.47,90.56 C548.1 134.54,90.79 135.2,91.45 135.22,91.45 135.43,91.66 135.43,92.94 135.34,93.03 v2(135.34,94.85) 135.34,95.27 134.83,95.79 R887.2 R888.2
PCIAUX_GATE: length 4.2
  TOP w0.102: U24.92 45.72,39.58 44.98,39.58 44.52,40.04 v1(43.55,40.04) 42.87,40.04 42.25,40.66 R527.2
PCIE_CALR_RX: length 11.6
  TOP w0.102: v4(92.38,93.13) 92,93.13 91.65,93.47 88.41,93.47 88.22,93.28 88.22,93.14 87.89,92.81 84.02,92.81 U13.AA22
  BOTTOM w0.102: v4(92.38,93.13) 92.3,93.13 91.87,93.56 v2(91.87,93.86) 91.87,94.08 R1162.1
PCIE_CALR_TX: length 15.4
  TOP w0.102: U13.Y22 83.08,92.34 83.41,92.01 84.43,92.01 84.91,91.53 88.1,91.53 88.41,91.21 92.37,91.21 v4(93.47,92.31)
  BOTTOM w0.102: R1161.1 93.47,94.34 93.09,93.96 93.09,92.69 v4(93.47,92.31) 94.03,91.75 v2(94.03,91.65)
PCIE_RST#: length 353.7
  TOP w0.102: NGFF1.52 111.37,234.05 111.51,233.92 111.51,230.87 111.19,230.55 NGFF1.66 107.85,230.55 106.9,229.6 106.49,229.6 106.29,229.4 103.9,229.4 v3(103.06,230.23)
  L3 w0.127: v3(95.36,224.9) 101.07,219.19 104.78,219.19 111.44,212.53 112.14,212.53 115.09,209.58 115.09,206.68 125.28,196.49 160.92,196.49 166.73,190.69 168.59,190.69 168.69,190.58 168.87,190.51 169.06,190.38 169.23,190.21 169.36,190.02 169.43,189.84 172.09,187.19 172.09,174.83 172.25,174.67 172.25,164.87 171.65,164.28 171.65,123.79 170.9,123.03 170.8,123.03 170.52,122.76 170.52,122.66 169.54,121.68 164.69,121.68 159.76,116.75 153.7,116.75 149.86,112.91 149.86,111.27 146.97,108.38 137.76,108.38 132.14,102.77 125.73,102.77 119.98,97.01 119.98,89.91 120.27,89.63 120.27,87.12 117.98,84.84 117.98,79.62 108.69,70.32 108.69,69.78 102.13,63.23 94.22,63.23 93.91,63.23 89.61,58.94 85.78,58.94 82.37,62.34 76.48,62.34 72.35,58.21 69.55,58.21 68.13,56.79 65.93,56.79 63.55,54.4 52.84,54.4 52.72,54.53 51.29,54.53 50.03,53.26 50.03,49.74 v3(50.53,49.23)
  BOTTOM w0.102: v3(50.53,49.23) R1009.1 ; v3(103.06,230.23) 102.88,230.41 102.35,230.41 102.02,230.74 98.29,230.74 95.36,227.81 v2(95.36,225.94) v3(95.36,224.9)
PCIRST1#: length 6
  TOP w0.102: U24.51 52.47,53.35 51.71,54.1 v1(51.71,54.44) 51.82,54.54 R460.2 51.18,55.37 51.13,55.42 R457.2 50.27,55.42 50.22,55.37 R459.2
PCIRST2#: length 7.1
  TOP w0.102: v3(51.44,50.45) 52.07,51.09 U24.52
  BOTTOM w0.102: R1011.2 53.46,48.57 53.27,48.57 52.77,49.07 R1012.2 52.7,49.74 v2(52.37,50.07) 52.02,49.72 52.02,49.6 R1009.2 51.44,49.22 v3(51.44,50.45)
PECI_PCH: length 16
  TOP w0.102: U29.G40 128.51,85.36 128.51,86.11 126.85,87.78 126.71,87.78 126.49,88 121.91,88 119.99,89.92 119.53,89.92 119,89.39 v1(118.62,89.39) 118.18,89.83 R269.1 118.13,91.57 C174.1
PECI_READY: length 6.2
  TOP w0.102: v3(58.78,49.87) 59.22,49.44 59.91,49.44 60.46,49.98 U24.31
  BOTTOM w0.102: R1004.2 58.22,51.79 v2(59.19,51.79) 59.44,51.55 59.44,50.53 v3(58.78,49.87)
PECI_REQ_N: length 133.9
  TOP w0.102: U29.G38 128.69,84.02 128.3,84.4 128.3,86.03 126.76,87.57 126.63,87.57 126.4,87.8 121.76,87.8 120.07,89.49 v3(119.77,89.49) 119.1,88.81 v1(117.15,88.81) 115.95,90.01 R266.1
  L3 w0.127: v3(44.37,48.35) 44.82,48.79 44.82,50.17 44.22,50.77 44.22,51.9 47.3,54.99 52.8,54.99 53,54.78 63.39,54.78 65.78,57.17 67.97,57.17 69.39,58.59 72.19,58.59 76.32,62.72 76.64,62.72 82.53,62.72 85.93,59.32 89.46,59.32 93.75,63.61 94.38,63.61 101.97,63.61 108.31,69.94 108.31,70.48 117.6,79.78 117.6,87.32 v3(119.77,89.49)
  L4 w0.127: v3(44.37,48.35) 44.64,48.08 48.03,48.08 49.02,47.09 52.87,47.09 v3(52.9,47.12)
  BOTTOM w0.102: v3(52.9,47.12) 53.28,47.12 53.61,46.8 56.22,46.8 R1019.1
PECI_SIO_R: length 7.4
  TOP w0.102: v1(65.46,54.42) 65.46,54.2 R473.2 64.36,53.32 62.6,51.56 62.6,49.88 62.3,49.58 U24.30
PEG_C_RXN0: length 9.4
  TOP w0.127: U13.AG31 88.73,98.52 88.73,99.28 89.58,100.14 90.07,100.14 v4(90.35,100.42)
  BOTTOM w0.127: 91.38,100.5 91.02,100.14 90.63,100.14 v4(90.35,100.42) ; 91.38,100.5 v2(91.19,100.69) ; 91.38,100.5 91.72,100.83 91.72,101.01 91.99,101.28 92.16,101.28 92.43,101.55 92.43,101.94 92.31,102.06 92.31,102.44 92.43,102.57 92.43,102.95 92.31,103.07 92.31,103.45 92.43,103.58 92.43,103.96 C736.1
PEG_C_RXN1: length 8.3
  TOP w0.102: U13.AF28 87.75,97.47 88.08,97.8 88.08,97.87 88.08,97.87 88.08,98.05 88.01,98.15 88.01,98.49 88.15,98.86 88.15,100.04 88.38,100.27 88.38,100.33
  TOP w0.127: v3(90.42,102.22) 90.7,101.94 90.7,101.54 90.37,101.2 89.26,101.2 88.38,100.33
  BOTTOM w0.127: C741.1 90.7,102.77 90.7,102.5 v3(90.42,102.22)
PEG_C_RXN2: length 12.8
  TOP w0.127: U13.AF26 88.11,95.9 v4(88.11,95.95)
  BOTTOM w0.127: C750.1 87.68,106.55 87.68,101.23 88.13,100.78 88.13,100.14 ; v4(88.11,95.95) 87.71,96.35 87.7,96.35 87.27,96.78 87.27,98.27 88.13,99.13 88.13,100.14 ; v2(87.86,100.14) 88.13,100.14
PEG_C_RXN3: length 11.2
  TOP w0.127: v4(86.54,95.16) 86.16,95.54 U13.AD26
  BOTTOM w0.127: v4(86.54,95.16) 86.26,95.44 86.26,95.56 85.88,95.94 85.88,96.53 85.75,96.65 85.75,98.31 86.59,99.15 86.59,99.55 86.39,99.76 86.39,103.62 ; C738.1 86.39,104.42 86.39,103.62 ; v2(86.11,103.62) 86.39,103.62
PEG_C_RXN4: length 13.8
  TOP w0.127: v4(84.84,94.29) 84.39,94.74 U13.AB25
  BOTTOM w0.127: v4(84.84,94.29) 85.09,94.55 85.5,94.55 85.8,94.85 85.8,95.39 85.62,95.56 85.62,96.23 85.32,96.53 85.32,99.88 84.77,100.43 84.77,101.2 ; 84.77,101.2 84.77,105.65 C747.1 ; 84.77,101.2 v2(85.04,101.2)
PEG_C_RXN5: length 12.2
  TOP w0.127: v4(82.65,93.51) 83.08,93.94 U13.Y24
  BOTTOM w0.127: v4(82.65,93.51) 82.98,93.84 82.98,94.15 83.41,94.57 83.84,94.57 84.23,94.96 84.23,97.24 83.96,97.51 83.96,99.05 82.98,100.03 82.98,101.94 ; C744.1 82.98,102.87 82.98,101.94 ; 82.98,101.94 v2(82.7,101.94)
PEG_C_RXN6: length 13.2
  TOP w0.127: U13.AB26 84.19,95.54 v4(83.74,95.09)
  BOTTOM w0.127: v2(81.2,104.63) 81.49,104.63 ; 81.49,104.63 81.49,99.59 83,98.09 83,95.56 83.25,95.3 83.53,95.3 v4(83.74,95.09) ; 81.49,104.63 81.49,105.6 C737.1
PEG_C_RXN7: length 11.2
  TOP w0.127: U13.Y26 82.98,95.54 v4(82.64,95.2)
  BOTTOM w0.127: C749.1 79.25,103.43 79.25,102.75 ; v4(82.64,95.2) 82.47,95.37 82.09,95.37 81.84,95.63 81.84,97.24 80.14,98.94 80.14,101.3 79.25,102.19 79.25,102.75 ; v2(78.97,102.75) 79.25,102.75
PEG_C_RXP0: length 9.4
  TOP w0.127: v4(90.35,99.76) 90.22,99.88 89.69,99.88 88.98,99.18 88.98,98.31 U13.AH30
  BOTTOM w0.127: C740.1 92.68,104.04 92.68,101.44 92.46,101.22 ; v2(92.66,101.03) 92.46,101.22 ; 92.46,101.22 91.12,99.88 90.47,99.88 v4(90.35,99.76)
PEG_C_RXP1: length 8.3
  TOP w0.102: 88.56,100.15 88.54,100.15 88.35,99.96 88.35,98.82 88.21,98.45 88.21,98.45 88.21,98.22 88.28,98.12 88.28,97.63 88.37,97.54 U13.AG29
  TOP w0.127: v6(91.41,102.27) 90.96,101.81 90.96,101.43 90.47,100.95 90.24,100.95 90.12,100.82 89.74,100.82 89.61,100.95 89.36,100.95 89.22,100.81 89.22,100.63 88.95,100.36 88.77,100.36 88.56,100.15
  BOTTOM w0.127: v6(91.41,102.27) 90.96,102.73 90.96,102.94 C748.1
PEG_C_RXP2: length 12.7
  TOP w0.127: v4(88.16,96.76) 87.75,96.34 U13.AF27
  BOTTOM w0.127: 88.15,98.78 87.53,98.16 87.53,96.88 87.81,96.61 88.01,96.61 v4(88.16,96.76) ; 88.15,98.78 v2(88.34,98.59) ; 88.15,98.78 88.39,99.02 88.39,100.88 87.93,101.34 87.93,102.48 88.06,102.61 88.06,102.99 87.93,103.11 87.93,103.49 88.06,103.62 88.06,104 87.93,104.12 87.93,104.5 88.06,104.63 88.06,105.01 87.93,105.13 87.93,105.51 88.06,105.64 88.06,106.02 87.93,106.14 87.93,106.52 C743.1
PEG_C_RXP3: length 11.2
  TOP w0.127: U13.AD27 86.15,96.1 86.31,95.95 v4(86.56,95.95)
  BOTTOM w0.127: v4(86.56,95.95) 86.23,95.95 86.13,96.05 86.13,96.63 86,96.76 86,97.19 86.13,97.32 86.13,97.7 86,97.82 86,98.2 86.2,98.39 86.37,98.39 86.64,98.66 86.64,98.84 86.84,99.04 86.84,99.66 86.64,99.86 86.64,100.3 86.74,100.4 86.74,100.82 86.64,100.93 86.64,101.69 ; 86.64,101.69 v2(86.92,101.69) ; 86.64,101.69 86.64,102.32 86.76,102.44 86.76,102.82 86.64,102.95 86.64,103.33 86.76,103.45 86.76,103.83 86.64,103.96 86.64,104.34 C745.1
PEG_C_RXP4: length 13.8
  TOP w0.127: v4(84.96,95.13) 85.35,94.74 U13.AC25
  BOTTOM w0.127: v4(84.96,95.13) 84.96,94.91 85.06,94.8 85.39,94.8 85.55,94.95 85.55,95.28 85.37,95.46 85.37,96.12 85.06,96.43 85.06,97.75 84.94,97.88 84.94,98.26 85.06,98.38 85.06,98.77 84.94,98.89 84.94,99.27 85.06,99.4 85.06,99.78 84.52,100.32 84.52,101.81 84.39,101.93 84.39,102.31 84.52,102.44 84.52,102.82 84.39,102.94 84.39,103.32 84.52,103.45 84.52,103.83 84.39,103.95 84.39,104.34 84.52,104.46 84.52,104.99 ; 84.52,104.99 v2(84.23,104.99) ; 84.52,104.99 84.52,105.65 C739.1
PEG_C_RXP5: length 12.1
  TOP w0.127: v4(83.59,93.48) 83.25,93.14 U13.Y23
  BOTTOM w0.127: v2(83.52,100.72) 83.24,100.72 ; 83.24,100.72 83.24,102.84 C751.1 ; 83.24,100.72 83.24,100.14 84.21,99.16 84.21,97.61 84.48,97.35 84.48,94.85 83.95,94.32 83.52,94.32 83.24,94.04 83.24,93.84 v4(83.59,93.48)
PEG_C_RXP6: length 13.2
  TOP w0.127: v4(83.74,95.78) 84.31,96.34 U13.AB27
  BOTTOM w0.127: v2(82.02,100.72) 81.74,100.72 ; 81.74,100.72 81.74,99.7 83.25,98.19 83.25,95.66 83.36,95.55 83.52,95.55 v4(83.74,95.78) ; 81.74,100.72 81.74,102.05 81.84,102.14 81.84,102.58 81.74,102.68 81.74,103.06 81.87,103.18 81.87,103.56 81.74,103.69 81.74,105.64 C746.1
PEG_C_RXP7: length 11.1
  TOP w0.127: U13.Y27 82.95,96.23 v4(82.58,95.85)
  BOTTOM w0.127: C742.1 79.5,103.35 79.5,102.3 79.92,101.88 ; 79.92,101.88 80.39,101.41 80.39,101.03 80.52,100.9 80.52,100.52 80.39,100.4 80.39,99.05 80.66,98.78 80.84,98.78 81.11,98.51 81.11,98.33 81.38,98.06 81.55,98.06 81.82,97.79 81.82,97.62 82.09,97.35 82.09,96.97 82.21,96.84 82.21,96.46 82.09,96.34 82.09,95.73 82.2,95.63 82.35,95.63 v4(82.58,95.85) ; 79.92,101.88 v2(80.11,102.07)
PEG_C_TXN0: length 61.9
  TOP w0.102: CPU1.L2 70.66,148.69 70.46,148.49 70.46,147.71 70.92,147.25 70.92,146.97 70.89,146.95 70.89,146.92
  TOP w0.127: 70.89,146.92 70.89,146.64 69.73,145.48 69.73,140.29 71.12,138.9 77.7,138.9 79.02,140.22 83.51,140.22 88.72,135 88.72,125.6 92.58,121.74 92.58,118.63 ; C139.1 89.85,108.56 89.85,109.27 92.58,112 92.58,118.63 ; 92.58,118.63 v1(92.25,118.63)
PEG_C_TXN1: length 61.7
  TOP w0.102: 71.59,147.08 71.63,147.11 71.63,147.43 71.36,147.7 71.36,148.99 71.92,149.55 CPU1.M3
  TOP w0.127: 71.59,147.08 71.59,146.38 70.54,145.32 70.54,141.08 71.65,139.96 77.07,139.96 v4(77.35,139.68) ; 89.13,109.69 88.57,109.13 88.57,106.39 C152.1 ; 89.13,109.69 v1(88.9,109.92) ; 89.13,109.69 89.63,110.19 89.63,110.8 91.31,112.48 91.31,121.9 87.93,125.28 87.93,134.68 83.43,139.18 80.27,139.18 v4(80.01,138.92)
  BOTTOM w0.127: v4(80.01,138.92) 79.76,139.18 79.4,139.18 78.61,139.96 77.63,139.96 v4(77.35,139.68)
PEG_C_TXN2: length 60.4
  TOP w0.102: 69.51,147.22 69.51,147.25 69.53,147.27 69.53,149.39 CPU1.K3
  TOP w0.127: 87.33,109.36 87.33,109.92 89.31,111.9 89.31,112.43 90.53,113.65 90.53,121.57 86.92,125.18 86.92,134.55 83.36,138.11 70.75,138.11 68.87,139.99 68.87,145.88 69.51,146.52 69.51,147.22 ; 87.33,109.36 v1(87,109.36) ; 87.33,109.36 87.33,108.57 C137.1
PEG_C_TXN3: length 61.6
  TOP w0.102: 68.71,147.12 68.71,147.13 68.74,147.16 68.74,148.2 69.18,148.64 CPU1.J2
  TOP w0.127: C150.1 86.06,106.41 86.06,109.84 86.87,110.65 ; 68.71,147.12 68.71,146.84 68.08,146.21 68.08,139.77 68.08,139.66 69.96,137.78 70.42,137.32 83.03,137.32 86.03,134.32 86.03,124.41 89.56,120.88 89.56,113.83 87.45,111.72 87.45,111.24 86.87,110.65 ; v1(86.64,110.88) 86.87,110.65
PEG_C_TXN4: length 60.6
  TOP w0.102: CPU1.H3 68.05,149.74 67.93,149.74 67.7,149.51 67.7,147.86 67.56,147.71 67.56,147.13 67.53,147.11 67.53,147.09
  TOP w0.127: v1(88.14,114.11) 88.36,113.88 ; 88.36,113.88 88.77,114.29 88.77,120.56 85.24,124.09 85.24,133.97 82.67,136.53 70.03,136.53 67.27,139.3 67.27,146.53 67.53,146.79 67.53,147.09 67.53,147.09 ; 88.36,113.88 84.77,110.29 84.77,108.56 C135.1
PEG_C_TXN5: length 62.2
  TOP w0.102: CPU1.G2 67.35,148.64 66.8,148.09 66.8,147.18 66.77,147.15
  TOP w0.127: 66.77,147.15 66.22,146.6 66.22,139.2 69.7,135.72 82.32,135.72 84.45,133.59 84.45,123.71 87.99,120.18 87.99,115.15 87.17,114.33 ; 87.17,114.33 v1(86.94,114.56) ; 87.17,114.33 83.37,110.54 83.37,106.4 C148.1
PEG_C_TXN6: length 55.6
  TOP w0.102: 65.6,147.27 65.74,147.41 65.74,147.75 65.88,147.88 65.88,148.27 65.88,148.28 65.88,149.39 66.1,149.61 66.27,149.61 66.43,149.77 CPU1.F3
  TOP w0.127: C133.1 81.89,108.61 81.89,109.41 ; 65.6,147.27 65.38,147.05 65.38,138.79 79.96,124.22 82.8,124.22 83.21,123.81 83.21,123.81 87.2,119.82 87.2,116.19 81.89,110.88 81.89,109.41 ; v1(81.56,109.41) 81.89,109.41
PEG_C_TXN7: length 57.4
  TOP w0.127: CPU1.E2 65.1,148.61 65.1,147.74 64.36,147 64.36,138.26 79.88,122.74 83.16,122.74 86.36,119.55 86.36,116.65 80.33,110.61 80.33,107.93 ; v1(80.01,107.93) 80.33,107.93 ; 80.33,107.93 80.33,106.41 C146.1
PEG_C_TXP0: length 61.9
  TOP w0.102: 71.15,146.92 71.15,146.95 71.12,146.97 71.12,147.34 70.66,147.79 70.66,148.4 70.73,148.47 70.91,148.47 71.01,148.37 CPU1.L1
  TOP w0.127: 92.84,117.26 92.84,116.21 92.96,116.09 92.96,115.71 92.84,115.58 92.84,115.2 92.96,115.08 92.96,114.7 92.84,114.57 92.84,111.9 90.1,109.17 90.1,108.56 C140.1 ; 92.84,117.26 92.84,121.85 88.98,125.71 88.98,135.11 83.61,140.47 78.91,140.47 77.59,139.15 71.23,139.15 69.98,140.4 69.98,145.38 71.15,146.54 71.15,146.92 ; 92.84,117.26 v1(93.17,117.26)
PEG_C_TXP1: length 61.7
  TOP w0.102: 71.85,147.08 71.83,147.09 71.83,147.52 71.56,147.78 71.56,148.91 71.69,149.03 CPU1.M2
  TOP w0.127: 90.54,111.35 91.57,112.38 91.57,113.55 91.69,113.68 91.69,114.06 91.57,114.18 91.57,114.56 91.69,114.69 91.69,115.07 91.57,115.19 91.57,115.58 91.69,115.7 91.69,116.08 91.57,116.21 91.57,116.59 91.69,116.71 91.69,117.09 91.57,117.22 91.57,117.6 91.69,117.72 91.69,118.1 91.57,118.23 91.57,118.97 91.69,119.1 91.69,119.48 91.57,119.6 91.57,119.98 91.69,120.11 91.69,120.49 91.57,120.61 91.57,120.99 91.69,121.12 91.69,121.5 91.57,121.62 91.57,122.01 88.19,125.38 88.19,134.78 83.53,139.44 83.21,139.44 80.26,139.44 v4(80.01,139.68) ; 90.54,111.35 v1(90.78,111.11) ; 90.54,111.35 89.89,110.7 89.89,110.09 88.82,109.02 88.82,106.41 C153.1 ; 71.85,147.08 71.85,146.27 70.79,145.22 70.79,141.18 71.75,140.22 77.07,140.22 v4(77.35,140.5)
  BOTTOM w0.127: v4(80.01,139.68) 79.76,139.43 79.5,139.43 78.72,140.22 77.63,140.22 v4(77.35,140.5)
PEG_C_TXP2: length 60.3
  TOP w0.102: 69.76,147.22 69.76,147.25 69.74,147.27 69.74,149.31 69.87,149.44 70,149.44 70.09,149.34 CPU1.K2
  TOP w0.127: 90.07,112.84 89.56,112.33 89.56,111.79 89.01,111.24 89.01,111.06 88.74,110.79 88.56,110.79 87.58,109.81 87.58,108.54 C138.1 ; 90.07,112.84 v1(90.3,112.61) ; 90.07,112.84 90.78,113.55 90.78,121.68 87.17,125.29 87.17,134.66 83.47,138.36 70.85,138.36 69.12,140.09 69.12,145.78 69.76,146.42 69.76,147.22
PEG_C_TXP3: length 61.6
  TOP w0.102: 68.96,147.12 68.96,147.13 68.94,147.16 68.94,147.88 CPU1.J1
  TOP w0.127: 88.3,112.21 87.71,111.61 87.71,111.13 86.31,109.73 86.31,106.38 C151.1 ; 88.3,112.21 v1(88.54,111.97) ; 88.3,112.21 89.81,113.72 89.81,114.13 89.94,114.26 89.94,114.64 89.81,114.76 89.81,115.93 89.94,116.06 89.94,116.44 89.81,116.56 89.81,116.95 89.94,117.07 89.94,117.45 89.81,117.58 89.81,117.96 89.94,118.08 89.94,118.46 89.81,118.59 89.81,118.97 89.94,119.09 89.94,119.47 89.81,119.6 89.81,119.98 89.94,120.1 89.94,120.48 89.81,120.61 89.81,120.99 89.15,121.66 89.15,121.83 88.88,122.1 88.7,122.1 88.43,122.37 88.43,122.55 88.16,122.82 87.99,122.82 87.72,123.09 87.72,123.26 87.45,123.53 87.27,123.53 87,123.8 87,123.98 86.73,124.25 86.56,124.25 86.29,124.52 86.29,134.42 83.13,137.58 70.53,137.58 70.21,137.89 68.33,139.77 68.33,146.1 68.96,146.73 68.96,147.12
PEG_C_TXP4: length 60.6
  TOP w0.102: CPU1.H2 68.26,149.43 68.16,149.53 68.01,149.53 67.91,149.43 67.91,147.78 67.76,147.63 67.76,147.07 67.78,147.04 67.78,147.02
  TOP w0.127: 67.78,147.02 67.78,146.69 67.52,146.43 67.52,139.41 70.14,136.79 82.78,136.79 85.5,134.07 85.5,124.19 89.03,120.66 89.03,114.18 85.02,110.18 85.02,109.71 ; 85.02,109.71 85.02,108.56 C136.1 ; 85.02,109.71 v1(85.34,109.71)
PEG_C_TXP5: length 62.2
  TOP w0.102: CPU1.G1 67.12,148.12 67.01,148.01 67.01,147.03
  TOP w0.127: C149.1 83.63,106.4 83.63,107.1 83.75,107.22 83.75,107.61 83.63,107.73 83.63,108.11 83.75,108.23 83.75,108.62 83.63,108.74 83.63,109.64 ; 83.63,109.64 v1(83.95,109.64) ; 83.63,109.64 83.63,110.43 83.9,110.7 84.07,110.7 84.34,110.97 84.34,111.14 84.61,111.41 84.79,111.41 85.06,111.68 85.06,111.86 85.33,112.13 85.5,112.13 85.77,112.4 85.77,112.57 86.04,112.84 86.22,112.84 86.49,113.11 86.49,113.29 86.76,113.56 86.93,113.56 87.2,113.83 87.2,114 88.24,115.04 88.24,120.28 84.71,123.81 84.71,133.69 82.43,135.97 69.8,135.97 66.47,139.3 66.47,141.07 66.57,141.17 66.57,141.59 66.47,141.7 66.47,142.08 66.57,142.18 66.57,142.6 66.47,142.71 66.47,146.49 67.01,147.03
PEG_C_TXP6: length 55.6
  TOP w0.102: 65.78,147.09 65.95,147.26 65.95,147.66 66.08,147.79 66.08,148.36 66.08,149.3 66.18,149.41 66.33,149.41 66.43,149.3 CPU1.F2
  TOP w0.127: C134.1 82.14,108.53 82.14,110.78 82.41,111.05 82.59,111.05 82.86,111.32 82.86,111.49 83.13,111.76 83.3,111.76 83.57,112.03 83.57,112.21 83.84,112.48 84.02,112.48 84.29,112.75 84.29,112.92 85.29,113.93 ; v1(85.52,113.7) 85.29,113.93 ; 85.29,113.93 87.45,116.09 87.45,119.93 83.32,124.06 83.32,124.06 82.91,124.47 80.06,124.47 65.64,138.89 65.64,146.95 65.78,147.09
PEG_C_TXP7: length 57.4
  TOP w0.127: 80.98,110.9 86.61,116.54 86.61,119.65 83.27,123 79.99,123 68.32,134.67 68.32,134.84 68.05,135.11 67.87,135.11 67.6,135.38 67.6,135.56 67.33,135.83 67.16,135.83 66.89,136.1 66.89,136.27 66.62,136.54 66.44,136.54 66.17,136.81 66.17,136.99 65.9,137.26 65.73,137.26 65.46,137.53 65.46,137.7 65.19,137.97 65.01,137.97 64.62,138.37 64.62,141.68 64.74,141.8 64.74,142.19 64.62,142.31 64.62,142.69 64.74,142.82 64.74,143.2 64.62,143.32 64.62,143.7 64.74,143.83 64.74,144.21 64.62,144.33 64.62,144.71 64.74,144.84 64.74,145.22 64.62,145.34 64.62,145.72 64.74,145.85 64.74,146.23 64.62,146.35 64.62,146.89 65.52,147.8 CPU1.E1 ; 80.98,110.9 v1(81.2,110.68) ; 80.98,110.9 80.58,110.51 80.58,106.41 C147.1
PEG_COMP: length 8.8
  TOP w0.305: CPU1.P3 73.75,149.95 v3(74.2,150.4)
  BOTTOM w0.305: v2(73.29,149.25) 73.29,149.49 v3(74.2,150.4) 74.8,151 74.8,154.54 75.44,155.18 75.77,155.18 76.15,155.56 R831.2
PEG_RXN0: length 57.5
  TOP w0.127: v3(71.46,152.23) CPU1.L5
  BOTTOM w0.127: v2(75.62,124.82) 75.81,125.02 ; 75.81,125.02 73.32,127.51 73.32,146.52 70.72,149.13 70.72,151.67 71.02,151.97 71.2,151.97 v3(71.46,152.23) ; 75.81,125.02 76.8,124.04 76.8,123.36 92.41,107.75 92.41,105.53 C736.2
PEG_RXN1: length 58.2
  TOP w0.127: v3(69.63,152.23) CPU1.K6
  BOTTOM w0.127: C741.2 90.6,104.37 90.6,106.23 ; 90.6,106.23 90.6,107.38 88.87,109.1 88.87,110.09 71.67,127.3 71.67,140.22 70.82,141.08 70.82,146.02 71.15,146.35 71.15,147.6 70.08,148.67 70.08,151.79 v3(69.63,152.23) ; 90.6,106.23 v2(90.32,106.23)
PEG_RXN2: length 52.7
  TOP w0.127: v3(68.73,151.31) 68.73,151.33 CPU1.J5
  BOTTOM w0.127: v2(75.9,120.99) 76.09,121.18 ; 76.09,121.18 83.55,113.72 83.55,113.54 83.82,113.27 83.99,113.27 84.26,113 84.26,112.83 84.53,112.56 84.71,112.56 87.68,109.58 87.68,108.05 C750.2 ; 76.09,121.18 70.48,126.78 70.48,138.87 69.62,139.73 69.62,148.01 69.29,148.34 69.29,149.76 68.94,150.12 68.94,151.1 68.73,151.31 v3(68.73,151.31)
PEG_RXN3: length 55.8
  TOP w0.127: v3(67.79,152.17) 68.26,152.64 CPU1.H6
  BOTTOM w0.127: v2(81.25,113.85) 81.46,114.06 ; 81.46,114.06 82.86,112.66 82.86,112.48 83.13,112.21 83.3,112.21 86.42,109.09 86.42,106.37 86.11,106.06 C738.2 ; 81.46,114.06 68.73,126.78 68.73,148.12 67.97,148.88 67.97,149.79 68.28,150.1 68.28,150.76 68.04,151 68.04,151.93 v3(67.79,152.17)
PEG_RXN4: length 54.4
  TOP w0.127: v3(66.89,152.23) CPU1.G5
  BOTTOM w0.127: C747.2 84.73,107.21 84.73,107.91 ; 84.73,107.91 v2(85.01,107.91) ; 84.73,107.91 84.73,109.11 67.14,126.7 67.14,150.4 67.65,150.91 67.65,151.65 67.27,152.02 67.1,152.02 v3(66.89,152.23)
PEG_RXN5: length 56.6
  TOP w0.127: v3(65.98,152.23) CPU1.F6
  BOTTOM w0.127: v3(65.98,152.23) 65.53,151.79 65.53,151.11 65.7,150.94 65.7,126.18 74.08,117.8 ; C744.2 82.99,104.38 82.99,108.89 74.08,117.8 ; 74.08,117.8 v2(73.89,117.61)
PEG_RXN6: length 52.9
  TOP w0.127: v3(65.08,151.33) CPU1.E5
  BOTTOM w0.127: v2(74.42,115.53) 74.61,115.72 ; 74.61,115.72 81.47,108.86 81.47,107.15 C737.2 ; 74.61,115.72 64.74,125.59 64.74,148.55 64.39,148.9 64.39,149.8 64.61,150.02 64.61,150.86 v3(65.08,151.33)
PEG_RXN7: length 54.9
  TOP w0.127: v3(64.16,151.33) 64.61,150.89 CPU1.D4
  BOTTOM w0.127: 79.27,108.7 79.27,104.9 C749.2 ; 79.27,108.7 79.27,109.25 75.64,112.88 63.78,124.74 63.78,148.08 63.54,148.32 63.54,149.72 63.3,149.97 63.3,150.66 63.6,150.96 63.79,150.96 v3(64.16,151.33) ; 79.27,108.7 v2(78.99,108.7)
PEG_RXP0: length 57.5
  TOP w0.127: v3(71.46,151.32) CPU1.L4
  BOTTOM w0.127: C740.2 92.66,105.51 92.66,107.86 77.7,122.82 ; 77.7,122.82 77.05,123.47 77.05,124.15 73.58,127.62 73.58,137.99 73.7,138.11 73.7,138.49 73.58,138.62 73.58,139 73.7,139.12 73.7,139.51 73.58,139.63 73.58,146.62 70.97,149.23 70.97,151.56 71.13,151.72 71.34,151.72 71.46,151.59 v3(71.46,151.32) ; 77.7,122.82 v2(77.9,123.02)
PEG_RXP1: length 58.1
  TOP w0.127: CPU1.K5 v3(70.56,152.25)
  BOTTOM w0.127: C748.2 90.86,104.39 90.86,105.24 ; v3(70.56,152.25) 70.33,152.02 70.33,148.77 71.4,147.7 71.4,146.25 71.07,145.92 71.07,141.18 71.93,140.33 71.93,127.4 89.13,110.2 89.13,109.21 90.86,107.48 90.86,105.24 ; 90.86,105.24 v2(91.14,105.24)
PEG_RXP2: length 52.6
  TOP w0.127: v3(69.61,151.28) 69.59,151.28 69.18,150.86 CPU1.J4
  BOTTOM w0.127: C743.2 87.93,108.07 87.93,109.69 77.56,120.06 ; v3(69.61,151.28) 69.34,151.28 69.19,151.13 69.19,150.22 69.55,149.86 69.55,148.44 69.88,148.11 69.88,139.83 70.74,138.97 70.74,126.89 77.56,120.06 ; 77.56,120.06 v2(77.75,120.25)
PEG_RXP3: length 55.8
  TOP w0.127: v3(68.72,152.23) CPU1.H5
  BOTTOM w0.127: C745.2 87,106.06 86.68,106.37 86.68,109.2 82.5,113.37 ; 82.5,113.37 68.99,126.89 68.99,148.22 68.22,148.98 68.22,149.69 68.53,149.99 68.53,150.86 68.29,151.1 68.29,151.8 v3(68.72,152.23) ; 82.5,113.37 v2(82.7,113.57)
PEG_RXP4: length 54.3
  TOP w0.127: CPU1.G4 66.89,151.32 66.89,151.31 v3(66.88,151.31)
  BOTTOM w0.127: C739.2 84.48,107.13 84.48,109 83.07,110.41 ; 83.07,110.41 v2(82.88,110.22) ; 83.07,110.41 81.15,112.33 80.97,112.33 80.7,112.6 80.7,112.78 80.43,113.05 80.26,113.05 79.99,113.32 79.99,113.49 66.89,126.6 66.89,150.51 67.4,151.02 67.4,151.54 67.22,151.72 67.04,151.72 66.88,151.56 v3(66.88,151.31)
PEG_RXP5: length 56.7
  TOP w0.127: v3(65.98,151.32) CPU1.F5
  BOTTOM w0.127: C751.2 83.25,104.38 83.25,104.95 83.37,105.07 83.37,105.45 83.25,105.58 83.25,105.96 83.37,106.08 83.37,106.46 83.25,106.59 83.25,106.97 83.37,107.09 83.37,107.48 83.25,107.6 83.25,107.98 83.37,108.11 83.37,108.49 83.25,108.61 83.25,108.99 81.56,110.68 81.56,110.86 81.29,111.13 81.11,111.13 80.84,111.4 80.84,111.58 80.57,111.84 80.4,111.84 80.13,112.11 80.13,112.29 79.86,112.56 79.68,112.56 79.41,112.83 79.41,113.01 79.14,113.27 78.97,113.27 78.7,113.54 78.7,113.72 78.43,113.99 78.25,113.99 77.52,114.72 ; 77.52,114.72 v2(77.72,114.92) ; 77.52,114.72 65.96,126.28 65.96,143.41 66.07,143.52 66.07,143.94 65.96,144.04 65.96,144.42 66.07,144.53 66.07,144.95 65.96,145.05 65.96,145.44 66.07,145.54 66.07,145.96 65.96,146.07 65.96,150.94 65.98,150.95 v3(65.98,151.32)
PEG_RXP6: length 52.9
  TOP w0.127: v3(65.08,150.42) CPU1.E4
  BOTTOM w0.127: v3(65.08,150.42) 64.86,150.2 64.86,149.91 64.64,149.7 64.64,149.01 65,148.65 65,125.69 68.84,121.85 69.02,121.85 69.29,121.58 69.29,121.4 69.56,121.13 69.73,121.13 70,120.87 70,120.69 70.27,120.42 70.45,120.42 70.72,120.15 70.72,119.97 70.99,119.7 71.16,119.7 71.43,119.44 71.43,119.26 71.7,118.99 71.88,118.99 72.15,118.72 72.15,118.54 75.86,114.83 ; C746.2 81.72,107.15 81.72,108.97 80.37,110.32 80.37,110.5 80.1,110.77 79.92,110.77 79.65,111.04 79.65,111.21 79.38,111.48 79.21,111.48 78.94,111.75 78.94,111.93 78.67,112.2 78.49,112.2 78.22,112.47 78.22,112.64 77.96,112.91 77.78,112.91 77.51,113.18 77.51,113.36 77.24,113.63 77.06,113.63 75.86,114.83 ; 75.86,114.83 v2(76.07,115.05)
PEG_RXP7: length 54.9
  TOP w0.127: CPU1.D3 64.61,149.97 v3(64.16,150.42)
  BOTTOM w0.127: v2(78.28,111.01) 78.08,110.8 ; 78.08,110.8 64.04,124.85 64.04,148.18 63.8,148.42 63.8,149.83 63.55,150.07 63.55,150.55 63.71,150.71 63.87,150.71 v3(64.16,150.42) ; 78.08,110.8 78.68,110.21 78.85,110.21 79.12,109.94 79.12,109.76 79.53,109.36 79.53,108.28 79.65,108.16 79.65,107.77 79.53,107.65 79.53,107.27 79.65,107.14 79.65,106.76 79.53,106.64 79.53,106.26 79.65,106.13 79.65,105.75 79.53,105.63 79.53,104.92 C742.2
PEG_TXN0: length 11.2
  TOP w0.102: 88.11,101 88.09,100.98 88.09,100.94 87.1,99.94 87.1,99.01 87.22,98.89 87.22,98.61 U13.AE31
  TOP w0.127: v1(89.08,102.42) 89.3,102.2 ; 89.3,102.2 88.83,101.72 88.65,101.72 88.38,101.45 88.38,101.27 88.11,101 ; 89.3,102.2 89.84,102.73 89.84,103.11 89.72,103.24 89.72,103.62 89.84,103.74 89.84,104.58 89.72,104.7 89.72,105.09 89.84,105.21 89.84,105.59 89.72,105.72 89.72,106.1 89.84,106.22 89.84,107.05 C139.2
PEG_TXN1: length 9.7
  TOP w0.102: 87.02,100.95 87.02,100.89 86.31,100.19 86.31,99.68 86.55,99.45 86.55,98.86 86.41,98.49 86.41,98.15 86.48,98.05 86.48,97.47 U13.AD28
  TOP w0.127: 87.87,101.8 87.02,100.95 ; 87.87,101.8 v1(87.63,102.04) ; 87.87,101.8 88.16,102.1 88.16,102.87 88.58,103.29 88.58,104.88 C152.2
PEG_TXN2: length 10.9
  TOP w0.102: 85.39,100.01 85.39,100 85.42,99.97 85.42,99.12 85.6,98.94 85.6,98.59 U13.AC31
  TOP w0.127: C137.2 87.31,107.03 87.31,106.65 87.19,106.53 87.19,106.15 87.31,106.02 87.31,105.64 87.19,105.52 87.19,105.14 87.31,105.01 87.31,104.63 87.19,104.51 87.19,104.13 87.31,104 87.31,103.07 86.79,102.55 86.79,101.77 86.52,101.5 ; 86.52,101.5 86.52,101.5 86.12,101.09 85.94,101.09 85.67,100.82 85.67,100.64 85.39,100.37 85.39,100.01 ; 86.52,101.5 v1(86.28,101.74)
PEG_TXN3: length 9.3
  TOP w0.102: 84.71,100.82 84.71,100.81 84.73,100.78 84.73,100.03 84.95,99.82 84.95,98.86 84.81,98.49 84.81,98.15 84.88,98.05 84.88,97.47 U13.AB28
  TOP w0.127: 85.27,102.32 86.04,103.09 86.04,104.88 C150.2 ; 85.27,102.32 84.71,101.76 84.71,100.82 ; 85.27,102.32 v1(85.04,102.55)
PEG_TXN4: length 10.1
  TOP w0.127: C135.2 84.76,107.05 84.76,106.66 84.64,106.54 84.64,106.16 84.76,106.03 84.76,105.65 84.64,105.53 84.64,105.15 84.76,105.02 84.76,104.55 84.64,104.43 84.64,104.05 84.76,103.92 84.76,103.57 84.47,103.28 84.29,103.28 84.02,103.01 84.02,102.83 83.82,102.63 83.82,102.14 83.74,102.07 83.74,101.67 83.82,101.59 83.82,99.2 83.95,99.06 83.95,98.54 U13.AA31
PEG_TXN5: length 9.1
  TOP w0.102: U13.Y28 83.4,97.59 83.4,97.89 83.21,98.15 83.21,98.49 83.38,98.94 83.38,99.64 83.06,99.96 83.06,100.64 83.03,100.67
  TOP w0.127: 83.03,100.67 83.03,101.89 ; 83.03,101.89 83.03,103.44 83.37,103.78 83.37,104.88 C148.2 ; 83.03,101.89 v1(82.72,101.89)
PEG_TXN6: length 10.2
  TOP w0.102: U13.W31 82.34,98.53 82.34,99.59 81.89,100.03 81.89,100.42 81.79,100.52 81.79,100.82 81.89,100.92 81.89,101.23 81.85,101.27
  TOP w0.127: C133.2 81.85,107.04 81.85,106.66 81.73,106.54 81.73,106.16 81.85,106.03 81.85,105.65 81.73,105.53 81.73,105.15 81.85,105.02 81.85,104.33 ; 81.85,101.27 81.85,101.65 81.73,101.77 81.73,102.15 81.85,102.28 81.85,102.66 81.73,102.78 81.73,103.16 81.85,103.29 81.85,104.33 ; 81.85,104.33 v1(81.53,104.33)
PEG_TXN7: length 9.4
  TOP w0.102: 80.31,101.51 80.34,101.48 80.34,100.62 81.75,99.21 81.75,98.86 81.61,98.49 81.61,98.15 81.78,97.92 81.78,97.57 U13.V28
  TOP w0.127: C146.2 80.31,104.9 80.31,103.77 ; v1(79.98,103.77) 80.31,103.77 ; 80.31,103.77 80.31,101.51
PEG_TXP0: length 11.2
  TOP w0.102: 88.29,100.82 88.27,100.82 87.3,99.86 87.3,99.09 87.42,98.97 87.42,98.59 87.75,98.26 U13.AF30
  TOP w0.127: 88.29,100.82 90.09,102.63 90.09,106.36 ; v1(90.42,106.36) 90.09,106.36 ; 90.09,106.36 90.09,107.02 C140.2
PEG_TXP1: length 9.7
  TOP w0.102: U13.AE29 87.07,97.54 87.17,97.64 87.17,97.89 87.07,98 86.81,98 86.69,98.12 86.61,98.22 86.61,98.45 86.75,98.82 86.75,99.53 86.52,99.77 86.52,100.11 87.18,100.77 87.2,100.77
  TOP w0.127: 87.2,100.77 88.42,101.99 88.42,102.76 88.83,103.18 88.83,104.15 ; v1(89.15,104.15) 88.83,104.15 ; 88.83,104.15 88.83,104.88 C153.2
PEG_TXP2: length 10.9
  TOP w0.102: U13.AD30 85.8,98.29 85.8,99.03 85.62,99.2 85.62,99.98 85.65,100.01
  TOP w0.127: 87.56,103.54 87.56,107.03 C138.2 ; 87.56,103.54 87.56,102.96 87.05,102.44 87.05,101.66 85.65,100.26 85.65,100.01 ; 87.56,103.54 v1(87.88,103.54)
PEG_TXP3: length 9.3
  TOP w0.102: 84.96,100.82 84.94,100.8 84.94,100.12 85.15,99.91 85.15,98.82 85.01,98.45 85.01,98.22 85.18,98 85.47,98 85.57,97.9 85.57,97.64 85.47,97.54 U13.AC29
  TOP w0.127: 86.29,104.15 v1(86.61,104.15) ; 86.29,104.15 86.29,102.99 84.96,101.66 84.96,100.82 ; 86.29,104.15 86.29,104.88 C151.2
PEG_TXP4: length 10.5
  TOP w0.127: v1(85.34,104.1) 85.01,104.1 ; 85.01,104.1 85.01,107.02 C136.2 ; 85.01,104.1 85.01,103.46 84.07,102.52 84.07,99.3 84.21,99.17 84.21,98.28 U13.AB30
PEG_TXP5: length 9.1
  TOP w0.102: U13.AA29 83.92,97.54 84.02,97.64 84.02,97.9 83.92,98 83.6,98 83.49,98.12 83.41,98.22 83.41,98.45 83.58,98.9 83.58,99.72 83.26,100.04 83.26,100.64 83.29,100.67
  TOP w0.127: 83.63,104.23 83.63,104.88 C149.2 ; 83.63,104.23 v1(83.94,104.23) ; 83.63,104.23 83.63,103.68 83.29,103.34 83.29,100.67
PEG_TXP6: length 10.2
  TOP w0.102: U13.Y30 82.54,98.35 82.54,99.67 82.09,100.12 82.09,101.24 82.11,101.25 82.11,101.27
  TOP w0.127: v1(82.42,103.21) 82.11,103.21 ; 82.11,103.21 82.11,101.27 ; 82.11,103.21 82.11,107.04 C134.2
PEG_TXP7: length 9.3
  TOP w0.102: U13.W29 82.27,97.54 82.4,97.67 82.4,97.88 82.27,98.01 81.97,98.01 81.81,98.22 81.81,98.45 81.95,98.82 81.95,99.3 80.54,100.7 80.54,101.48 80.57,101.51
  TOP w0.127: v1(80.9,102.02) 80.57,102.02 ; 80.57,102.02 80.57,104.87 C147.2 ; 80.57,102.02 80.57,101.51
PHASE1_R: length 18.6
  TOP w0.254: PR45.2 31.41,131.26 PR46.2 32.61,130.77 31.86,130.02 v1(31.86,127.62) 31.86,115.85 v3(32.11,115.6)
  BOTTOM w0.254: v3(32.11,115.6) 32.11,115.17 PG4.1
PLTRST*_SIO: length 5
  TOP w0.102: U24.14 60.42,43.18 59.77,42.53 v3(59.77,42.43)
  BOTTOM w0.102: R1034.1 59.05,40.31 59.05,41.13 v2(59.56,41.64) 59.56,42.15 59.74,42.33 59.74,42.4 v3(59.77,42.43)
PLTRST_CPU_N: length 229.6
  TOP w0.102: v3(62.48,208.37) 65.39,208.37 66.12,207.63 R72.1 ; U29.F41 127.96,86.08 126.68,87.37 126.55,87.37 126.32,87.6 121.61,87.6 120.55,88.65 v3(119.82,88.65)
  L4 w0.127: v3(62.48,208.37) 62.48,206.23 57.28,201.02 57.28,188.91 56.52,188.15 56.52,169.61 55.82,168.91 55.82,147.3 79.94,123.17 93.16,123.17 93.42,122.92 114.05,102.29 114.05,101.98 114.05,101.98 114.05,94.22 119.61,88.66 119.82,88.66 v3(119.82,88.65)
  BOTTOM w0.102: R638.1 56.01,246.71 55.23,247.48 46.04,247.48 44.15,245.59 44.15,227.25 59.79,211.6 59.79,210.32 v2(61.16,208.95) 61.75,208.37 v3(62.48,208.37)
PLTRST_CPU_N1: length 5.7
  TOP w0.102: Q11.5 67.31,213.34 67.44,213.47 67.44,213.85 67.29,213.99 Q11.6 66.6,214.69 67.13,215.22 v1(68.2,215.22) R57.2
PLTRST_CPU_N2: length 5.9
  TOP w0.102: R62.2 63.82,209.47 v1(64.52,210.17) 64.9,210.55 65.86,210.55 R61.2 66.12,210.83 64.72,212.23 Q11.3
PLTRST_CR: length 216.4
  TOP w0.102: v3(52.52,54.06) 52.52,54.34 52.43,54.44 52.43,54.7 52.31,54.81 52.31,55.62 52.35,55.66 52.35,56.55 52.48,56.67 52.48,57.67 52.5,57.7 52.5,58.1 v1(52.58,58.18) 51.84,58.18 50.67,57.01 R457.1
  L3 w0.127: v3(52.52,54.06) 52.55,54.06 52.59,54.02 63.82,54.02 66.21,56.41 68.29,56.41 69.71,57.83 72.59,57.83 76.66,61.91 82.07,61.91 85.43,58.56 89.77,58.56 94.06,62.85 102.29,62.85 109.07,69.63 109.07,70.14 118.36,79.44 118.36,84.41 120.51,86.56 120.51,89.7 120.36,89.85 120.36,96.86 124.55,101.05 126.81,101.05 128.14,102.38 132.3,102.38 137.76,107.85 149.85,107.85 150.46,108.45 150.46,110.97 152,112.51 152.65,112.51 v3(153.42,113.27)
  L4 w0.127: v3(182.99,160.92) 182.92,160.85 182.92,151.36 179.83,148.27 179.83,142.49 177.72,140.38 177.72,124.33 169.64,116.24 165.62,116.24 164.2,114.82 154.97,114.82 v3(153.42,113.27)
  BOTTOM w0.102: U39.14 182.08,160.02 v3(182.99,160.92)
PLTRST_LAN_N: length 44.4
  TOP w0.102: v3(35.56,42.67) 35.1,42.67 33.44,41.02 33.44,41.02 33.3,40.88 32.82,40.88 31.92,39.98 30.09,39.98 29.38,39.27 U26.19
  L4 w0.127: v3(35.56,42.67) 35.56,42.67 35.56,42.48 35.77,42.27 35.77,41.91 36.83,40.85 36.83,38.54 37.98,37.39 38.73,37.39 39.89,38.54 40.81,38.54 40.9,38.63 40.93,38.63 42.19,39.89 42.19,41.53 42.75,42.09 43.73,42.09 43.81,42.01 47.34,42.01 48.05,41.3 50.47,41.3 51.18,42.01 55.2,42.01 v3(55.72,42.53)
  BOTTOM w0.102: v3(55.72,42.53) 55.72,45.36 v2(55.12,45.96) 54.7,46.38 53,46.38 52.45,46.93 52.45,47.79 52.7,48.05 R1012.1
PLTRST_N: length 315.3
  TOP w0.102: v4(136.61,83.43) 136.57,83.43 136.3,83.7 U29.AA37 ; v3(60.58,210.3) 61.79,211.5 R59.1
  L3 w0.127: v3(59.66,43.21) 58.64,44.24 58.64,47.65 59.24,48.26 61.73,48.26 63.25,49.77 64.05,49.77 65.83,51.55 66.67,51.55 68.64,53.51 69.49,53.51 70.91,54.94 91,54.94 94.87,58.81 100.79,58.81 102.07,57.53 108.75,57.53 109.18,57.1 109.56,57.1 111.38,58.91 111.38,65.67 113.54,67.83 113.54,68.01 119.31,73.78 119.43,73.78 119.8,74.15 124.12,74.15 126.19,76.22 126.19,80.13 125.59,80.73 125.59,84.96 124.64,85.91 v3(124.64,86.65) 124.98,86.31 125.71,86.31 125.97,86.57 125.97,86.9 127.25,88.17 127.4,88.17 128.22,88.99 128.22,92.4 128.21,92.41 128.21,93.74 128.23,93.77 128.23,94.48 130.78,97.04 130.78,97.91 131.3,98.42 131.95,98.42 134.3,100.77 v3(134.44,100.77)
  L4 w0.127: v3(124.64,86.65) 124.07,86.08 119.79,86.08 113.28,92.58 113.28,101.98 99.39,115.87 84.5,115.87 53.12,147.25 53.12,169.39 54.36,170.63 54.36,201.41 60.2,207.25 60.2,209.91 v3(60.58,210.3)
  BOTTOM w0.102: R1034.2 58.61,40.75 R1032.1 58.61,42.16 v3(59.66,43.21) ; v4(136.61,83.43) 136.23,83.82 136.23,84.78 137.15,85.71 137.15,89.55 136.65,90.05 136.65,94.78 136.77,94.89 136.77,95.34 136.48,95.63 136.4,95.63 136.14,95.89 136.14,98.23 134.77,99.6 v2(134.77,99.91) 134.44,100.24 v3(134.44,100.77)
PLTRST_N_R: length 4.5
  TOP w0.102: v1(62.23,212.39) R59.2 63.25,213.28 C25.1 ; C25.1 Q11.2 ; C25.1 R55.2
PLTRST_SL_N: length 193.4
  TOP w0.102: v3(138.56,37.37) 138.46,37.37 138.04,37.79 138.04,43.57 140.54,46.08 140.72,46.08 141.49,46.85 144.15,46.85 144.4,46.59 Q61.D 147.96,45.51 R472.1 ; R459.1 49.63,57.26 49.15,57.74 v3(49.15,58.15) ; R1160.2 95.64,94.28 96.41,95.04 R1159.1 96.74,95.04 97,94.78 97.99,94.78 98.81,93.96 100.36,93.96 102.49,91.83 102.49,89.26 101.7,88.48 v3(101.7,88.12) 103.5,88.12 104.65,89.26 109.6,89.26 114.39,84.47 114.68,84.47 115,84.15 115,82.85 115.57,82.28 115.57,81.14 114.49,80.05 D7.2 114.41,79.87 115.65,78.63 115.65,71.99 114.02,70.37 114.02,60.34 117.04,57.31 117.04,54.7 115.65,53.3 115.65,45.86 116.45,45.06 120.46,45.06 121.31,44.21 121.31,40.2 122.1,39.41 123.29,39.41 LPC1.3
  L3 w0.127: v3(101.7,88.12) 101.7,87.84 101.22,87.36 101.22,85.45 99.06,83.3 99.06,79.17 96.27,76.37 96.27,72.6 89.85,66.19 89.85,65.19 89.48,64.82 87.27,64.82 86.57,65.52 77.8,65.52 68.83,65.52 62.31,58.99 50.22,58.99 49.38,58.15 v3(49.15,58.15) ; LPC1.3 125.09,38.4 125.95,37.55 127.41,37.55 127.79,37.16 129.36,37.16 129.66,36.86 130.95,36.86 131.89,35.92 132.94,35.92 133.5,35.92 133.51,35.92 134.86,35.92 136.3,37.36 137.46,37.36 137.69,37.36 137.7,37.37 v3(138.56,37.37)
PLTRST_TPM_N: length 10.1
  TOP w0.102: U22.16 U23.16 148.56,43.39 149.35,44.18 R471.2 R472.2 146.95,46.01 145.37,46.01 Q61.S 145.37,45.21 v1(145.37,44.31)
PM_DPRSLPVR: length 4.6
  TOP w0.254: PR17.1 47.45,143.82 48.59,144.97 PR15.2 PR7.1 v1(49.31,147.18)
