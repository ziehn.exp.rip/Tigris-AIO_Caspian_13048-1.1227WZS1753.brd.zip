# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
RT8243_ENTRIP1_2: length 6.8
  TOP w0.254: PR87.1 101.83,36.31 102.93,37.41 Q73.D 102.93,38.46 103.92,38.46 v3(104.05,38.34)
  BOTTOM w0.254: v3(104.05,38.34) 104.22,38.34 v2(104.85,38.97) 105.04,39.16 R1055.1
RT8243_ENTRIP2: length 3.3
  TOP w0.203: 98.3,38.59 PU6.4
  TOP w0.254: 98.3,38.59 98.91,39.2 v1(99.11,39.2) 99.28,39.2 R539.1
RT8243_ENTRIP2_1: length 5.2
  TOP w0.254: R514.1 104.28,44.49 C276.1 103.26,43.23 v3(104.52,41.97) 104.84,41.65 Q69.G
RT8243_ENTRIP2_2: length 7.5
  TOP w0.254: R519.1 101.22,42.88 v1(101.6,42.5) 102.08,42.02 Q69.D 102.94,42.01 102.94,39.68 101.6,38.34 R539.2
RT8243_FB1: length 7
  TOP w0.203: PU6.1 97.49,37 97.49,36.99 97.5,36.99 98.7,35.78 98.7,35.48 v1(98.86,35.33)
  TOP w0.254: PC51.1 100.37,32.39 PR89.1 100.36,34.72 100.36,34.85 PR88.1 98.89,35.29 v1(98.86,35.33)
RT8243_FB2: length 6.2
  TOP w0.203: 97.92,39.48 97.66,39.48 97.49,39.3 PU6.5
  TOP w0.254: 97.92,39.48 98.42,39.48 99.06,40.12 v1(99.06,40.5) 99.06,40.62 99.82,41.39 PC46.1 PR82.1 PR84.1
RT8243_HG1: length 4.3
  TOP w0.635: v5(78.31,33.23) 78.13,33.41 Q77.4
  BOTTOM w0.635: v2(77.37,33.23) v5(78.31,33.23) 79.2,33.23 PR118.2
RT8243_HG2: length 4.2
  TOP w0.635: v5(78.49,46.77) Q65.4
  BOTTOM w0.635: v2(79.11,47.4) v5(78.49,46.77) 79.38,45.88 PR116.1
RT8243_LDO3: length 5.9
  TOP w0.203: PG1.1 92.58,36.74 v1(92.63,36.79) ; 93.6,36.18 93.6,37.07 93.91,37.39 PU6.15
  TOP w0.508: 93.6,36.18 93.17,35.75 92.74,35.75 PG1.1 92.38,35.8 91.54,35.8 PC48.1
RT8243_LDO5: length 5.3
  TOP w0.203: PU6.14 93.63,37.79 93.52,37.68
  TOP w0.508: 93.52,37.68 93.47,37.63 92.81,37.63 92.75,37.69 v3(92.73,37.69) 92.67,37.69 92.61,37.63 PC47.1
  BOTTOM w0.508: v2(93.73,37.6) 93.7,37.63 92.81,37.63 92.75,37.69 v3(92.73,37.69) 92.71,37.67 92.71,37.63 92.56,37.47 PG6.1
RT8243_LGATE1: length 33.1
  TOP w0.203: v5(94.36,36.56) 94.44,36.63 PU6.16
  TOP w0.635: Q81.4 73.79,23.96 74.65,24.83 v5(74.65,28.48)
  BOTTOM w0.635: v5(74.65,28.48) 74.65,32.06 76.96,34.38 v2(85.98,34.38) 92.23,34.38 94.36,36.51 v5(94.36,36.56)
RT8243_LGATE2: length 26.2
  TOP w0.203: v5(94.61,40.75) 95.14,40.23 PU6.10
  TOP w0.635: v5(76.1,47.81) 76.1,48.03 75.5,48.62 Q64.4
  BOTTOM w0.635: v5(94.61,40.75) 93.47,41.89 v2(87.88,41.89) 78.92,41.89 76.1,44.71 v5(76.1,47.81)
RT8243_PGOOD: length 5.1
  TOP w0.203: 97.41,39.86 97.28,39.74 PU6.6 ; PR81.2 R523.1
  TOP w0.254: 97.41,39.86 98.22,40.67 v1(98.22,41.45) 98.81,42.04 PR81.2
RT8243_PHASE1: length 19.3
  TOP w0.203: PU6.17 95.54,36.15 95.33,35.95 94.85,35.95 94.59,35.69
  TOP w0.635: 81.53,32.11 81.79,32.37 92.2,32.37 PC49.2 94.23,35.33 94.59,35.69 ; PR91.1 78.66,23.68 79.48,24.49 v5(79.48,24.51)
  vias: v2(78.33,24.62) v2(79.32,29.93) v5(78.54,31.2) v5(78.82,26.48) v5(79.4,25.56) v5(79.83,31.23) v5(79.93,26.5) v5(80.57,25.56) v5(80.7,24.52) v5(81.13,31.23) v5(81.15,26.5)
RT8243_PHASE2: length 14.4
  TOP w0.203: 95.25,41.39 95.52,41.11 95.52,40.23 95.54,40.22 PU6.9
  TOP w0.635: 95.25,41.39 95.25,41.89 95.5,42.15 PC44.1 92.05,42.66 91.03,43.67 84.71,43.67
  vias: v2(84.3,51.81) v5(81.74,45.91) v5(81.76,44.59) v5(83.01,50.63) v5(83.06,45.91) v5(83.06,44.64) v5(83.43,51.96) v5(84.25,50.63) v5(84.28,45.91) v5(84.28,44.64)
RT8243_TON: length 3
  TOP w0.203: PU6.3 98.2,38.19
  TOP w0.254: PR86.1 99.72,37.32 v1(99.11,37.93) 98.86,38.19 98.2,38.19
RT8243_UGATE1: length 16.5
  TOP w0.203: v5(95.68,35.48) 95.94,35.74 PU6.18
  BOTTOM w0.635: PR118.1 v2(87,32.75) 92.95,32.75 v5(95.68,35.48)
RT8243_UGATE2: length 19.1
  TOP w0.203: v5(96.11,41.09) 95.94,40.92 PU6.8
  BOTTOM w0.635: v5(96.11,41.09) 96.11,41.21 96.09,41.22 96.09,41.78 94.63,43.24 v2(85.98,43.24) 80.7,43.24 PR116.2
RT8243SECFB: length 5.8
  TOP w0.203: v1(92.46,38.97) 92.46,38.79 93.06,38.19 PU6.13
  TOP w0.254: v1(92.46,38.97) 92.28,39.15 PR85.1 91.43,39.18 PR83.1 91.39,40.23 PC45.2
RTCX_L: length 3.8
  TOP w0.102: R300.1 156.32,84.58 156.97,83.93 v1(157.15,83.93) 157.3,84.09 X1.1
RTL_ISOLATE_N: length 21.9
  TOP w0.102: U26.20 28.98,39.38 29.93,40.33 31.76,40.33 31.9,40.47 32.66,41.23 33.15,41.23 34.45,42.53 34.45,43.58 v1(35.37,44.5) 35.37,47.29 36.26,48.18 R497.1 36.77,48.24 R494.2 37.91,47.84 37.32,47.25 37.32,44.89 37.78,44.43 38.73,44.43 39,44.16 Q66.6
RTL_ISOLATE_N_1: length 13.5
  TOP w0.102: v3(36.68,43.6) 37.21,43.06 38.02,43.06 38.35,43.39 Q66.5 ; v3(37.31,38.72) 35.85,38.72 C289.1 R544.1 36.21,36.33 R548.2 v1(37.16,36.15)
  L4 w0.127: v3(37.31,38.72) 37.31,40.57 37.21,40.67 37.21,41 36.15,42.07 36.15,43.07 v3(36.68,43.6)
RTL_ISOLATE_N_2: length 6.4
  TOP w0.102: v1(39.88,47.86) 39.57,47.56 38.3,47.56 37.91,47.16 R498.2 37.91,46.91 38.35,46.47 Q66.2 38.35,44.81 38.23,44.69 37.85,44.69 37.7,44.83 Q66.3
S_LVDS_BL_EN: length 7.6
  TOP w0.102: R173.1 17.84,113.71 18.16,113.39 v1(18.16,112.89) 16.45,112.89 R175.1 R177.2 R176.2 R174.1
S_PANEL_ON: length 2.9
  TOP w0.102: R48.2 120.04,217.41 120.27,217.64 v1(120.27,217.92) 120.27,218.25 120.03,218.49 R41.1
S_TXE0+: length 16.1
  TOP w0.102: v3(141.1,220.05) 141.12,220.07 LVDS1.13
  BOTTOM w0.102: 140.92,217.51 140.03,216.61 133.54,216.61 131.97,215.04 131.97,214.31 131.9,214.23 U37.31 ; 140.92,217.51 v2(140.72,217.71) ; 140.92,217.51 141.43,218.01 141.43,219.72 v3(141.1,220.05)
S_TXE0-: length 16.2
  TOP w0.102: LVDS1.12 142.12,220.18 v3(141.99,220.05)
  BOTTOM w0.102: 141.68,218.78 v2(141.96,218.78) ; 141.68,218.78 141.68,219.74 v3(141.99,220.05) ; 141.68,218.78 141.68,217.9 140.13,216.35 133.64,216.35 132.23,214.94 132.23,214.31 132.3,214.23 U37.32
S_TXE1+: length 13.9
  TOP w0.102: LVDS1.16 v3(138.12,220.05)
  BOTTOM w0.102: v3(138.12,220.05) 138.43,219.74 138.43,218.3 137.49,217.36 137.11,217.36 ; 137.11,217.36 v2(137.11,217.64) ; 137.11,217.36 133.19,217.36 131.17,215.34 131.17,214.31 131.1,214.23 U37.29
S_TXE1-: length 14
  TOP w0.102: LVDS1.15 139.12,220.21 138.96,220.05 v3(138.91,220.05)
  BOTTOM w0.102: 138.68,218.7 138.68,219.77 138.91,220 v3(138.91,220.05) ; 138.68,218.7 v2(138.96,218.7) ; 138.68,218.7 138.68,218.19 137.6,217.1 133.3,217.1 131.43,215.23 131.43,214.31 131.5,214.23 U37.30
S_TXE2+: length 11.9
  TOP w0.102: LVDS1.19 135.12,220.21 135.2,220.13 v3(135.2,220.12)
  BOTTOM w0.102: v3(135.2,220.12) 135.51,219.81 135.51,218.4 135.23,218.12 132.86,218.12 131.8,217.05 ; U37.27 130.3,214.23 130.37,214.31 130.37,215.63 131.8,217.05 ; 131.8,217.05 v2(131.6,217.26)
S_TXE2-: length 11.9
  TOP w0.102: v3(136.07,220.1) 136.07,220.13 136.12,220.18 LVDS1.18
  BOTTOM w0.102: 135.76,219.11 135.76,218.29 135.34,217.87 132.97,217.87 130.63,215.52 130.63,214.31 130.7,214.23 U37.28 ; 135.76,219.11 135.76,219.8 v3(136.07,220.1) ; 135.76,219.11 v2(136.04,219.11)
S_TXE3+: length 12.9
  TOP w0.102: LVDS1.23 131.12,220.23 131.22,220.13 v3(131.22,220.12)
  BOTTOM w0.102: 127.41,216.16 127.41,213.09 128.15,212.35 U37.23 ; 127.41,216.16 v2(127.13,216.16) ; 127.41,216.16 127.41,217.18 129.29,219.06 130.91,219.06 131.22,219.37 v3(131.22,220.12)
S_TXE3-: length 12.7
  TOP w0.102: LVDS1.22 132.12,220.22 132.08,220.18 v3(132.08,220.12)
  BOTTOM w0.102: 128.91,218.32 127.67,217.08 127.67,213.19 128.11,212.75 U37.24 ; 128.91,218.32 v2(129.11,218.12) ; 128.91,218.32 129.4,218.8 131.01,218.8 131.47,219.26 131.47,219.72 131.86,220.12 v3(132.08,220.12)
S_TXEC+: length 11.3
  TOP w0.102: LVDS1.21 133.12,220.23 v3(133.25,220.1)
  BOTTOM w0.102: 129.57,215.58 129.57,217.34 130.56,218.32 131.21,218.32 131.75,218.86 133.1,218.86 133.55,219.31 133.55,219.79 v3(133.25,220.1) ; 129.57,215.58 129.57,214.31 129.5,214.23 U37.25 ; 129.57,215.58 v2(129.29,215.58)
S_TXEC-: length 11.2
  TOP w0.102: LVDS1.20 134.12,220.12 v3(134.11,220.12)
  BOTTOM w0.102: 133.53,218.93 v2(133.73,218.73) ; 133.53,218.93 133.2,218.6 131.85,218.6 131.32,218.07 130.66,218.07 129.83,217.23 129.83,214.31 129.9,214.23 U37.26 ; 133.53,218.93 133.81,219.21 133.81,219.81 v3(134.11,220.12)
S_TXO0+: length 25.3
  TOP w0.102: v3(152.27,220.07) 152.12,220.23 LVDS1.2
  BOTTOM w0.102: 148.28,215.26 v2(148.06,215.48) ; 148.28,215.26 150.71,217.69 151.43,217.69 152.81,219.06 152.81,219.72 152.45,220.07 v3(152.27,220.07) ; 148.28,215.26 144.66,211.64 141.05,211.64 140.21,212.48 137.52,212.48 136.15,211.11 135.44,211.11 135.4,211.15 U37.41
S_TXO0-: length 25.3
  TOP w0.102: LVDS1.1 153.12,220.19 153.06,220.13 v3(153.06,220.12)
  BOTTOM w0.102: 146.4,213.02 v2(146.61,212.81) ; 146.4,213.02 150.81,217.43 151.54,217.43 153.06,218.96 v3(153.06,220.12) ; 146.4,213.02 144.77,211.39 140.94,211.39 140.1,212.23 137.62,212.23 136.25,210.85 135.49,210.85 135.39,210.75 U37.42
S_TXO1+: length 22.4
  TOP w0.102: LVDS1.4 150.12,220.15 v3(150.19,220.07)
  BOTTOM w0.102: v3(150.19,220.07) 150.39,220.07 150.8,219.67 150.8,219.41 149.12,217.74 ; 149.12,217.74 144.15,212.76 142.66,212.76 142.2,213.22 137.21,213.22 135.92,211.92 135.39,211.92 135.36,211.95 135.2,211.95 135.19,211.95 U37.39 ; 149.12,217.74 v2(148.92,217.94)
S_TXO1-: length 22.5
  TOP w0.102: LVDS1.3 151.12,220.14 v3(151.05,220.07)
  BOTTOM w0.102: 150.53,218.79 144.25,212.51 142.56,212.51 142.1,212.96 137.32,212.96 136.02,211.67 135.28,211.67 135.16,211.55 U37.40 ; 150.53,218.79 v2(150.75,218.58) ; 150.53,218.79 151.05,219.31 v3(151.05,220.07)
S_TXO2+: length 19.9
  TOP w0.102: v3(148.29,220.12) 148.29,220.13 148.12,220.29 LVDS1.6
  BOTTOM w0.102: U37.37 135.34,212.75 135.43,212.66 135.59,212.66 136.89,213.97 138.4,213.97 ; 138.4,213.97 v2(138.4,214.26) ; 138.4,213.97 143.51,213.97 148.89,219.35 148.89,219.69 148.47,220.12 v3(148.29,220.12)
S_TXO2-: length 19.9
  TOP w0.102: v3(149.15,220.1) 149.12,220.13 LVDS1.5
  BOTTOM w0.102: v3(149.15,220.1) 149.15,219.25 144.34,214.44 ; 144.34,214.44 143.61,213.71 137,213.71 135.69,212.4 135.48,212.4 135.43,212.35 U37.38 ; 144.34,214.44 v2(144.55,214.23)
S_TXO3+: length 17.2
  TOP w0.102: v3(143.21,220.07) 143.12,220.16 LVDS1.11
  BOTTOM w0.102: v2(143.21,220.89) v3(143.21,220.07) 143.54,219.74 143.54,219.07 140.33,215.87 133.87,215.87 132.77,214.78 132.77,214.31 132.7,214.23 U37.33
S_TXO3-: length 16.7
  TOP w0.102: LVDS1.10 144.12,220.15 144.07,220.1 v3(144.07,220.05)
  BOTTOM w0.102: v3(144.07,220.05) 143.79,219.77 143.79,218.97 141.41,216.59 ; 141.41,216.59 v2(141.63,216.37) ; 141.41,216.59 140.44,215.62 133.97,215.62 133.03,214.67 133.03,214.31 133.1,214.23 U37.34
S_TXOC+: length 17.9
  TOP w0.102: v3(145.26,220.1) 145.12,220.23 LVDS1.9
  BOTTOM w0.102: 144.72,218.03 141.82,215.13 134.22,215.13 133.57,214.48 133.57,214.31 133.5,214.23 U37.35 ; 144.72,218.03 v2(144.5,218.25) ; 144.72,218.03 145.57,218.88 145.57,219.79 v3(145.26,220.1)
S_TXOC-: length 17.8
  TOP w0.102: LVDS1.8 v3(146.12,220.12)
  BOTTOM w0.102: 145.82,219.14 v2(146.1,219.14) ; 145.82,219.14 145.82,219.82 v3(146.12,220.12) ; 145.82,219.14 145.82,218.78 141.93,214.88 134.33,214.88 133.83,214.38 133.83,214.31 133.9,214.23 U37.36
SA0_DIM0: length 6
  TOP w0.102: DIMM1.197 164.24,126.54 166.03,126.54 v4(166.73,125.84)
  BOTTOM w0.102: R848.1 164.59,127.49 v2(165.25,126.83) 166.24,125.84 v4(166.73,125.84)
SA0_DIM1: length 8.2
  TOP w0.102: v4(152.28,123.12) 151.47,123.92 151.47,125.22 150.19,126.5 DIMM2.197
  BOTTOM w0.102: v2(154.69,124.13) 154.54,124.28 R851.1 153.44,124.28 v4(152.28,123.12)
SA1_DIM0: length 4.6
  TOP w0.102: v4(165.53,124.24) 165.53,125.03 165.26,125.3 DIMM1.201
  BOTTOM w0.102: R852.1 165.2,124.57 v4(165.53,124.24) 165.68,124.24 v2(166.24,123.68)
SA1_DIM1: length 6.4
  TOP w0.102: v4(149.68,123.02) 150.62,123.96 150.62,124.85 150.17,125.3 DIMM2.201
  BOTTOM w0.102: v4(149.68,123.02) v2(149.68,123.94) 149.68,124.33 R850.2
SATA1GP: length 10.6
  TOP w0.102: U29.J40 129.96,85.44 129.96,85.91 129.47,86.4 129.44,86.4 125.96,89.88 125.52,89.88 v1(125.3,90.1) 125.27,90.13 125.27,90.99 124.78,91.49 R274.1 123.92,91.52 R272.2
SATA2GP: length 13.3
  TOP w0.102: R268.2 120.53,91.38 R282.2 121.6,89.84 122.05,89.39 v1(122.43,89.39) 122.95,89.91 123.94,89.91 124.33,89.52 126.03,89.52 129.36,86.19 129.39,86.19 129.57,86.01 129.57,85.72 129.29,85.44 U29.H40
SATA3GP: length 18.6
  TOP w0.102: R242.2 121.92,95.81 121.92,96.5 121.84,96.58 121.84,97.04 v1(121.95,97.14) 122.56,96.53 R243.1 123.18,96.19 123.19,96.2 123.76,96.2 124.03,95.93 124.03,94.91 126.31,92.63 126.31,92.25 126.67,91.89 126.67,91.79 128.08,90.37 128.42,90.37 130.11,88.69 130.31,88.69 131.91,87.09 U29.N41
SATA4GP: length 15.9
  TOP w0.102: R264.1 v1(122.56,93.46) 123.12,93.46 123.43,93.76 123.89,93.76 124.16,93.49 124.16,93.44 125.05,92.55 125.1,92.55 125.35,92.3 125.35,91.92 127.8,89.47 127.8,88.91 129.37,87.34 130.7,87.34 131.1,86.94 131.1,85.6 131.02,85.52 130.93,85.43 130.93,84.89 131.24,84.58 U29.M39
SATA5GP: length 18.5
  TOP w0.102: R237.1 120.25,96.55 v1(120.25,95.67) 121.4,94.52 124.1,94.52 126.11,92.51 126.11,92.33 126.11,92.33 126.11,92.16 126.47,91.81 126.47,91.7 128,90.17 128.34,90.17 130.03,88.48 130.23,88.48 131.63,87.08 131.63,85.7 131.91,85.43 131.91,85.31 U29.N40
SATA__RXN0_C: length 10.2
  TOP w0.102: v1(15.52,56.04) 15.52,55.68 ; 15.52,55.68 16.14,55.68 C254.2 ; 15.52,55.68 10.81,55.68 10.39,55.25 7.65,55.25 HDD1.5
SATA__RXN5_C: length 10.9
  TOP w0.102: v1(14.05,74.79) 13.8,74.54 ; 13.8,74.54 13.46,74.88 10.76,74.88 9.25,76.38 7.52,76.38 ODD1.5 ; 13.8,74.54 14.22,74.11 14.22,72.2 C222.2
SATA__RXP0_C: length 10.8
  TOP w0.102: C256.2 16.14,55.46 10.9,55.46 10.48,55.04 7.65,55.04 HDD1.6
  BOTTOM w0.102: v2(7.95,54.8) HDD1.6
SATA__RXP5_C: length 11.3
  TOP w0.102: ODD1.6 7.12,75.69 7.59,76.16 9.16,76.16 10.67,74.66 13.37,74.66 14,74.02 14,72.2 C224.2
  BOTTOM w0.102: v2(7.9,75.88) ODD1.6
SATA__TXN0_C: length 11
  TOP w0.102: C252.2 16.05,57.79 11.54,57.79 10.48,58.85 7.65,58.85 HDD1.3
  BOTTOM w0.102: v2(7.95,58.63) HDD1.3
SATA__TXN5_C: length 13.1
  TOP w0.102: C220.2 15.84,74.39 15.84,75.37 14.99,76.22 11.44,76.22 7.82,79.85 7.65,79.85 ODD1.3
  BOTTOM w0.102: v2(7.98,79.49) ODD1.3
SATA__TXP0_C: length 10.5
  TOP w0.102: v1(15.44,58.35) 15.44,58 ; 15.44,58 11.63,58 10.57,59.06 7.65,59.06 HDD1.2 ; 15.44,58 16.05,58 C251.2
SATA__TXP5_C: length 13
  TOP w0.102: ODD1.2 7.65,80.06 7.91,80.06 8.04,79.93 8.04,79.93 11.53,76.44 15.08,76.44 15.54,75.98 ; 15.54,75.98 16.06,75.46 16.06,74.39 C218.2 ; 15.54,75.98 v1(15.8,76.23)
SATAHDR_RX_DN0: length 127.5
  TOP w0.102: v3(122.05,79.99) 122.34,79.7 122.34,79.02 123.01,78.34 125.43,78.34 125.74,78.64 125.74,78.78 125.89,78.93 U29.B28 ; v3(35.08,52.18) 35.08,52.18 34.77,51.88 33.32,51.88 32.74,52.46 ; 32.74,52.46 32.32,52.88 21.63,52.88 18.83,55.68 17.7,55.68 C254.1 ; 32.74,52.46 v1(32.99,52.71)
  L4 w0.127: v3(35.08,52.18) 35.41,52.18 35.94,52.71 35.94,53.22 37.1,54.38 38.21,54.38 39.73,55.89 39.73,56.27 39.73,56.55 41.88,58.71 44.04,58.71 45.68,60.35 54.16,60.35 55.12,59.38 71.12,59.38 76.61,64.87 89.6,64.87 91.61,66.87 108.72,66.87 111.4,69.56 112.55,69.56 117.89,74.9 117.89,77.23 120.05,79.39 122.18,79.39 122.34,79.55 122.34,79.7 v3(122.05,79.99)
SATAHDR_RX_DN5: length 137.7
  TOP w0.102: v4(124.62,77.33) 124.62,77.63 124.9,77.91 125.92,77.91 126.26,78.26 U29.C27 ; C222.1 14.22,70.64 14.22,67.88 25.55,56.55 ; v1(25.81,56.8) 25.55,56.55 ; 25.55,56.55 26.9,55.2 34.84,55.2 36.78,53.26 36.78,51.49 v3(36.98,51.29)
  L4 w0.127: v4(124.62,77.33) 124.62,75.59 123.05,74.01 119.36,74.01 109.35,64 91.32,64 90.5,63.18 77.27,63.18 71.81,57.72 54.41,57.72 53.47,58.66 46.37,58.66 43.79,56.08 42.33,56.08 40.68,54.43 40.68,53.7 38.86,51.88 37.19,51.88 36.98,51.68 v3(36.98,51.29)
SATAHDR_RX_DP0: length 127.4
  TOP w0.102: v3(35.05,51.29) 34.68,51.66 33.24,51.66 32.23,52.66 27.64,52.66 ; U29.A28 125.43,78.93 125.52,78.83 125.52,78.73 125.34,78.56 123.1,78.56 122.56,79.1 122.56,79.61 v4(122.94,79.99) ; 27.64,52.66 21.54,52.66 18.74,55.46 17.7,55.46 C256.1 ; 27.64,52.66 v1(27.64,52.31)
  L4 w0.127: v3(35.05,51.29) 35.05,51.44 36.21,52.6 36.21,53.11 37.21,54.11 38.32,54.11 39.99,55.78 39.99,55.89 39.99,55.89 39.99,56.16 39.99,56.44 42,58.44 44.15,58.44 45.8,60.08 54.05,60.08 55.01,59.12 71.23,59.12 76.72,64.6 89.71,64.6 91.72,66.61 108.83,66.61 111.51,69.29 112.66,69.29 118.16,74.79 118.16,77.12 120.16,79.13 122.29,79.13 122.61,79.44 122.61,79.66 v4(122.94,79.99)
SATAHDR_RX_DP5: length 138
  TOP w0.102: v3(36.12,51.29) 36.56,51.73 36.56,52.66 ; U29.B27 125.7,78.13 124.81,78.13 124.81,78.12 124.01,77.33 v4(123.99,77.33) ; 36.56,52.66 36.56,53.17 34.75,54.99 26.81,54.99 14,67.79 14,70.64 C224.1 ; 36.56,52.66 v1(36.22,52.66)
  L4 w0.127: v4(123.99,77.33) 124.36,76.96 124.36,75.7 122.94,74.28 119.25,74.28 109.24,64.27 91.21,64.27 90.39,63.45 77.16,63.45 71.7,57.98 54.52,57.98 53.58,58.92 46.26,58.92 43.68,56.35 42.21,56.35 40.41,54.54 40.41,53.81 38.75,52.14 37.08,52.14 36.72,51.79 36.72,51.74 36.27,51.29 v3(36.12,51.29)
SATAHDR_TX_DN0: length 128.7
  TOP w0.102: v1(19.91,55.84) 20.17,56.09 ; 20.17,56.09 22.86,53.4 32.47,53.4 32.74,53.67 34.39,53.67 v3(34.99,53.07) ; 20.17,56.09 18.47,57.79 17.74,57.79 C252.1 ; U29.F31 v4(128.3,80.71)
  L4 w0.127: v3(34.99,53.07) 35.18,53.07 35.53,53.42 35.53,54.02 36.32,54.81 37.96,54.81 39.23,56.08 39.23,56.77 41.8,59.33 44,59.33 45.45,60.78 54.39,60.78 55.27,59.9 70.87,59.9 76.42,65.46 84.84,65.46 86.69,67.31 108.54,67.31 111.35,70.12 112.5,70.12 117.46,75.08 117.46,77.41 120.49,80.44 127.11,80.44 127.54,80.87 128.14,80.87 v4(128.3,80.71)
SATAHDR_TX_DN5: length 139.1
  TOP w0.102: v4(128.91,79.49) 128.7,79.28 U29.G28 ; 36.7,54.72 37.37,54.06 v3(37.37,53.55) ; 36.7,54.72 36.28,55.14 35.78,55.14 35.31,55.61 28.16,55.61 24.45,59.32 24.08,59.32 15.85,67.55 15.85,72.79 C220.1 ; 36.7,54.72 v1(36.45,54.47)
  L4 w0.127: v3(37.37,53.55) 37.57,53.35 37.57,53 37.86,52.7 38.69,52.7 39.98,53.99 39.98,54.72 40.69,55.43 40.69,55.87 42.56,57.74 44.47,57.74 46.08,59.36 53.78,59.36 54.57,58.57 54.72,58.42 71.52,58.42 77.01,63.9 90.13,63.9 92.03,65.81 110.17,65.81 119.8,75.45 120.55,75.45 123.01,77.91 127.22,77.91 128.07,78.76 128.23,78.76 128.91,79.44 v4(128.91,79.49)
SATAHDR_TX_DP0: length 128.7
  TOP w0.102: v4(129.06,80.71) U29.H31 ; 33.48,53.88 35.01,53.88 v3(35.06,53.93) ; 33.48,53.88 v1(33.48,54.24) ; 33.48,53.88 32.65,53.88 32.38,53.62 22.95,53.62 18.56,58 17.74,58 C251.1
  L4 w0.127: v3(35.06,53.93) 36.21,55.08 37.85,55.08 38.96,56.19 38.96,56.88 41.69,59.6 43.89,59.6 45.34,61.05 54.5,61.05 55.38,60.17 70.76,60.17 76.31,65.72 84.73,65.72 86.58,67.57 108.43,67.57 111.24,70.38 112.39,70.38 117.19,75.19 117.19,77.52 120.38,80.71 127,80.71 127.43,81.14 128.63,81.14 v4(129.06,80.71)
SATAHDR_TX_DP5: length 138.7
  TOP w0.102: C218.1 16.07,72.81 16.07,67.64 24.17,59.53 24.54,59.53 28.24,55.83 29.16,55.83 ; 29.16,55.83 35.4,55.83 35.87,55.36 36.37,55.36 37.58,54.15 38.18,53.55 v3(38.24,53.55) ; 29.16,55.83 v1(29.16,56.17) ; U29.F28 128.12,78.85 128.27,79 v4(128.27,79.49)
  L4 w0.127: v4(128.27,79.49) 128.27,79.18 128.12,79.03 127.96,79.03 127.11,78.18 122.9,78.18 120.44,75.71 119.69,75.71 110.06,66.07 91.92,66.07 90.02,64.17 76.9,64.17 71.41,58.68 54.83,58.68 53.89,59.62 45.97,59.62 44.36,58.01 42.45,58.01 40.42,55.98 40.42,55.54 39.71,54.83 39.71,54.1 38.58,52.97 37.98,52.97 37.83,53.11 37.83,53.34 38.05,53.55 v3(38.24,53.55)
SATARBIAS_PCH: length 6.5
  TOP w0.102: R316.2 122.1,82.64 v1(122.94,82.64) 124.06,82.64 124.46,83.03 126.34,83.03 126.55,82.82 126.55,82.68 126.95,82.29 126.95,81.81 U29.D33
SB3V: length 677.5
  TOP w0.203: U29.AP35 142.88,82.29 142.88,81.56 U29.AN33 ; v3(62.59,48.38) U24.27
  TOP w0.254: U29.AW26 146.09,77.43 146.78,77.43 147.77,76.44 148.08,76.44 149.35,75.17 C215.1 ; U29.AM33 U29.AN33
  TOP w0.305: 140.07,74.08 139.7,73.7 U29.AH18 ; 140.07,74.08 139.7,74.45 U29.AH20 ; 140.07,74.08 v4(140.08,74.08) ; 140.77,74.22 U29.AJ20 ; 140.77,74.22 v4(140.77,74.08) ; 140.77,74.22 140.77,74.24 U29.AK20 ; v4(132.11,74.95) 132.41,74.65 U29.P20 ; v4(143.21,82.96) 142.98,82.74 142.98,82.45 142.97,82.44 U29.AP35
  TOP w0.381: U29.AH22 139.37,75.84 v4(139.37,76.06)
  TOP w0.508: R223.2 139.17,98.03 139.83,97.37 139.83,95.13 R258.1 139.04,94.63 138.51,95.16 137.24,95.16 ; R278.2 136.09,91.92 v3(136.09,92.54) ; v3(66.29,48.37) 66.12,48.37 65.74,48.75 R493.2 R482.2 ; R501.1 41.53,46.85 41.25,47.13 40.31,47.13 v3(40.28,47.1) R498.1 ; R513.1 41.49,44.69 v3(40.51,44.69) ; v3(136.91,200.62) 136.8,200.62 136.21,201.22 R82.1 ; R383.1 156.44,73.39 156.74,73.09 157.04,73.09 v3(157.11,73.16) 157.15,73.16 157.56,72.75 R385.2 ; v3(131.88,101.03) 132.46,100.44 133.8,100.44 134.44,99.8 134.44,99.25 ; R98.1 v3(179.2,192.01) ; 133.52,95.81 133.07,96.25 133.07,97.88 134.44,99.25 ; 133.52,95.81 133.44,95.81 132.94,95.31 v4(132.94,94.62) ; 133.52,95.81 R232.1 ; R445.1 46.82,59.33 46.05,60.11 R440.1 45.6,60.32 44.22,61.71 v3(44.07,61.71) ; v3(40.04,39.86) 41.08,40.9 R527.1 ; v3(143.47,95.21) 143.5,95.21 R251.2 ; 145.97,100.31 143.89,100.31 143.51,99.93 142.07,99.93 141.86,100.14 137.72,100.14 136.4,98.82 134.88,98.82 134.44,99.25 ; R10.1 90.56,237.47 91.11,238.02 R6.1 91.65,240.18 R2.1 ; v3(124.47,99.82) 124.38,99.73 123.64,99.73 122.99,100.38 R216.1 ; v3(160.38,67.8) 160.38,67.9 160.06,68.22 R415.1 R421.1 ; R492.2 R495.2 41.34,49.51 v3(40.13,49.51) ; v3(31.52,26.53) 32.49,25.56 Q80.S ; C215.1 150.3,75.87 v3(150.5,76.06) ; 137.24,95.16 136.98,94.9 R257.2 R256.2 ; 137.24,95.16 136.29,95.16 v3(136.27,95.14) ; R260.2 140.08,93.06 v4(139.57,92.55) 139.39,92.37 R277.1 R276.1 138.35,92.27 v3(137.97,92.65)
  TOP w0.559: PC1.1 88.22,230.79 ; R10.1 88.3,233.89 ; v3(74.55,233.92) 71.05,233.92 66.24,229.11 66.24,219.65 69.22,216.68 69.22,213.85 68.64,213.28 R57.1
  TOP w0.762: v5(164.59,96.12) 164.69,96.02 169.19,96.02 MEJ1.1 ; v5(147.52,95.79) 147.52,96.95 145.97,98.5 145.97,101.46 148.29,103.77 R201.1
  TOP w1.27: v5(161.42,225.23) 159.26,225.23 154.74,220.71 154.74,215.78 151.49,212.53 151.49,209.36 143.46,201.33 v5(139.95,201.33)
  L3 w0.508: v3(53.8,47.25) 53.56,47.02 53.56,46.85 51.65,44.93 v3(51.65,43.29) 51.65,40.64 52.2,40.1 52.2,38.04 53.14,37.09 53.48,37.09 56.32,34.25 56.32,31.04 v3(56.26,30.97) ; 152.76,92.04 152.76,94.09 v3(152.5,94.34) ; 152.76,92.04 152.76,91.49 153.46,90.79 v3(153.92,90.79) ; 152.76,92.04 151.79,91.07 151.79,90.01 151.13,89.35 v3(151.13,87.62) ; v3(124.47,99.82) 125.13,100.48 127.38,100.48 127.92,101.03 v3(131.88,101.03) ; v3(23.19,24.47) 23.19,24.65 23.16,24.67 23.16,25.66 21.84,26.98 v3(21.84,27.16) 22.61,27.92 25.53,27.92 v3(25.81,28.2) ; v3(135.13,45.45) 135.1,45.42 128.14,45.42 v3(127.56,46.01) 123.62,46.01 122.24,47.38 121.35,47.38 120.34,46.37 120.34,45.86 119.7,45.22 116.02,45.22 114.55,46.69 113.88,46.69 103.62,56.96 101.83,56.96 100.56,58.23 95.11,58.23 91.25,54.37 71.15,54.37 68.83,52.05 68.83,50.91 v3(66.29,48.37) ; v3(40.51,44.69) 41.45,43.76 41.45,41.27 v3(40.04,39.86) ; v4(140.08,74.08) 140.08,72.5 139.65,72.07 139.65,71.06 139.42,70.83 139.42,68.62 139.42,68.57 139.03,68.18 138.28,68.18 137.92,68.54 137.42,68.54 136.86,67.98 v3(134.65,67.98) ; v3(149,86.62) 147.32,84.95 147.32,79.23 v3(150.5,76.06) 150.5,74.12 v4(150.92,73.7) ; v3(14.76,42.96) 17.5,42.96 18.31,42.15 20.78,42.15 21.13,42.5 v3(21.13,42.66)
  L4 w0.508: v4(141.22,92.69) 139.7,92.69 v4(139.57,92.55) ; v3(40.51,44.69) 40.87,44.69 41.53,44.02 46.05,44.02 46.6,43.48 46.67,43.48 48.29,41.87 50.23,41.87 v3(51.65,43.29) ; v3(136.09,92.54) 136.2,92.43 137.75,92.43 v3(137.97,92.65) ; v3(18.95,40.36) 19.47,40.36 21.01,41.89 22.48,41.89 ; v3(156.92,57.59) 158.57,59.24 158.57,61.79 159.07,62.3 159.07,62.89 159.85,63.67 159.85,67.2 160.38,67.72 v3(160.38,67.8) 159.89,68.28 159.89,70.43 157.16,73.16 v3(157.11,73.16) ; v5(164.59,96.12) 154.28,96.12 v3(152.5,94.34) ; v3(66.29,48.37) 66.29,48.38 v3(62.59,48.38) 61.88,49.08 57.99,49.08 57.15,48.24 54.79,48.24 v3(53.8,47.25) ; v3(134.65,67.98) 134.53,67.98 134.07,68.44 134.07,68.95 134.09,68.97 134.09,69.65 134.16,69.73 134.16,70.37 134.14,70.39 134.14,74.05 133.24,74.95 v4(132.11,74.95)
  L4 w1.27: v5(96.14,209.28) 100.53,209.28 101.75,208.06 106.2,208.06 112.8,201.46 117.75,201.46 122.1,205.8 125.86,205.8 127.38,204.28 131.88,204.28 135.53,200.62 v3(136.91,200.62) 137.62,201.33 v5(139.95,201.33)
  BOTTOM w0.381: v3(157.11,73.16) 157.11,73.13 156.87,72.88 v2(155.57,72.88) 151.73,72.88 v4(150.92,73.7) 149.1,73.7 147.88,74.91 145.8,74.91 145.47,74.58 145.47,73.8 144.86,73.19 143.66,73.19 143.24,73.61 141.24,73.61 v4(140.77,74.08) v4(140.08,74.08) 139.88,74.28 139.88,75.23 139.37,75.74 v4(139.37,76.06) ; C591.1 147.32,83.86 146.48,83.86 146.01,83.4 145.27,83.4 144.96,83.09 143.33,83.09 v4(143.21,82.96) ; v3(136.27,95.14) 136.27,95.11 136.09,94.93 v3(136.09,92.54)
  BOTTOM w0.508: v3(62.59,48.38) 62.59,48.52 61.85,49.26 C676.2 ; v3(151.13,87.62) 151.05,87.55 149.06,87.55 R933.2 149,87.49 v3(149,86.62) 149,85.44 148.47,84.92 148.06,84.92 147.51,84.38 C591.1 ; R1090.1 25.53,28.48 v3(25.81,28.2) ; R663.1 4.93,237.78 6.73,235.98 v3(7.37,235.98) ; v3(40.04,39.86) 39.67,39.5 39.67,36.89 ; v3(153.92,90.79) 153.9,90.76 153.34,90.76 152.66,90.08 R937.2 ; R927.1 138.21,92.42 v3(137.97,92.65) ; R920.2 151.89,92.54 152.7,93.36 152.7,94.14 v3(152.5,94.34) 152.48,94.37 151.71,94.37 150.54,93.2 149.07,93.2 ; R1010.1 54.87,48.18 53.95,47.25 v3(53.8,47.25) ; R925.1 140.12,92 v4(139.57,92.55) 140.21,93.19 R926.2 ; C717.1 22.1,26.66 22.07,26.69 22.07,26.93 v3(21.84,27.16) 20.76,27.16 R1096.1 20.71,26.45 PC72.1 ; R905.2 133.95,93.52 133.45,94.02 133.45,94.37 133.2,94.62 v4(132.94,94.62) 132.85,94.54 R903.2 ; v3(156.92,57.59) 155.55,56.22 151.47,56.22 144.78,49.53 143.61,49.53 142.75,48.67 142.75,48.61 141.8,47.66 141.55,47.66 139.68,45.79 135.47,45.79 v3(135.13,45.45) ; R1040.1 v3(18.95,40.36) ; v4(141.22,92.69) 141.22,93.71 141.8,94.28 R911.2 ; v4(140.08,74.08) 139.87,73.87 C633.1 ; v3(44.07,61.71) 44.07,62.47 43.43,63.1 31.88,63.1 v5(31.75,63.23) ; v3(127.56,46.01) 127.56,46.42 129.01,47.86 R1015.1 ; R1028.1 v3(14.76,42.96) ; v3(179.2,192.01) 179.95,191.26 184.88,191.26 185.1,191.48 185.1,222 178.29,228.81 169.24,228.81 166.98,226.55 ; R868.2 128.04,99.74 128.98,99.74 R867.2 129.03,100.04 129.33,100.34 129.38,100.34 R862.1 129.86,101.27 130.28,101.69 131.22,101.69 v3(131.88,101.03) ; v3(31.68,24.88) 30.51,24.88 28.68,23.05 23.95,23.05 23.19,23.81 v3(23.19,24.47)
  BOTTOM w1.27: v5(96.14,209.28) 94.49,210.93 92.54,210.93 92.29,211.09 88.65,214.74 88.65,225.66 v5(89.03,226.04) ; v5(161.42,225.23) 166.04,225.23 F6.1
  vias: v2(36.35,32.5) v2(39.12,48.24) v5(13.21,65.64) v5(13.21,64.5) v5(13.21,63.36) v5(30.73,63.23) v5(31.37,64.12) v5(87,233.28) v5(87,232.14) v5(87,231)
SB5V: length 592.6
  TOP w0.381: v3(27.19,141.49) 27.35,141.64 U47.3
  TOP w0.508: 21.87,142.25 20.54,142.25 19.85,142.94 19.85,143.42 R1141.1 18.73,144.27 17.21,145.79 R161.1 ; R573.2 42.52,30.31 41.96,29.75 v3(41.96,29.67) ; v3(129.31,104.66) 128.91,104.66 PC26.1 127.64,105.62 127.01,105 126.33,105 125.56,104.24 U14.6 ; R106.1 v3(185.39,185.02) ; v5(121.16,33.92) 121.16,33 119.63,31.48 119.63,25.23 118.98,24.57 118.95,24.57 117.96,23.58 v3(117.96,20.35) ; R1050.1 R1027.1 19.18,41.64 18.82,42 v3(18.82,43.16) ; v3(27.19,141.49) 25.79,141.49 C732.1 25.39,141.08 23.65,141.08 23.24,141.49 ; PC38.2 110.9,64.06 110.9,61.62 111.6,60.92 v3(112.39,60.92) ; v3(168.19,100.36) 167.94,100.36 167,99.42 R210.1 167.39,98.97 171.05,98.97 171.86,98.15 171.86,96.66 168.43,93.23 168.43,85.33 PR71.1 ; v3(109.86,19.16) 109.86,19.91 108.05,21.71 103.9,21.71 103.08,22.53 98.72,22.53 97.64,21.45 85.85,21.45 84.84,20.43 71.83,20.43 67.58,16.19 66.09,16.19 65.99,16.29 63.38,16.29 60.45,19.22 60.45,20.41 59.39,21.47 58.34,21.47 57.68,20.81 57.68,20.27 55.43,18.02 46.79,18.02 43.69,14.92 v3(41.68,14.92) ; R536.1 v3(114.47,41.05)
  TOP w0.635: PC38.2 110.03,64.14 109.89,63.99 PU5.6
  TOP w0.762: R1074.1 119.33,40.58 119.33,38.92 v3(119.13,38.72) 119.13,38.17 121.16,36.14 v5(121.16,33.92)
  L3 w0.508: v3(20.7,128.61) 21.96,127.35 21.96,121.76 20.45,120.25 20.45,96.26 20.82,95.89 20.82,81.45 v5(27.99,74.28) 27.99,73.21 27.08,72.3 27.08,47.76 25.53,46.21 v3(25.53,45.62) 31.27,39.88 31.27,31.38 32.16,30.49 37.54,30.49 38.36,29.67 v3(41.96,29.67) 41.96,28.79 41.07,27.9 41.07,26.81 38.63,24.37 38.63,23.56 37.09,22.01 37.09,16.67 36.32,15.9 36.32,15.36 36.99,14.69 41.45,14.69 v3(41.68,14.92)
  L3 w0.635: v3(150.5,106.16) 150.5,105.65 149.72,104.87 141.54,104.87 138.76,102.09 v3(138.3,102.09) 137.64,102.09 137.13,101.58 135.67,101.58 135.17,101.08 135.17,100.21 134.62,99.67 134.62,99.55 134.51,99.44 134.51,99.22 133.97,98.68 133.66,98.37 133.66,98.31 129.49,94.14 129.49,94.05 129.42,93.98 129.42,89.37 127.75,87.71 127.75,86.46 126.09,84.8 126.09,81 127.44,79.65 127.44,76.79 124.24,73.59 120.02,73.59 114.24,67.81 114.24,67.54 113.92,67.22 113.92,62.44 v3(112.39,60.92)
  L3 w0.762: v3(112.39,60.92) 112.39,57.9 114.68,55.61 v3(114.68,53.83)
  L4 w0.508: v3(185.39,185.02) 185.39,184.98 185.42,184.96 185.42,182.99 190.96,177.45 190.96,169.53 191.41,169.07 191.41,152.08 189.06,149.73 189.06,111.96 184.07,106.97 184.07,99.9 v3(184.07,99.9) ; v3(117.96,20.35) 111.05,20.35 v3(109.86,19.16) ; v3(27.19,141.49) 27.19,140.92 25.91,139.63 25.91,133.82 v3(20.7,128.61)
  L4 w0.635: v3(168.19,100.36) 168.14,100.31 164.88,100.31 164.46,99.89 164.3,99.89 163.79,99.39 163.79,99.38 163.37,98.96 163.36,98.96 162.72,98.31 158.32,98.31 158.2,98.44 158.09,98.44 156.27,100.25 156.27,104.06 154.18,106.16 v3(150.5,106.16)
  L4 w0.762: v3(114.47,41.05) 115.71,41.05 120.46,45.8 120.46,49.16 115.79,53.83 v3(114.68,53.83)
  BOTTOM w0.508: 28.07,74.36 R979.1 ; 28.07,74.36 v5(27.99,74.28) ; 28.07,74.36 28.07,75.68 29.39,77 30.91,77 D18.1 ; v3(138.3,102.09) 137.54,102.09 136.46,103.17 133.5,103.17 132.59,104.09 131.68,104.09 131.67,104.08 129.85,104.08 129.31,104.62 v3(129.31,104.66) 129.31,105.7 R860.2 ; v3(185.39,185.02) 185.17,185.02 184.66,185.53 184.66,189.65 R791.1 182.09,188.35 180.05,188.35 R794.1 ; v3(25.53,45.62) 24.91,46.24 22.07,46.24 18.99,43.16 v3(18.82,43.16) ; v2(181.15,99.85) 183.86,99.85 183.91,99.9 v3(184.07,99.9)
  BOTTOM w0.635: v3(168.19,100.36) 169.59,101.76 179.24,101.76 v2(181.15,99.85)
  BOTTOM w0.762: v3(119.13,38.72) 116.8,38.72 v3(114.47,41.05)
SD_CD#: length 26.1
  TOP w0.102: MEMCD1.10 188.03,142.29 188.85,143.11 188.85,157.84 v3(189.23,158.23)
  BOTTOM w0.102: v3(189.23,158.23) 189.23,157.59 v2(188.93,157.29) 188.85,157.21 187.01,157.21 C446.1 185.92,157.13 184.35,157.13 184.2,157.28 U39.20
SD_CLK: length 3.9
  TOP w0.102: v1(182.04,155.28) 182.58,155.81 183.01,155.81 183.67,156.47 183.97,156.47 183.98,156.48 MEMCD1.5
SD_CLK_C_1: length 15
  TOP w0.102: v3(184.71,155.08) 183.16,155.08 R128.1
  L4 w0.127: v3(184.71,155.08) 184.71,154.7 185.71,153.69 185.71,150.64 184.15,149.08 v3(183.26,149.08)
  BOTTOM w0.102: v3(183.26,149.08) v2(184.28,149.08) 185.17,149.08 185.55,149.46 R838.2 185.48,150.22 185.03,150.22 184.8,149.99 184.42,149.99 184.19,150.22 C461.1
SD_CLK_C_2: length 6.3
  BOTTOM w0.102: R838.1 184.7,151.05 184.02,151.72 184.02,151.88 v2(183.57,152.33) 182.99,152.91 182.6,152.91 181.89,153.62 181.89,154.19 182.08,154.38 U39.27
SD_CMD: length 6.5
  TOP w0.102: v3(182.79,148.47) 183.9,148.47 184.4,148.98 MEMCD1.2
  BOTTOM w0.102: R839.2 182.5,151.37 v2(181.74,150.6) 181.74,149.53 v3(182.79,148.47)
SD_CMD_C: length 4.5
  BOTTOM w0.102: U39.28 181.68,154.29 181.66,154.26 181.66,152.97 v2(182.25,152.38) 182.44,152.38 R839.1
SD_DAT0: length 14.8
  TOP w0.102: v3(189.3,152.76) 189.1,152.97 189.1,157.21 189.69,157.79 189.69,160.44 188.64,161.48 MEMCD1.7
  BOTTOM w0.102: v3(189.3,152.76) 189.05,153.02 v2(188.47,153.02) 187.52,153.02 R837.2
SD_DAT0_C: length 4.7
  BOTTOM w0.102: U39.25 183.6,155.03 184.34,154.29 185.02,154.29 v2(185.57,153.73) 185.57,153.48 186.16,152.89 R837.1
SD_DAT1: length 15.4
  TOP w0.102: MEMCD1.8 189.18,163.11 189.92,162.37 189.92,157.7 189.33,157.12 189.33,154.64 v3(189.56,154.42)
  BOTTOM w0.102: v3(189.56,154.42) 189.43,154.29 v2(188.59,154.29) 187.64,154.29 R835.2
SD_DAT1_C: length 3.6
  BOTTOM w0.102: R835.1 186.49,154.03 v2(185.52,155) 184.84,155.68 U39.24
SD_DAT2: length 11.3
  TOP w0.102: MEMCD1.9 183.87,143.98 181.84,146.01 v3(181.84,147.94)
  BOTTOM w0.102: R841.2 180.47,151.18 180.47,148.2 v2(180.53,148.13) 180.73,147.94 v3(181.84,147.94)
SD_DAT2_C: length 3.2
  BOTTOM w0.102: U39.30 180.88,154.45 180.29,153.86 180.19,153.86 v2(179.81,153.48) 179.81,152.73 R841.1
SD_DAT3: length 8
  TOP w0.102: MEMCD1.1 183.65,146.48 182.63,147.51 182.63,147.94 v3(181.86,148.7)
  BOTTOM w0.102: v3(181.86,148.7) v2(181.23,149.34) 180.97,149.59 180.97,151.3 R840.2
SD_DAT3_C: length 2.7
  BOTTOM w0.102: U39.29 181.28,154.37 181.08,154.16 v2(181.08,153.45) 181.08,152.6 R840.1
SD_LDO_EN: length 5.8
  BOTTOM w0.102: U39.13 181.68,160.12 182.25,160.68 182.25,161.38 v2(182.4,161.53) 182.47,161.6 183.01,161.6 R819.2 182.5,162.86 R820.1
SD_LED: length 2
  BOTTOM w0.102: U39.22 185.33,156.48 TP89.1
SD_WP: length 19.7
  TOP w0.102: v3(189.79,156.7) 190.28,157.19 190.28,163.84 189.19,164.92 MEMCD1.11
  BOTTOM w0.102: U39.21 184.34,156.88 184.34,156.88 185.2,156.88 185.22,156.91 186.99,156.91 187.83,156.07 188.11,156.07 v2(188.26,156.22) 188.27,156.22 188.42,156.07 189.15,156.07 v3(189.79,156.7)
SENSE_B: length 5.5
  TOP w0.102: R332.2 R331.2 v1(181.61,83.52) 181.61,84.44 180.72,85.33 180.55,85.33 180.32,85.55 U16.33
SER_IRQ: length 266.7
  TOP w0.102: v3(62.61,35.52) 62.58,35.52 62.47,35.62 60.78,35.62 60.66,35.49 59.49,35.49 59.27,35.72 U24.127 ; R270.1 119.41,91.52 122.1,88.83 122.92,88.83 v3(123.57,89.48) 123.95,89.1 123.95,88.65 124.4,88.21 126.67,88.21 126.9,87.98 126.93,87.98 128.71,86.2 128.71,85.59 128.92,85.38 128.92,84.86 128.62,84.56 U29.G39 ; v3(141.6,43.59) 141.6,43.49 141.41,43.3 U23.27 U22.27
  L3 w0.127: v3(170.18,70.09) 169.8,69.71 169.8,62.4 160.25,52.85 152.68,52.85 152.35,53.18 150.69,53.18 146.72,49.22 146.72,43.65 145.85,42.78 142.52,42.78 141.71,43.59 v3(141.6,43.59) ; v3(152.86,109.5) 152.86,108.25 151.64,107.02 141.83,107.02 140.06,105.24 136.78,105.24 136.09,104.55 133.22,101.69 133.22,101.28 131.49,99.54 126.42,99.54 125.51,98.63 125.51,98.63 124.16,97.27 124.16,94.95 124.65,94.46 124.65,92.83 123.06,91.25 123.06,90.1 123.57,89.6 v3(123.57,89.48) 123.32,89.48 122,88.16 122,85.02 120.93,83.96 120.93,81.61 119.63,80.31 119.63,79.05 110.19,69.6 110.19,69.49 110.19,69.16 110.19,69.16 110.19,69.05 102.09,60.96 93.75,60.96 89.51,56.71 70.17,56.71 68.75,55.29 67.07,55.29 63.7,51.93 62.86,51.93 61.73,50.8 59.04,50.8 57.24,49 57.24,44.41 57.1,44.28 57.1,38.91 57.46,38.55 58.25,38.55 60.29,36.52 60.29,36.46 61.22,35.52 62.61,35.52 v3(62.61,35.52)
  L4 w0.127: v3(164.85,90.28) 164.85,83.25 166.46,81.64 166.46,79.78 168.4,77.83 168.4,73.1 169.88,71.62 169.88,70.39 v3(170.18,70.09)
  BOTTOM w0.102: v3(164.85,90.28) 164.85,90.29 165.13,90.56 165.13,96.34 163.24,98.23 158.87,98.23 v2(157.6,99.5) 157.28,99.82 157.28,105.74 157,106.02 154.35,108.67 153.7,108.67 v3(152.86,109.5)
SIDE_USB3_RX1+: length 11.6
  TOP w0.102: L10.3 184.77,125.34 185.01,125.11 185.12,125.11 185.63,125.62 185.83,125.62 185.97,125.75 U10.9 U10.2 188.01,125.75 188.14,125.62 188.79,125.62 190.79,123.62 192.7,123.62 193.16,123.16 193.52,123.16 193.62,123.26 SSUSB1.6
SIDE_USB3_RX1-: length 11.6
  TOP w0.102: L10.2 184.77,124.66 185.01,124.89 185.21,124.89 185.72,125.4 185.86,125.4 185.99,125.27 U10.10 U10.1 188,125.27 188.14,125.4 188.7,125.4 190.7,123.4 192.61,123.4 193.07,122.94 193.52,122.94 193.62,122.84 SSUSB1.5
SIDE_USB3_RX2+: length 12.6
  TOP w0.102: L13.3 186.8,101.17 186.6,101.37 186.34,101.37 186.11,101.6 186.11,103.47 186.52,103.88 186.82,103.88 186.95,104.01 U11.9 U11.2 188.84,104.01 188.97,103.88 189.76,103.88 190.73,102.9 192.38,102.9 193.13,102.16 193.52,102.16 193.62,102.26 SSUSB2.6
SIDE_USB3_RX2-: length 11.9
  TOP w0.102: L13.2 186.85,101.85 186.59,101.58 186.43,101.58 186.33,101.69 186.33,103.38 186.61,103.66 186.82,103.66 186.95,103.53 U11.10 U11.1 188.84,103.53 188.97,103.66 189.67,103.66 190.64,102.69 192.29,102.69 193.04,101.94 193.52,101.94 193.62,101.84 SSUSB2.5
SIDE_USB3_TX1+: length 11.3
  TOP w0.102: L9.3 184.82,127.5 185.05,127.27 185.39,127.27 185.52,127.14 185.8,127.14 185.93,127.27 U10.6 U10.5 188.01,127.27 188.14,127.14 189.08,127.14 190.38,128.44 192.34,128.44 193.05,129.16 193.52,129.16 193.62,129.26 SSUSB1.9
SIDE_USB3_TX1-: length 11.3
  TOP w0.102: L9.2 184.82,126.82 185.05,127.05 185.3,127.05 185.43,126.93 185.8,126.93 185.93,126.79 U10.7 U10.4 188,126.79 188.14,126.93 189.17,126.93 190.47,128.23 192.43,128.23 193.14,128.94 193.52,128.94 193.62,128.84 SSUSB1.8
SIDE_USB3_TX2+: length 10.8
  TOP w0.102: L12.3 185.66,105.84 185.89,105.6 186.25,105.6 186.46,105.4 186.64,105.4 186.77,105.53 U11.6 U11.5 188.84,105.53 188.97,105.4 189.46,105.4 191.47,107.41 192.34,107.41 193.09,108.16 193.52,108.16 193.62,108.26 SSUSB2.9
SIDE_USB3_TX2-: length 10.8
  TOP w0.102: L12.2 185.66,105.15 185.89,105.39 186.16,105.39 186.37,105.18 186.64,105.18 186.77,105.05 U11.7 U11.4 188.84,105.05 188.97,105.18 189.55,105.18 191.56,107.2 192.43,107.2 193.18,107.94 193.52,107.94 193.62,107.84 SSUSB2.8
SIO_ATXPG: length 8.2
  TOP w0.102: U24.123 57.67,35.66 57.79,35.54 57.79,35.16 58.45,34.49 59.9,34.49 v1(60.38,34.02) 60.38,33.55 60.32,33.49 R562.2 59.93,33.02 59.31,33.64 v3(59.31,33.89)
  BOTTOM w0.102: v3(59.31,33.89) 58.79,34.41 R1067.2
SIO_ATXPG_C: length 3.4
  BOTTOM w0.102: C696.1 59.71,34.97 R1067.1 59.92,34.93 60.3,34.55 v2(60.78,34.55) 60.83,34.6 60.83,35.63 R1080.1
SIO_GREEN: length 75.2
  TOP w0.254: U24.24 59.58,47.18 59.38,46.97 59.36,46.97 59.16,46.77 59.16,46.76 v3(59.14,46.74)
  L4 w0.254: v3(59.14,46.74) 59.84,46.74 60.86,45.72 60.86,38.39 58.95,36.48 45.18,36.48 44.32,35.62 37.25,35.62 35.06,37.81 35.06,40.12 33.7,41.48 33.7,44.2 33.88,44.39 33.88,45.01 33.88,45.02 33.88,45.4 v3(34.55,46.06)
  BOTTOM w0.254: R1024.2 R1028.2 13.07,42.39 13.08,42.38 R1036.1 13.96,41.83 14.23,42.1 Q103.G 15.81,42.43 20.14,46.77 26.64,46.77 27.18,46.24 v2(29.46,46.24) 32.03,46.24 32.49,45.78 34.27,45.78 v3(34.55,46.06)
SIO_GREEN_GP000: length 60.6
  TOP w0.102: v3(59.16,38.74) 59.18,38.72 59.18,38.49 59.35,38.32 60.16,38.32 60.22,38.38 U24.2
  L4 w0.127: v3(59.16,38.74) 58.97,38.55 56.52,38.55 55.22,37.26 48.3,37.26 47.36,38.2 44.94,38.2 43.75,37 37.82,37 36.45,38.38 36.45,40.69 35.38,41.75 35.38,41.89 35.08,42.2 35.08,43.63 36.04,44.59 v3(36.04,46.42)
  BOTTOM w0.102: R1024.1 14.5,44.03 15.02,43.51 16.33,43.51 19.94,47.13 v2(27.43,47.13) 31.61,47.13 32.63,46.11 33.95,46.11 34.36,46.52 35.2,46.52 35.31,46.42 v3(36.04,46.42)
SIO_HDD_LED: length 32.5
  TOP w0.102: R540.1 R537.2 17.91,39.23 18.06,39.38 v3(18.06,39.4) ; U24.89 44.68,40.78 44.3,41.16 43.29,41.16 42.91,41.54 40.64,41.54 39.57,42.61 37.11,42.61 36.68,43.04 35.95,43.04 v3(35.55,43.44)
  BOTTOM w0.102: v3(18.06,39.4) 18.52,39.86 21.21,39.86 24.05,42.71 v2(32.87,42.71) 33.96,42.71 34.69,43.44 v3(35.55,43.44)
SIO_HDD_LED_1: length 2.5
  TOP w0.102: Q70.B 14.5,38.03 v1(15.37,38.03) 16.27,38.03 R540.2
SIO_LVDS_BL_ADJ: length 297.9
  TOP w0.165: v3(43.56,69.58) 44.96,68.18 44.96,63.14 47.58,60.52 49.62,60.52 51.17,58.96 53.14,58.96 54.49,57.62 54.49,55.96 R461.1 54.07,55.2 54.07,53.89 54.06,53.88 54.06,53.71 53.27,52.92 U24.49 ; R168.2 18.14,120.63 v3(18.26,120.51)
  L3 w0.165: v3(18.26,120.51) 17.02,119.26 17.02,111.24 16.64,110.85 16.64,105.9 18.29,104.25 18.29,103.64 17.3,102.65 17.3,95.49 17.29,95.48 17.29,95.32 16.64,94.67 16.64,85.71 17.3,85.05 17.3,76.59 v3(18.95,74.94)
  L4 w0.165: v3(54.23,156.7) 54.61,157.08 54.61,169.53 55.24,170.16 55.24,201.25 60.91,206.92 60.91,209.31 62.37,210.78 63.98,210.78 73.01,219.8 96.06,219.8 96.82,219.04 104.17,219.04 108.84,214.38 114.9,214.38 115.07,214.54 117.64,214.54 118.32,215.23 119.12,215.23 120.1,216.21 120.98,216.21 v3(121.79,215.4)
  BOTTOM w0.165: v3(121.79,215.4) 122.07,215.12 122.07,214.53 R717.1 ; v3(43.56,69.58) 42.42,69.58 39.45,66.61 36.15,66.61 35.58,66.04 33.27,66.04 32.14,67.17 28.87,67.17 v2(27.94,68.11) 25.78,68.11 v3(18.95,74.94) ; v3(18.26,120.51) 18.76,121 18.76,124.54 21.42,127.2 21.42,128.85 22.95,130.37 38.19,130.37 39.12,131.3 52.59,131.3 53.98,132.68 53.98,156.45 v3(54.23,156.7)
SIO_PECI_REQ_N: length 10.8
  TOP w0.102: v3(56.01,45.91) 58.49,45.91 58.92,45.48 60.1,45.48 60.2,45.58 U24.20
  BOTTOM w0.102: v3(56.01,45.91) 56.02,45.92 56.65,45.92 57.19,46.45 R1019.2 57.19,47.01 57.53,47.35 v2(58.04,47.35) 58.17,47.23 58.17,45.89 Q102.C
SIO_PROCHOT_R_N: length 4.5
  TOP w0.102: U24.36 58.47,53.44 59.45,54.42 v1(59.89,54.42) 60.05,54.57 R451.2
SIO_PSON_N: length 165.5
  TOP w0.102: v3(48.08,54.31) 48.25,54.48 48.25,55.13 R463.1 49.21,54.82 50.42,54.82 51.94,53.3 51.94,52.92 51.67,52.64 U24.53 ; v3(29.92,146.21) 29.92,146.43 29.34,147.01 29.34,148.82 28.94,149.21 26.92,149.21 26.52,148.8 25.95,148.8 24.73,147.58 24.16,147.58 23.83,147.91 22.61,147.91 22.43,147.74 18.47,147.74 18.01,148.19 R158.1
  L3 w0.127: v3(30.46,67.68) 29.89,68.26 29.89,71.61 30.47,72.19 30.47,73.25 30.47,73.25 30.47,75.38 23.29,82.56 23.29,98.08 23.25,98.12 23.25,118.13 24.64,119.52 24.64,128.81 30.1,134.27 30.1,146.03 v3(29.92,146.21)
  L4 w0.127: v3(19.43,52.56) 19.43,58.71 28.34,67.61 30.39,67.61 v3(30.46,67.68)
  BOTTOM w0.102: Q98.G 31.58,68.79 30.48,67.68 v3(30.46,67.68) ; v3(48.08,54.31) 47.37,53.6 44.98,53.6 43.13,51.75 37.92,51.75 37.67,51.5 37.67,50.5 36.96,49.79 36.5,49.79 35.89,50.4 34.04,50.4 31.88,52.56 v2(28.19,52.56) v3(19.43,52.56)
SIO_PSON_N_C: length 2.8
  TOP w0.102: R158.2 17.2,148.05 17.2,147.33 v1(16.97,147.1) 16.97,147.2 15.96,148.21 R159.1
SIO_PSON_N_C_1: length 3.2
  TOP w0.102: Q121.G 39.75,155.53 v1(39.75,154.87) 39.55,154.67 R1139.2
SIO_PSON_N_C_2: length 8.3
  TOP w0.102: Q121.D 39.88,158.63 v1(38.51,160) 37.18,158.68 Q122.G 36.25,159.22 34.07,159.22 R1138.2
SIO_PSON_N_C_3: length 5.6
  TOP w0.102: Q122.D 36.2,155.46 35.69,154.95 v1(35.13,154.95) 34.84,154.95 34.45,155.34 34.45,155.59 R1133.2 33.78,155.37 R1135.1
SIO_PSON_N_C_4: length 3
  TOP w0.102: R1135.2 v1(31.5,155.05) 31.1,155.45 31.1,155.8 Q115.1
SIO_PSON_N_C_5: length 15.2
  TOP w0.102: C734.2 30.92,160.83 R1137.1 ; R1136.2 R1137.1 ; R1137.1 30.92,159.03 31.37,158.58 Q115.3 30.06,158.42 29.82,158.66 28.93,158.66 v1(28.8,158.53) 28.68,158.4 28.68,155.56 28.4,155.28 25.96,155.28 25.27,154.59 C735.1 24.89,154.92 23.75,154.92
SIO_SMBCLK1: length 4.9
  TOP w0.102: U24.70 44.97,48.38 44.97,48.39 43.69,49.68 TP166.1 43.31,51.04 R492.1
SIO_SMBCLK2: length 5.7
  TOP w0.102: U24.26 62.12,47.98 62.18,47.92 62.92,47.92 63.55,48.55 v1(63.55,49.13) 64.31,49.89 R482.1 R481.2
SIO_SMBDAT1: length 4.7
  TOP w0.102: R495.1 42.48,48.82 TP167.1 43.26,48.04 44.04,48.04 44.49,47.58 U24.72
SIO_SMBDAT2: length 4.5
  TOP w0.102: R493.1 R496.2 63.58,47.61 63.54,47.57 v1(63.37,47.57) 62.03,47.57 62.02,47.58 U24.25
SIO_SPKR: length 120
  TOP w0.203: 58.88,35.16 58.47,35.57 U24.125
  TOP w0.305: 58.88,35.16 62.14,35.16 62.34,34.96 62.41,34.96 v3(62.61,34.76) 63.22,34.15 v1(63.22,34.15) 63.22,33.81 R561.1
  L3 w0.305: v3(62.61,34.76) 61.43,34.76 59.89,36.29 59.89,36.36 58.09,38.16 57.3,38.16 56.67,38.79 56.67,40.97 56.64,41 56.64,44.38 56.85,44.58 56.85,49.16 59.92,52.23 62.41,52.23 62.61,52.43 63.5,52.43 66.75,55.69 68.59,55.69 70.01,57.11 89.35,57.11 93.59,61.35 101.82,61.35 109.79,69.33 109.79,69.77 119.13,79.1 119.13,80.26 120.48,81.61 120.48,81.64 120.61,81.77 120.61,84.15 121.68,85.21 121.68,90.45 124.26,93.02 124.26,94.29 v3(123.57,94.98)
  BOTTOM w0.305: R898.1 123.79,94.76 v3(123.57,94.98)
SIO_TACH3: length 4.4
  TOP w0.165: R450.1 58.88,55.2 58.55,54.87 58.52,54.87 v1(58.08,54.43) 57.44,53.79 57.44,53.79 57.18,53.54 57.18,53.02 57.27,52.93 U24.39
SIO_YELLOW: length 64.1
  TOP w0.254: v3(59.11,45.93) 59.11,45.96 59.93,46.78 U24.23
  L4 w0.254: v3(59.11,45.93) 59.03,45.86 59.03,40.9 60.45,39.48 60.45,38.56 58.78,36.89 45.01,36.89 44.15,36.03 37.42,36.03 35.47,37.97 35.47,40.28 34.41,41.35 34.41,41.38 34.1,41.68 34.1,44.04 34.29,44.22 34.29,44.74 34.64,45.09 v3(34.64,45.12)
  BOTTOM w0.254: v3(34.64,45.12) 34.64,45.09 33.17,43.62 v2(29.31,43.62) 28.73,43.04 23.89,43.04 22.1,41.25 R1040.2 R1033.2 18.6,41.25 Q107.G
SLEEVE: length 32.6
  TOP w0.203: v3(180.34,84.85) 180.34,85.05 179.92,85.46 U16.32
  TOP w0.508: R323.2 175.87,82.41 v3(175.72,82.25) 175.51,82.05 C206.1
  TOP w1.016: UHS1.4 202.06,82.81 202.06,79.81 Q46.D
  L3 w1.016: v3(189.1,87.72) 189.13,87.74 197.21,87.74 UHS1.4
  BOTTOM w0.508: v3(180.34,84.85) 179.98,84.85 v2(178.49,83.35) 178.08,83.35 176.99,82.25 v3(175.72,82.25) ; 183.01,85.84 183.64,86.47 183.64,86.66 184.59,87.61 Q42.1
SLEEVE_G: length 8.5
  TOP w0.102: R380.2 194.25,73.45 194.72,73.45 195.15,73.87 Q49.D 198.22,73.87 R386.1 199.47,74.28 v1(199.75,74.56) 199.75,75.42 Q46.G
SLP_S3_N: length 586.2
  TOP w0.102: v3(4.62,246.03) 4.62,243.21 7.21,240.62 7.21,239.02 8.64,237.6 19.92,237.6 20.69,236.83 21.72,235.8 26.6,235.8 31.04,240.24 v3(32.31,240.24) ; v3(161.16,24.11) 160.73,23.68 160.73,23.29 160.53,23.09 R578.1 ; R204.1 149.81,102.09 v3(150.29,102.57) ; v3(64.8,37.02) 64.29,37.02 64.21,36.94 61.98,36.94 61.39,37.52 59.11,37.52 58.34,38.29 57.54,38.29 57.28,38.02 57.28,37.56 56.87,37.15 U24.121 ; U29.AK40 140.83,85.3 141.43,85.9 141.43,86.31 141.76,86.64 141.76,89.37 v4(141.61,89.52) 141.8,89.52 142.7,90.42 142.7,91.47 143.54,92.31 144.52,92.31 145.95,93.74 145.95,95.46 v3(146.33,95.84)
  L3 w0.127: v3(64.8,37.02) 64.8,33.85 65.34,33.3 65.34,24.14 67.47,22.01 67.59,22.01 v3(67.82,21.78) 68.66,20.94 70.82,20.94 75.31,16.44 78.53,16.44 79.4,17.32 79.4,17.59 80.47,18.67 88.53,18.67 89.64,19.77 92.42,19.77 94.26,21.61 101.08,21.61 101.61,22.14 109.7,22.14 111.01,20.83 116.6,20.83 117.91,22.14 122.49,22.14 123.4,21.23 128.96,21.23 131.28,23.56 133.65,23.56 135.14,25.04 135.97,25.04 138.43,27.5 v3(138.43,29.7) 138.54,29.7 139.83,31 139.83,31 145.4,36.57 145.4,37.48 144.6,38.28 144.6,39.83 147.87,43.1 147.87,48.74 150.95,51.83 150.97,51.83 v3(151.26,52.11) ; v3(32.31,240.24) 35.79,240.24 43.31,232.72 43.31,215.96 46.53,212.73 48.87,212.73 50.01,211.59 50.01,174.61 43.18,167.78 43.18,164.42 v3(41.5,162.75)
  L4 w0.127: v3(151.26,52.11) 151.26,52.5 152.2,53.43 v3(152.2,57.64) 152.2,57.82 153.45,59.08 153.45,62.13 155.5,64.17 155.5,65.14 156.41,66.06 156.41,69.58 154.11,71.89 154.11,78.54 151.38,81.26 151.38,81.69 150.25,82.82 150.25,83.68 149.55,84.39 148.56,84.39 144.21,88.73 142.4,88.73 v4(141.61,89.52) ; v3(150.29,102.57) 152.13,100.73 152.13,98.52 151.13,97.52 147.47,97.52 146.33,96.38 v3(146.33,95.84) ; v3(39.75,150.28) 42,148.03 42,140.84 41.55,140.4 41.55,112 38,108.44 38,89.32 36.42,87.74 36.42,74.78 37.17,74.03 37.17,65.59 27.25,55.68 27.25,49.59 24.17,46.5 24.17,43.9 26.2,41.87 26.2,40.05 27.08,39.18 27.08,35.03 28.11,33.99 28.12,33.98 29.76,32.34 29.76,32.18 32.25,29.69 32.25,25.97 34.77,23.44 34.77,23.24 35.87,22.13 38.05,22.13 42.39,17.79 42.39,17.41 43.86,15.94 44.98,15.94 47.49,18.45 48.62,18.45 48.93,18.76 52.38,18.76 52.79,19.17 53.18,19.17 53.26,19.09 55.11,19.09 58.27,15.94 59.18,15.94 60.15,16.9 60.27,17.03 65.28,17.03 66.44,15.87 67.83,15.87 67.97,15.73 v3(68.07,15.73)
  BOTTOM w0.102: v3(41.5,162.75) 40.97,162.75 40.46,162.24 v2(40.46,157.97) 40.46,150.99 v3(39.75,150.28) ; v3(68.07,15.73) 68.07,15.83 68.28,16.04 68.28,17.03 68.45,17.21 68.45,21.14 v3(67.82,21.78) ; R632.1 v3(4.62,246.03) ; R1014.1 137.48,48.12 139.12,48.12 140.84,49.84 141.52,49.84 143.39,51.72 145.11,51.72 151.02,57.64 v3(152.2,57.64) ; v3(161.16,24.11) 160.05,25.23 153.06,25.23 152.63,25.66 145.89,25.66 143.68,27.87 142.62,27.87 140.79,29.7 v3(138.43,29.7)
SLP_S3_N_1: length 3.3
  BOTTOM w0.102: Q87.2 4.45,242.27 3.68,243.04 v2(3.68,243.34) 3.68,243.38 R632.2
SLP_S3_N_2: length 7.7
  BOTTOM w0.102: Q86.5 6.68,245.35 6.91,245.12 6.91,244.08 5.94,243.11 5.94,241.33 4.91,240.31 R658.2 v2(3.99,240.22)
SLP_S3_N_3: length 5.3
  BOTTOM w0.102: Q87.6 6.91,241.32 R658.1 4.93,239.34 R663.2 4.95,239.16 R667.1 6.79,239.16 6.9,239.06 v2(6.9,239.06)
SLP_S3_N_4: length 3.2
  BOTTOM w0.102: Q89.B 7.74,237.45 v2(7.74,238.11) 7.57,238.27 R667.2
SLP_S3_N_Q46: length 2.8
  BOTTOM w0.102: v2(138.3,47.42) R1014.2 137.13,47.26 Q101.5
SLP_S3_N_R1: length 295.3
  TOP w0.102: v3(153.54,20.18) 154.13,20.76 158.64,20.76 R590.2 R578.2 162.24,23.35 Q79.G ; R1139.1 36.65,154.67 v1(36.55,154.77) 37.26,155.48 v3(37.66,155.48)
  L3 w0.127: v3(32.24,31.35) 39.97,31.35 42.1,33.47 43.56,33.47 44.83,32.21 44.83,27.38 50.16,22.06 51.05,22.06 55.3,17.8 55.55,17.8 57.9,15.45 62.52,15.45 66.29,11.68 66.29,9.44 66.29,9.12 67.27,8.15 70.43,8.15 73.34,5.24 81.98,5.24 85.32,8.58 90.08,8.58 90.53,8.14 92.76,8.14 93.37,8.75 103.88,8.75 104.12,8.52 105.5,8.52 107.23,10.24 124.46,10.24 124.74,9.97 128.78,9.97 129.36,10.55 133.38,10.55 140.84,18.02 152.1,18.02 153.29,19.21 153.29,19.92 v3(153.54,20.18)
  L4 w0.127: v3(37.66,155.48) 41.88,151.25 41.88,149.23 42.65,148.47 42.65,142.32 44.06,140.92 44.06,111.64 38.81,106.39 38.81,89.29 36.8,87.28 36.8,75.72 38.63,73.89 38.63,73.5 37.97,72.84 37.97,65.32 28.08,55.42 28.08,42.77 28.65,42.2 29.25,42.2 29.74,41.7 29.74,38.03 30.56,37.22 30.56,33.72 31.08,33.2 31.08,32.71 32.11,31.68 32.11,31.48 v3(32.24,31.35)
SLP_S4_N: length 373.4
  TOP w0.102: v3(183.13,184.01) 179.9,184.01 R107.1 ; R563.2 58.14,31.26 v3(58.1,31.23) ; U29.AT35 144.49,82.57 144.81,82.89 145.21,82.89 145.25,82.86 145.51,82.86 145.7,83.05 146.5,83.05 148.69,85.24 v3(149.67,85.24)
  L3 w0.127: v3(175.23,145.68) 175.23,145.4 175.43,145.21 175.43,144.97 175.53,144.87 175.53,123.11 170.84,118.42 170.52,118.42 170.52,118.42 169.43,118.42 166.03,118.42 159.77,112.16 159.77,109.84 157.38,107.46 157.38,98.31 155,95.93 155,93.78 155.41,93.37 155.41,91.05 153.18,88.82 153.18,87.58 150.84,85.24 v3(149.67,85.24) ; v3(152.93,47.74) 152.17,46.97 152.17,45.84 151,44.67 151,39 149.96,37.96 149.83,37.96 147.08,35.21 146.6,35.21 141.14,29.75 141.14,28.02 135.12,22.01 132.07,22.01 129.64,19.58 128.75,19.58 127.96,18.79 127.39,18.79 125.68,17.08 120.6,17.08 119.05,18.63 115.55,18.63 114.83,17.9 106.92,17.9 106.3,18.51 102.48,18.51 101.07,17.11 94.13,17.11 94.1,17.14 93.99,17.14 92.99,18.14 90.35,18.14 86.67,14.46 80.26,14.46 79.81,14.92 79.16,14.92 79.16,14.92 78.09,14.92 74.32,14.92 70.21,19.02 67.73,19.02 61.67,25.08 61.67,27.66 v3(58.1,31.23)
  L4 w0.127: v3(149.67,85.24) 150.11,85.68 150.11,86.34 150.82,87.04 151.19,87.04 151.49,86.74 152.79,86.74 152.95,86.9 153.58,86.9 156.15,84.34 156.15,72.77 156.2,72.72 156.2,72.71 158.55,70.36 158.55,64.07 157.53,63.06 157.53,60.6 156.36,59.43 156.36,58.75 155.93,58.32 155.93,52.89 154.55,51.51 154.55,51.4 154.28,51.12 154.28,50.9 154.11,50.74 154.11,50.35 153.59,49.83 153.59,48.47 153.02,47.89 153.02,47.82 v3(152.93,47.74) ; v3(183.13,184.01) 182.32,184.01 178.96,180.64 178.96,175.88 182.18,172.65 183.69,172.65 v3(186.94,169.4)
  BOTTOM w0.102: v3(175.23,145.68) 175.31,145.75 187.55,145.75 v2(188.84,147.04) 191.64,149.84 191.64,167.24 189.48,169.4 v3(186.94,169.4) ; R1048.1 112.53,39.8 109.47,42.86 109.47,44.46 110.31,45.3 134.17,45.3 134.86,44.61 139.29,44.61 141.78,47.1 146.47,47.1 147.82,48.45 152.22,48.45 v3(152.93,47.74)
