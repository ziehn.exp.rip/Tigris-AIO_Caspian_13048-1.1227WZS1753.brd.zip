# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C402-TO0D2H26
  custom 0.152x0.152 smd: 1(0,0.457) 2(0,-0.457)
C402H20
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C402H22
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C402H24
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
C603
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H36
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C603H40
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
C805H38
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H54
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H56
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C805H58
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
C1206H71
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
C1210H111
  rect 2.794x1.397 smd: 1(0,1.473) 2(0,-1.473)
CI0104P1VKK-NH
  round 1.27 hole 0.889: 1(3,0) 2(1,0) 3(-1,0) 4(-3,0)
CON2C
  custom 0.171x0.171 smd: 1(0,0.533) 2(0,-0.533)
CON2C-U
  custom 0.171x0.171 smd: 1(0,0.533) 2(0,-0.533)
CT3528H79
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT7343H75
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
DFN8G2-G1309-UH40
  rect 0.305x0.737 smd: 1(0.75,1.018) 2(0.25,1.018) 3(-0.25,1.018) 4(-0.75,1.018) 5(-0.75,-1.018) 6(-0.25,-1.018) 7(0.25,-1.018) 8(0.75,-1.018)
  rect 1.295x0.889 smd: 9(0,0)
DFN10G3-G265175H32
  rect 0.305x0.914 smd: 1(1,1.549) 2(0.5,1.549) 3(0,1.549) 4(-0.5,1.549) 5(-1,1.549) 6(-1,-1.549) 7(-0.5,-1.549) 8(0,-1.549) 9(0.5,-1.549) 10(1,-1.549)
  rect 2.642x1.753 smd: 11(0,0)
DFN10G2510H26
  rect 0.305x0.787 smd: 1(1,0.494) 5(-1,0.494) 6(-1,-0.494) 10(1,-0.494)
  rect 0.254x0.787 smd: 2(0.521,0.494) 4(-0.521,0.494) 7(-0.521,-0.494) 9(0.521,-0.494)
  rect 0.025x0.025 smd: 3(0,0.494)
  rect 0.406x1.753 smd: 8(0,-0.494)
DM-BSH-03001-FDA-01
  round 0.254 hole 1.016 unplated: (-10.065,0) (10.065,0)
  rect 0.279x2.769 smd: 1(-7.25,-5.526) 2(-7.25,0.198) 3(-6.75,-5.526) 4(-6.75,0.198) 5(-6.25,-5.526) 6(-6.25,0.198) 7(-5.751,-5.526) 8(-5.751,0.198) 9(-5.25,-5.526) 10(-5.25,0.198) 11(-4.75,-5.526) 12(-4.75,0.198) 13(-4.249,-5.526) 14(-4.249,0.198) 15(-3.75,-5.526) 16(-3.75,0.198) 17(-3.25,-5.526) 18(-3.25,0.198) 19(-2.75,-5.526) 20(-2.75,0.198) 21(-2.25,-5.526) 22(-2.25,0.198) 23(-1.75,-5.526) 24(-1.75,0.198) 25(-1.25,-5.526) 26(-1.25,0.198) 27(-0.751,-5.526) 28(-0.751,0.198) 29(-0.25,-5.526) 30(-0.25,0.198) 31(0.25,-5.526) 32(0.25,0.198) 33(0.751,-5.526) 34(0.751,0.198) 35(1.25,-5.526) 36(1.25,0.198) 37(1.75,-5.526) 38(1.75,0.198) 39(2.25,-5.526) 40(2.25,0.198) 41(2.75,-5.526) 42(2.75,0.198) 43(3.25,-5.526) 44(3.25,0.198) 45(3.75,-5.526) 46(3.75,0.198) 47(4.249,-5.526) 48(4.249,0.198) 49(4.75,-5.526) 50(4.75,0.198) 51(5.25,-5.526) 52(5.25,0.198) 53(5.751,-5.526) 54(5.751,0.198) 55(6.25,-5.526) 56(6.25,0.198) 57(6.75,-5.526) 58(6.75,0.198) 59(7.25,-5.526) 60(7.25,0.198)
DO214AAAK-1121H97
  rect 2.311x2.032 smd: A(0,2.322) K(0,-2.322)
ECAP-100D6D3H237
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H355
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H375
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
ECAP-100D6D3H473
  rect 1.397x1.397 hole 0.991: 1(0,-1.27)
  round 1.397 hole 0.991: 2(0,1.27)
FUSE-1005H17
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
FUSE-3216H26
  rect 1.778x1.27 smd: 1(0,-1.336) 2(0,1.336)
FUSE-7452-UH50
  rect 2.21x5.283 smd: 1(-3.404,0) 2(3.404,0)
G881A04102TEU
  round 0.254 hole 1.041 unplated: (-4.5,0) (4.5,0)
  round 1.676 hole 1.041: 1(1.5,-3.94) 2(-1.5,-3.94) 3(1.5,-0.94) 4(-1.5,-0.94)
G6179-1000000-U
  rect 0.635x2.108 smd: 1(1.905,3.47) 2(0.635,3.47) 3(-0.635,3.47) 4(-1.905,3.47) 5(-1.905,-3.47) 6(-0.635,-3.47) 7(0.635,-3.47) 8(1.905,-3.47)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GEN315R138-8-F-A
  round 0.254 hole 3.505 unplated: (0,0)
  round 0.864 hole 0.508: 1(-2.794,1.372) 2(-1.397,2.769) 3(2.794,1.372) 4(1.397,-2.819) 5(-1.397,-2.819) 6(-2.794,-1.422) 7(1.397,2.769) 8(2.794,-1.422)
GEN315R177-8-F-A
  round 0.254 hole 4.496 unplated: (0,0)
  round 0.864 hole 0.508: 1(-2.794,1.397) 2(-1.397,2.794) 3(2.794,1.397) 4(1.397,-2.794) 5(-1.397,-2.794) 6(-2.794,-1.397) 7(1.397,2.794) 8(2.794,-1.397)
HF1103E-P1
  round 0.254 hole 1.651 unplated: (-4.45,-3.43)
  round 1.422 hole 1.016: 1(-2.54,0) 2(0,0) 3(2.54,0)
HF08040-M1
  round 0.254 hole 1.143 unplated: (-3.81,-2.16)
  round 1.549 hole 1.143: 1(3.81,0) 2(1.27,0) 3(-1.27,0) 4(-3.81,0)
HL5507F
  round 0.254 hole 1.016 unplated: (5,0)
  round 1.321 hole 0.914: 1(-6,-1) 2(-6,1) 3(-4,-1) 4(-4,1) 5(-2,-1) 6(-2,1) 7(0,-1) 8(0,1) 9(2,-1) 10(2,1) 11(4,-1) 12(4,1) 13(6,-1) 14(6,1)
HOLE236R157
  round 5.994 hole 3.988: 1(0,0)
JAC331-0140A8B-9H
  oval 1.321x2.235 hole 0.61x1.524: 1(-4.95,2.1) 4(5,2.1) P(3.25,-3.15) Q(-3.9,-2.1)
  oval 2.235x1.422 hole 1.524x0.711: 5(0,3.17)
L402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L402H24
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L603H38
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
L805H44
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
L3030-3009H40
  rect 3.251x1.524 smd: 1(0,1.108) 2(0,-1.108)
L3330-1230H95
  rect 3.251x1.778 smd: 1(0,1.135) 2(0,-1.135)
L20125H42
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
L109100-2230H158
  rect 3.505x3.353 smd: 1(0,4.52) 2(0,-4.52)
L112100-2135H158
  rect 4.013x3.251 smd: 1(0,4.72) 2(0,-4.72)
L115100-2230H158
  rect 3.251x3.099 smd: 1(0,4.845) 2(0,-4.845)
L125100-4P-1H28
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H36
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L125100-4P-1H37
  rect 0.762x0.432 smd: 1(0.625,0.341) 2(-0.625,0.341) 3(-0.625,-0.341) 4(0.625,-0.341)
L686647H119
  rect 2.159x3.429 smd: 1(-3.111,0) 2(3.111,0)
LED1608AKH30
  custom 0.216x0.216 smd: A(0,0.762) K(0,-0.762)
MC-146H56
  rect 1.397x0.61 smd: 1(-3.299,-0.45) 2(3.299,-0.45) 3(3.299,0.45) 4(-3.299,0.45)
NTC-402H24
  custom 0.152x0.152 smd: 1(0,0.445) 2(0,-0.445)
NTC-603H28
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
PFPCC128-5H48
  rect 0.203x1.524 smd: 1(6.2,7.747) 2(5.8,7.747) 3(5.4,7.747) 4(5,7.747) 5(4.6,7.747) 6(4.2,7.747) 7(3.8,7.747) 8(3.4,7.747) 9(3,7.747) 10(2.6,7.747) 11(2.2,7.747) 12(1.8,7.747) 13(1.4,7.747) 14(0.999,7.747) 15(0.599,7.747) 16(0.199,7.747) 17(-0.199,7.747) 18(-0.599,7.747) 19(-0.999,7.747) 20(-1.4,7.747) 21(-1.8,7.747) 22(-2.2,7.747) 23(-2.6,7.747) 24(-3,7.747) 25(-3.4,7.747) 26(-3.8,7.747) 27(-4.2,7.747) 28(-4.6,7.747) 29(-5,7.747) 30(-5.4,7.747) 31(-5.8,7.747) 32(-6.2,7.747) 65(-6.2,-7.747) 66(-5.8,-7.747) 67(-5.4,-7.747) 68(-5,-7.747) 69(-4.6,-7.747) 70(-4.2,-7.747) 71(-3.8,-7.747) 72(-3.4,-7.747) 73(-3,-7.747) 74(-2.6,-7.747) 75(-2.2,-7.747) 76(-1.8,-7.747) 77(-1.4,-7.747) 78(-0.999,-7.747) 79(-0.599,-7.747) 80(-0.199,-7.747) 81(0.199,-7.747) 82(0.599,-7.747) 83(0.999,-7.747) 84(1.4,-7.747) 85(1.8,-7.747) 86(2.2,-7.747) 87(2.6,-7.747) 88(3,-7.747) 89(3.4,-7.747) 90(3.8,-7.747) 91(4.2,-7.747) 92(4.6,-7.747) 93(5,-7.747) 94(5.4,-7.747) 95(5.8,-7.747) 96(6.2,-7.747)
  rect 1.524x0.203 smd: 33(-7.747,6.2) 34(-7.747,5.8) 35(-7.747,5.4) 36(-7.747,5) 37(-7.747,4.6) 38(-7.747,4.2) 39(-7.747,3.8) 40(-7.747,3.4) 41(-7.747,3) 42(-7.747,2.6) 43(-7.747,2.2) 44(-7.747,1.8) 45(-7.747,1.4) 46(-7.747,0.999) 47(-7.747,0.599) 48(-7.747,0.199) 49(-7.747,-0.199) 50(-7.747,-0.599) 51(-7.747,-0.999) 52(-7.747,-1.4) 53(-7.747,-1.8) 54(-7.747,-2.2) 55(-7.747,-2.6) 56(-7.747,-3) 57(-7.747,-3.4) 58(-7.747,-3.8) 59(-7.747,-4.2) 60(-7.747,-4.6) 61(-7.747,-5) 62(-7.747,-5.4) 63(-7.747,-5.8) 64(-7.747,-6.2) 97(7.747,-6.2) 98(7.747,-5.8) 99(7.747,-5.4) 100(7.747,-5) 101(7.747,-4.6) 102(7.747,-4.2) 103(7.747,-3.8) 104(7.747,-3.4) 105(7.747,-3) 106(7.747,-2.6) 107(7.747,-2.2) 108(7.747,-1.8) 109(7.747,-1.4) 110(7.747,-0.999) 111(7.747,-0.599) 112(7.747,-0.199) 113(7.747,0.199) 114(7.747,0.599) 115(7.747,0.999) 116(7.747,1.4) 117(7.747,1.8) 118(7.747,2.2) 119(7.747,2.6) 120(7.747,3) 121(7.747,3.4) 122(7.747,3.8) 123(7.747,4.2) 124(7.747,4.6) 125(7.747,5) 126(7.747,5.4) 127(7.747,5.8) 128(7.747,6.2)
POLYSW-3217-UH40
  rect 1.905x1.143 smd: 1(0,1.418) 2(0,-1.418)
POLYSW-4633-UH24
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-5PH45
  rect 0.762x1.524 smd: 1(-1.905,-3.81) 2(-0.635,-3.81) 3(0.635,-3.81) 4(1.905,-3.81)
  rect 5.283x5.08 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.635,2.032) 7(-0.635,2.032) 8(-1.905,2.032)
PSDAT0-09GLBS1ZZ4H1
  round 0.254 hole 1.651 unplated: (-12.65,0) (12.65,0)
  rect 0.991x2.54 smd: 1(-7.57,8.12) 2(-5.07,8.12) 3(-2.57,8.12) 4(-0.07,8.12) 5(2.43,8.12) 6(4.93,8.12) 7(7.43,8.12) 8(9.055,8.12) 9(-10.07,8.12) 10(-11.755,8.12) 11(10.875,8.12)
  rect 2.057x2.489 smd: 12(-15.229,-8.35) 13(15.229,-8.35)
PT2-P0P-26B9
  round 0.254 hole 3.2 unplated: (-5.715,0) (5.715,0)
  round 1.321 hole 0.914: 1(5.715,-8.89) 2(4.445,-6.35) 3(3.175,-8.89) 4(1.905,-6.35) 5(0.635,-8.89) 6(-0.635,-6.35) 7(-1.905,-8.89) 8(-3.175,-6.35) 9(-4.445,-8.89) 10(-5.715,-6.35)
  round 1.448 hole 1.041: 11(6.325,4.11) 12(3.785,4.11) 13(-3.785,4.11) 14(-6.325,4.11)
  round 1.981 hole 1.575: 15(7.875,-3.89) 16(-7.875,-3.89)
QFN10-G255185-UH40
  rect 0.305x0.889 smd: 1(1,1.57) 2(0.5,1.57) 3(0,1.57) 4(-0.5,1.57) 5(-1,1.57) 6(-1,-1.57) 7(-0.5,-1.57) 8(0,-1.57) 9(0.5,-1.57) 10(1,-1.57)
  rect 2.54x1.778 smd: 11(0,0)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN32-G3D55H40
  rect 0.305x0.838 smd: 1(1.75,2.591) 8(-1.75,2.591) 17(-1.75,-2.591) 24(1.75,-2.591)
  rect 0.305x0.94 smd: 2(1.25,2.54) 3(0.751,2.54) 4(0.25,2.54) 5(-0.25,2.54) 6(-0.751,2.54) 7(-1.25,2.54) 18(-1.25,-2.54) 19(-0.751,-2.54) 20(-0.25,-2.54) 21(0.25,-2.54) 22(0.751,-2.54) 23(1.25,-2.54)
  rect 0.838x0.305 smd: 9(-2.591,1.75) 16(-2.591,-1.75) 25(2.591,-1.75) 32(2.591,1.75)
  rect 0.94x0.305 smd: 10(-2.54,1.25) 11(-2.54,0.751) 12(-2.54,0.25) 13(-2.54,-0.25) 14(-2.54,-0.751) 15(-2.54,-1.25) 26(2.54,-1.25) 27(2.54,-0.751) 28(2.54,-0.25) 29(2.54,0.25) 30(2.54,0.751) 31(2.54,1.25)
  rect 3.531x3.531 smd: 33(0,0)
QFN32J4-G2D8-3H40
  rect 0.203x0.508 smd: 1(1.4,1.886) 8(-1.4,1.886) 17(-1.4,-1.886) 24(1.4,-1.886)
  rect 0.203x0.533 smd: 2(1,1.886) 3(0.6,1.886) 4(0.2,1.886) 5(-0.2,1.886) 6(-0.6,1.886) 7(-1,1.886) 18(-1,-1.886) 19(-0.6,-1.886) 20(-0.2,-1.886) 21(0.2,-1.886) 22(0.6,-1.886) 23(1,-1.886)
  rect 0.508x0.203 smd: 9(-1.886,1.4) 16(-1.886,-1.4) 25(1.886,-1.4) 32(1.886,1.4)
  rect 0.533x0.203 smd: 10(-1.886,1) 11(-1.886,0.6) 12(-1.886,0.2) 13(-1.886,-0.2) 14(-1.886,-0.6) 15(-1.886,-1) 26(1.886,-1) 27(1.886,-0.6) 28(1.886,-0.2) 29(1.886,0.2) 30(1.886,0.6) 31(1.886,1)
  rect 2.794x2.794 smd: 33(0,0)
QFN32J4-G2D8-4H32
  rect 0.203x0.864 smd: 1(1.4,2.057) 8(-1.4,2.057) 17(-1.4,-2.057) 24(1.4,-2.057)
  rect 0.203x0.914 smd: 2(1,2.057) 3(0.6,2.057) 4(0.2,2.057) 5(-0.2,2.057) 6(-0.6,2.057) 7(-1,2.057) 18(-1,-2.057) 19(-0.6,-2.057) 20(-0.2,-2.057) 21(0.2,-2.057) 22(0.6,-2.057) 23(1,-2.057)
  rect 0.864x0.203 smd: 9(-2.057,1.4) 16(-2.057,-1.4) 25(2.057,-1.4) 32(2.057,1.4)
  rect 0.914x0.203 smd: 10(-2.057,1) 11(-2.057,0.6) 12(-2.057,0.2) 13(-2.057,-0.2) 14(-2.057,-0.6) 15(-2.057,-1) 26(2.057,-1) 27(2.057,-0.6) 28(2.057,-0.2) 29(2.057,0.2) 30(2.057,0.6) 31(2.057,1)
  rect 2.692x2.692 smd: 33(0,0)
QFN32J4-G2D9-U1H36
  rect 0.203x0.864 smd: 1(1.4,2.085) 2(1,2.085) 3(0.6,2.085) 4(0.2,2.085) 5(-0.2,2.085) 6(-0.6,2.085) 7(-1,2.085) 8(-1.4,2.085) 17(-1.4,-2.085) 18(-1,-2.085) 19(-0.6,-2.085) 20(-0.2,-2.085) 21(0.2,-2.085) 22(0.6,-2.085) 23(1,-2.085) 24(1.4,-2.085)
  rect 0.864x0.203 smd: 9(-2.085,1.4) 10(-2.085,1) 11(-2.085,0.6) 12(-2.085,0.2) 13(-2.085,-0.2) 14(-2.085,-0.6) 15(-2.085,-1) 16(-2.085,-1.4) 25(2.085,-1.4) 26(2.085,-1) 27(2.085,-0.6) 28(2.085,-0.2) 29(2.085,0.2) 30(2.085,0.6) 31(2.085,1) 32(2.085,1.4)
  rect 2.692x2.692 smd: 33(0,0)
QFN40-G3D5H32
  rect 0.203x0.914 smd: 1(1.8,2.553) 10(-1.8,2.553) 21(-1.8,-2.553) 30(1.8,-2.553)
  rect 0.203x0.965 smd: 2(1.4,2.527) 3(1,2.527) 4(0.6,2.527) 5(0.2,2.527) 6(-0.2,2.527) 7(-0.6,2.527) 8(-1,2.527) 9(-1.4,2.527) 22(-1.4,-2.527) 23(-1,-2.527) 24(-0.6,-2.527) 25(-0.2,-2.527) 26(0.2,-2.527) 27(0.6,-2.527) 28(1,-2.527) 29(1.4,-2.527)
  rect 0.914x0.203 smd: 11(-2.553,1.8) 20(-2.553,-1.8) 31(2.553,-1.8) 40(2.553,1.8)
  rect 0.965x0.203 smd: 12(-2.527,1.4) 13(-2.527,1) 14(-2.527,0.6) 15(-2.527,0.2) 16(-2.527,-0.2) 17(-2.527,-0.6) 18(-2.527,-1) 19(-2.527,-1.4) 32(2.527,-1.4) 33(2.527,-1) 34(2.527,-0.6) 35(2.527,-0.2) 36(2.527,0.2) 37(2.527,0.6) 38(2.527,1) 39(2.527,1.4)
  rect 3.505x3.505 smd: 41(0,0)
QFN48J6-G4D55H40
  rect 0.203x1.016 smd: 1(2.2,3) 2(1.8,3) 3(1.4,3) 4(1,3) 5(0.6,3) 6(0.2,3) 7(-0.2,3) 8(-0.6,3) 9(-1,3) 10(-1.4,3) 11(-1.8,3) 12(-2.2,3) 25(-2.2,-3) 26(-1.8,-3) 27(-1.4,-3) 28(-1,-3) 29(-0.6,-3) 30(-0.2,-3) 31(0.2,-3) 32(0.6,-3) 33(1,-3) 34(1.4,-3) 35(1.8,-3) 36(2.2,-3)
  rect 1.016x0.203 smd: 13(-3,2.2) 14(-3,1.8) 15(-3,1.4) 16(-3,1) 17(-3,0.6) 18(-3,0.2) 19(-3,-0.2) 20(-3,-0.6) 21(-3,-1) 22(-3,-1.4) 23(-3,-1.8) 24(-3,-2.2) 37(3,-2.2) 38(3,-1.8) 39(3,-1.4) 40(3,-1) 41(3,-0.6) 42(3,-0.2) 43(3,0.2) 44(3,0.6) 45(3,1) 46(3,1.4) 47(3,1.8) 48(3,2.2)
  rect 4.547x4.547 smd: 49(0,0)
QFN48J6-G465H40
  rect 0.203x0.965 smd: 1(2.2,3.025) 2(1.8,3.025) 3(1.4,3.025) 4(1,3.025) 5(0.6,3.025) 6(0.2,3.025) 7(-0.2,3.025) 8(-0.6,3.025) 9(-1,3.025) 10(-1.4,3.025) 11(-1.8,3.025) 12(-2.2,3.025) 25(-2.2,-3.025) 26(-1.8,-3.025) 27(-1.4,-3.025) 28(-1,-3.025) 29(-0.6,-3.025) 30(-0.2,-3.025) 31(0.2,-3.025) 32(0.6,-3.025) 33(1,-3.025) 34(1.4,-3.025) 35(1.8,-3.025) 36(2.2,-3.025)
  rect 0.965x0.203 smd: 13(-3.025,2.2) 14(-3.025,1.8) 15(-3.025,1.4) 16(-3.025,1) 17(-3.025,0.6) 18(-3.025,0.2) 19(-3.025,-0.2) 20(-3.025,-0.6) 21(-3.025,-1) 22(-3.025,-1.4) 23(-3.025,-1.8) 24(-3.025,-2.2) 37(3.025,-2.2) 38(3.025,-1.8) 39(3.025,-1.4) 40(3.025,-1) 41(3.025,-0.6) 42(3.025,-0.2) 43(3.025,0.2) 44(3.025,0.6) 45(3.025,1) 46(3.025,1.4) 47(3.025,1.8) 48(3.025,2.2)
  rect 4.648x4.648 smd: 49(0,0)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H15
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.216x0.216 smd: 1(0,0.762) 2(0,-0.762)
R805H24
  rect 1.397x1.143 smd: 1(0,0.965) 2(0,-0.965)
R1206H28
  rect 1.651x1.27 smd: 1(0,1.397) 2(0,-1.397)
R2512H32
  rect 3.505x1.778 smd: 1(0,2.794) 2(0,-2.794)
RT-D6-4D5-1010H375
  round 2.489 hole 1.727: 1(3,2.25) 2(-3,-2.25)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SC70-6H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SE331721H237
  rect 1.422x3.556 smd: 1(0,2.574) 2(0,-2.574)
SE361416H237
  rect 1.422x3.556 smd: 1(0,2.574) 2(0,-2.574)
SKT-HDMI22-152071
  rect 0.305x2.007 smd: 1(4.21,3.37) 2(3.71,3.37) 3(3.21,3.37) 4(2.71,3.37) 5(2.21,3.37) 6(1.71,3.37) 7(1.21,3.37) 8(0.71,3.37) 9(0.21,3.37) 10(-0.29,3.37) 11(-0.79,3.37) 12(-1.29,3.37) 13(-1.79,3.37) 14(-2.29,3.37) 15(-2.79,3.37) 16(-3.29,3.37) 17(-3.79,3.37) 18(-4.29,3.37) 19(-4.79,3.37)
  oval 4.521x1.524 hole 3.81x0.813: 20(0,-2.53)
  oval 1.321x4.47 hole 0.61x3.759: 21(-7.25,0) 22(7.25,0)
SKT-USB6-146072
  round 1.346 hole 0.94: 1(-3.5,2.71) 2(-1,2.71) 3(1,2.71) 4(3.5,2.71)
  round 2.718 hole 2.311: 5(-6.57,0) 6(6.57,0)
SKT-USB11-145165
  round 1.067 hole 0.711: 1(3.5,3.5) 2(1,3.5) 3(-1,3.5) 4(-3.5,3.5) 5(-4,2) 6(-2,2) 7(0,2) 8(2,2) 9(4,2)
  oval 1.524x3.023 hole 0.813x2.311: 10(6.4,0) 11(-6.4,0)
SKTBGA1150R740611UH367NF
  round 0.254 hole 3.81 unplated: (-35.21,0) (25.81,18) (25.81,-18)
  round 0.508 smd: A4(-16.187,18.288) AU1(-18.931,-14.63) AU39(18.016,-15.545) AU40(18.931,-15.545) AV1(-18.931,-15.545) AV2(-18.016,-15.545) AV38(17.102,-16.459) AV39(18.016,-16.459) AW2(-18.016,-16.459) AW3(-17.102,-16.459) AW37(16.187,-17.374) AW38(17.102,-17.374) AY3(-17.102,-17.374) B3(-17.102,17.374) B4(-16.187,17.374) B37(16.187,16.459) B38(17.102,16.459) B39(18.016,16.459) C2(-18.016,16.459) C3(-17.102,16.459) C39(18.016,15.545) C40(18.931,15.545) D1(-18.931,15.545) D2(-18.016,15.545) D39(18.016,14.63) D40(18.931,14.63)
  oval 0.356x0.457 smd: A5(-15.273,18.288) A6(-14.359,18.288) A7(-13.444,18.288) A11(-9.787,18.288) A12(-8.872,18.288) A13(-7.958,18.288) A14(-7.043,18.288) A15(-6.129,18.288) A16(-5.215,18.288) A17(-4.3,18.288) A18(-3.386,18.288) AU18(-1.186,-15.545) AU19(-0.272,-15.545) AU20(0.643,-15.545) AU21(1.557,-15.545) AU22(2.471,-15.545) AU23(3.386,-15.545) AV16(-3.015,-16.459) AV17(-2.101,-16.459) AV18(-1.186,-16.459) AV19(-0.272,-16.459) AV20(0.643,-16.459) AV21(1.557,-16.459) AV22(2.471,-16.459) AV23(3.386,-16.459) AV24(4.3,-16.459) AV25(5.215,-16.459) AV26(6.129,-16.459) AV27(7.043,-16.459) AV28(7.958,-16.459) AV29(8.872,-16.459) AV30(9.787,-16.459) AV31(10.701,-16.459) AV32(11.615,-16.459) AV33(12.53,-16.459) AV34(13.444,-16.459) AV35(14.359,-16.459) AV36(15.273,-16.459) AW4(-16.187,-16.459) AW5(-15.273,-16.459) AW6(-14.359,-16.459) AW7(-13.444,-16.459) AW8(-12.53,-16.459) AW9(-11.615,-16.459) AW10(-10.701,-16.459) AW11(-7.587,-17.374) AW12(-6.673,-17.374) AW13(-5.758,-17.374) AW14(-4.844,-17.374) AW15(-3.929,-17.374) AW16(-3.015,-17.374) AW17(-2.101,-17.374) AW18(-1.186,-17.374) AW23(3.386,-17.374) AW24(4.3,-17.374) AW25(5.215,-17.374) AW26(6.129,-17.374) AW27(7.043,-17.374) AW28(7.958,-17.374) AW29(8.872,-17.374) AW30(9.787,-17.374) AW31(10.701,-17.374) AW32(11.615,-17.374) AW33(12.53,-17.374) AW34(13.444,-17.374) AW35(14.359,-17.374) AW36(15.273,-17.374) AY4(-16.187,-17.374) AY5(-15.273,-17.374) AY6(-14.359,-17.374) AY7(-13.444,-17.374) AY8(-12.53,-17.374) AY9(-11.615,-17.374) AY10(-10.701,-17.374) AY11(-7.587,-18.288) AY12(-6.673,-18.288) AY13(-5.758,-18.288) AY14(-4.844,-18.288) AY15(-3.929,-18.288) AY16(-3.015,-18.288) AY17(-2.101,-18.288) AY18(-1.186,-18.288) AY23(3.386,-18.288) AY24(4.3,-18.288) AY25(5.215,-18.288) AY26(6.129,-18.288) AY27(7.043,-18.288) AY28(7.958,-18.288) AY29(8.872,-18.288) AY30(9.787,-18.288) B5(-15.273,17.374) B6(-14.359,17.374) B7(-13.444,17.374) B8(-12.53,17.374) B9(-11.615,17.374) B10(-10.701,17.374) B11(-9.787,17.374) B12(-8.872,17.374) B13(-7.958,17.374) B14(-7.043,17.374) B15(-6.129,17.374) B16(-5.215,17.374) B17(-4.3,17.374) B18(-3.386,17.374) C8(-12.53,16.459) C9(-11.615,16.459) C10(-10.701,16.459) C11(-9.787,16.459) C19(-2.471,16.459) C20(-1.557,16.459) C21(-0.643,16.459) C22(0.272,16.459) D8(-12.53,15.545) D9(-11.615,15.545) D10(-10.701,15.545) D11(-9.787,15.545) D20(-1.557,15.545) D21(-0.643,15.545)
  round 0.429 smd: A23(1.186,18.288) A24(2.101,18.288) A25(3.015,18.288) A26(3.929,18.288) A27(4.844,18.288) A28(5.758,18.288) A29(6.673,18.288) A30(7.587,18.288) AA5(-15.273,0) AA6(-14.359,0) AA7(-13.444,0) AA33(12.53,-0.914) AA34(13.444,-0.914) AA35(14.359,-0.914) AA36(15.273,-0.914) AB5(-15.273,-0.914) AB6(-14.359,-0.914) AB7(-13.444,-0.914) AB33(12.53,-1.829) AB34(13.444,-1.829) AB35(14.359,-1.829) AB36(15.273,-1.829) AB39(18.016,-1.829) AB40(18.931,-1.829) AC5(-15.273,-1.829) AC6(-14.359,-1.829) AC7(-13.444,-1.829) AC33(12.53,-2.743) AC34(13.444,-2.743) AC35(14.359,-2.743) AC36(15.273,-2.743) AC37(16.187,-2.743) AC38(17.102,-2.743) AD3(-17.102,-2.743) AD4(-16.187,-2.743) AD5(-15.273,-2.743) AD6(-14.359,-2.743) AD7(-13.444,-2.743) AD33(12.53,-3.658) AD34(13.444,-3.658) AD35(14.359,-3.658) AD36(15.273,-3.658) AD37(16.187,-3.658) AD38(17.102,-3.658) AE3(-17.102,-3.658) AE4(-16.187,-3.658) AE5(-15.273,-3.658) AE6(-14.359,-3.658) AE7(-13.444,-3.658) AE33(12.53,-4.572) AE34(13.444,-4.572) AE35(14.359,-4.572) AE36(15.273,-4.572) AE37(16.187,-4.572) AE38(17.102,-4.572) AF3(-17.102,-4.572) AF4(-16.187,-4.572) AF5(-15.273,-4.572) AF6(-14.359,-4.572) AF7(-13.444,-4.572) AF33(12.53,-5.486) AF34(13.444,-5.486) AF35(14.359,-5.486) AF36(15.273,-5.486) AF37(16.187,-5.486) AF38(17.102,-5.486) AG3(-17.102,-5.486) AG4(-16.187,-5.486) AG5(-15.273,-5.486) AG6(-14.359,-5.486) AG7(-13.444,-5.486) AG8(-12.53,-5.486) AG33(12.53,-6.401) AG34(13.444,-6.401) AG35(14.359,-6.401) AG36(15.273,-6.401) AG37(16.187,-6.401) AG38(17.102,-6.401) AH3(-17.102,-6.401) AH4(-16.187,-6.401) AH5(-15.273,-6.401) AH6(-14.359,-6.401) AH7(-13.444,-6.401) AH8(-12.53,-6.401) AH33(12.53,-7.315) AH34(13.444,-7.315) AH35(14.359,-7.315) AH36(15.273,-7.315) AH37(16.187,-7.315) AH38(17.102,-7.315) AJ3(-17.102,-7.315) AJ4(-16.187,-7.315) AJ5(-15.273,-7.315) AJ6(-14.359,-7.315) AJ7(-13.444,-7.315) AJ8(-12.53,-7.315) AJ9(-11.615,-7.315) AJ11(-7.587,-8.23) AJ12(-6.673,-8.23) AJ13(-5.758,-8.23) AJ14(-4.844,-8.23) AJ15(-3.929,-8.23) AJ16(-3.015,-8.23) AJ17(-2.101,-8.23) AJ18(-1.186,-8.23) AJ19(-0.272,-8.23) AJ20(0.643,-8.23) AJ21(1.557,-8.23) AJ22(2.471,-8.23) AJ23(3.386,-8.23) AJ24(4.3,-8.23) AJ25(5.215,-8.23) AJ26(6.129,-8.23) AJ27(7.043,-8.23) AJ28(7.958,-8.23) AJ29(8.872,-8.23) AJ30(9.787,-8.23) AJ31(10.701,-8.23) AJ32(11.615,-8.23) AJ33(12.53,-8.23) AJ34(13.444,-8.23) AJ35(14.359,-8.23) AJ36(15.273,-8.23) AJ37(16.187,-8.23) AJ38(17.102,-8.23) AK3(-17.102,-8.23) AK4(-16.187,-8.23) AK5(-15.273,-8.23) AK6(-14.359,-8.23) AK7(-13.444,-8.23) AK8(-12.53,-8.23) AK9(-11.615,-8.23) AK10(-10.701,-8.23) AK11(-7.587,-9.144) AK12(-6.673,-9.144) AK13(-5.758,-9.144) AK14(-4.844,-9.144) AK15(-3.929,-9.144) AK16(-3.015,-9.144) AK17(-2.101,-9.144) AK18(-1.186,-9.144) AK19(-0.272,-9.144) AK20(0.643,-9.144) AK21(1.557,-9.144) AK22(2.471,-9.144) AK23(3.386,-9.144) AK24(4.3,-9.144) AK25(5.215,-9.144) AK26(6.129,-9.144) AK27(7.043,-9.144) AK28(7.958,-9.144) AK29(8.872,-9.144) AK30(9.787,-9.144) AK31(10.701,-9.144) AK32(11.615,-9.144) AK33(12.53,-9.144) AK34(13.444,-9.144) AK35(14.359,-9.144) AK36(15.273,-9.144) AK37(16.187,-9.144) AK38(17.102,-9.144) AL3(-17.102,-9.144) AL4(-16.187,-9.144) AL5(-15.273,-9.144) AL6(-14.359,-9.144) AL7(-13.444,-9.144) AL8(-12.53,-9.144) AL9(-11.615,-9.144) AL10(-10.701,-9.144) AL11(-7.587,-10.058) AL12(-6.673,-10.058) AL13(-5.758,-10.058) AL14(-4.844,-10.058) AL15(-3.929,-10.058) AL16(-3.015,-10.058) AL17(-2.101,-10.058) AL18(-1.186,-10.058) AL19(-0.272,-10.058) AL20(0.643,-10.058) AL21(1.557,-10.058) AL22(2.471,-10.058) AL23(3.386,-10.058) AL24(4.3,-10.058) AL25(5.215,-10.058) AL26(6.129,-10.058) AL27(7.043,-10.058) AL28(7.958,-10.058) AL29(8.872,-10.058) AL30(9.787,-10.058) AL31(10.701,-10.058) AL32(11.615,-10.058) AL33(12.53,-10.058) AL34(13.444,-10.058) AL35(14.359,-10.058) AL36(15.273,-10.058) AL37(16.187,-10.058) AL38(17.102,-10.058) AM3(-17.102,-10.058) AM4(-16.187,-10.058) AM5(-15.273,-10.058) AM6(-14.359,-10.058) AM7(-13.444,-10.058) AM8(-12.53,-10.058) AM9(-11.615,-10.058) AM10(-10.701,-10.058) AM11(-7.587,-10.973) AM12(-6.673,-10.973) AM13(-5.758,-10.973) AM14(-4.844,-10.973) AM15(-3.929,-10.973) AM16(-3.015,-10.973) AM17(-2.101,-10.973) AM18(-1.186,-10.973) AM19(-0.272,-10.973) AM20(0.643,-10.973) AM21(1.557,-10.973) AM22(2.471,-10.973) AM23(3.386,-10.973) AM24(4.3,-10.973) AM25(5.215,-10.973) AM26(6.129,-10.973) AM27(7.043,-10.973) AM28(7.958,-10.973) AM29(8.872,-10.973) AM30(9.787,-10.973) AM31(10.701,-10.973) AM32(11.615,-10.973) AM33(12.53,-10.973) AM34(13.444,-10.973) AM35(14.359,-10.973) AM36(15.273,-10.973) AM37(16.187,-10.973) AM38(17.102,-10.973) AN3(-17.102,-10.973) AN4(-16.187,-10.973) AN5(-15.273,-10.973) AN6(-14.359,-10.973) AN7(-13.444,-10.973) AN8(-12.53,-10.973) AN9(-11.615,-10.973) AN10(-10.701,-10.973) AN11(-7.587,-11.887) AN12(-6.673,-11.887) AN13(-5.758,-11.887) AN14(-4.844,-11.887) AN15(-3.929,-11.887) AN16(-3.015,-11.887) AN17(-2.101,-11.887) AN18(-1.186,-11.887) AN19(-0.272,-11.887) AN20(0.643,-11.887) AN21(1.557,-11.887) AN22(2.471,-11.887) AN23(3.386,-11.887) AN24(4.3,-11.887) AN25(5.215,-11.887) AN26(6.129,-11.887) AN27(7.043,-11.887) AN28(7.958,-11.887) AN29(8.872,-11.887) AN30(9.787,-11.887) AN31(10.701,-11.887) AN32(11.615,-11.887) AN33(12.53,-11.887) AN34(13.444,-11.887) AN35(14.359,-11.887) AN36(15.273,-11.887) AN37(16.187,-11.887) AN38(17.102,-11.887) AP3(-17.102,-11.887) AP4(-16.187,-11.887) AP5(-15.273,-11.887) AP6(-14.359,-11.887) AP7(-13.444,-11.887) AP8(-12.53,-11.887) AP9(-11.615,-11.887) AP10(-10.701,-11.887) AP11(-7.587,-12.802) AP12(-6.673,-12.802) AP13(-5.758,-12.802) AP14(-4.844,-12.802) AP15(-3.929,-12.802) AP16(-3.015,-12.802) AP17(-2.101,-12.802) AP18(-1.186,-12.802) AP19(-0.272,-12.802) AP20(0.643,-12.802) AP21(1.557,-12.802) AP22(2.471,-12.802) AP23(3.386,-12.802) AP24(4.3,-12.802) AP25(5.215,-12.802) AP26(6.129,-12.802) AP27(7.043,-12.802) AP28(7.958,-12.802) AP29(8.872,-12.802) AP30(9.787,-12.802) AP31(10.701,-12.802) AP32(11.615,-12.802) AP33(12.53,-12.802) AP34(13.444,-12.802) AP35(14.359,-12.802) AP36(15.273,-12.802) AP37(16.187,-12.802) AP38(17.102,-12.802) AR3(-17.102,-12.802) AR4(-16.187,-12.802) AR5(-15.273,-12.802) AR6(-14.359,-12.802) AR7(-13.444,-12.802) AR8(-12.53,-12.802) AR9(-11.615,-12.802) AR10(-10.701,-12.802) AR11(-7.587,-13.716) AR12(-6.673,-13.716) AR13(-5.758,-13.716) AR14(-4.844,-13.716) AR15(-3.929,-13.716) AR16(-3.015,-13.716) AR17(-2.101,-13.716) AR18(-1.186,-13.716) AR19(-0.272,-13.716) AR20(0.643,-13.716) AR21(1.557,-13.716) AR22(2.471,-13.716) AR23(3.386,-13.716) AR24(4.3,-13.716) AR25(5.215,-13.716) AR26(6.129,-13.716) AR27(7.043,-13.716) AR28(7.958,-13.716) AR29(8.872,-13.716) AR30(9.787,-13.716) AR31(10.701,-13.716) AR32(11.615,-13.716) AR33(12.53,-13.716) AR34(13.444,-13.716) AR35(14.359,-13.716) AR36(15.273,-13.716) AR37(16.187,-13.716) AR38(17.102,-13.716) AT3(-17.102,-13.716) AT4(-16.187,-13.716) AT5(-15.273,-13.716) AT6(-14.359,-13.716) AT7(-13.444,-13.716) AT8(-12.53,-13.716) AT9(-11.615,-13.716) AT10(-10.701,-13.716) AT11(-7.587,-14.63) AT12(-6.673,-14.63) AT13(-5.758,-14.63) AT14(-4.844,-14.63) AT15(-3.929,-14.63) AT16(-3.015,-14.63) AT17(-2.101,-14.63) AT18(-1.186,-14.63) AT19(-0.272,-14.63) AT20(0.643,-14.63) AT21(1.557,-14.63) AT22(2.471,-14.63) AT23(3.386,-14.63) AT24(4.3,-14.63) AT25(5.215,-14.63) AT26(6.129,-14.63) AT27(7.043,-14.63) AT28(7.958,-14.63) AT29(8.872,-14.63) AT30(9.787,-14.63) AT31(10.701,-14.63) AT32(11.615,-14.63) AT33(12.53,-14.63) AT34(13.444,-14.63) AT35(14.359,-14.63) AT36(15.273,-14.63) AT37(16.187,-14.63) AT38(17.102,-14.63) AU3(-17.102,-14.63) AU4(-16.187,-14.63) AU5(-15.273,-14.63) AU6(-14.359,-14.63) AU7(-13.444,-14.63) AU8(-12.53,-14.63) AU9(-11.615,-14.63) AU10(-10.701,-14.63) AU11(-7.587,-15.545) AU12(-6.673,-15.545) AU13(-5.758,-15.545) AU14(-4.844,-15.545) AU15(-3.929,-15.545) AU16(-3.015,-15.545) AU17(-2.101,-15.545) AU24(4.3,-15.545) AU25(5.215,-15.545) AU26(6.129,-15.545) AU27(7.043,-15.545) AU28(7.958,-15.545) AU29(8.872,-15.545) AU30(9.787,-15.545) AU31(10.701,-15.545) AU32(11.615,-15.545) AU33(12.53,-15.545) AU34(13.444,-15.545) AU35(14.359,-15.545) AU36(15.273,-15.545) AU37(16.187,-15.545) AU38(17.102,-15.545) AV3(-17.102,-15.545) AV4(-16.187,-15.545) AV5(-15.273,-15.545) AV6(-14.359,-15.545) AV7(-13.444,-15.545) AV8(-12.53,-15.545) AV9(-11.615,-15.545) AV10(-10.701,-15.545) AV11(-7.587,-16.459) AV12(-6.673,-16.459) AV13(-5.758,-16.459) AV14(-4.844,-16.459) AV15(-3.929,-16.459) AV37(16.187,-16.459) B23(1.186,17.374) B24(2.101,17.374) B25(3.015,17.374) B26(3.929,17.374) B27(4.844,17.374) B28(5.758,17.374) B29(6.673,17.374) B30(7.587,17.374) B31(10.701,16.459) B32(11.615,16.459) B33(12.53,16.459) B34(13.444,16.459) B35(14.359,16.459) B36(15.273,16.459) C4(-16.187,16.459) C5(-15.273,16.459) C6(-14.359,16.459) C7(-13.444,16.459) C12(-8.872,16.459) C13(-7.958,16.459) C14(-7.043,16.459) C15(-6.129,16.459) C16(-5.215,16.459) C17(-4.3,16.459) C18(-3.386,16.459) C23(1.186,16.459) C24(2.101,16.459) C25(3.015,16.459) C26(3.929,16.459) C27(4.844,16.459) C28(5.758,16.459) C29(6.673,16.459) C30(7.587,16.459) C31(10.701,15.545) C32(11.615,15.545) C33(12.53,15.545) C34(13.444,15.545) C35(14.359,15.545) C36(15.273,15.545) C37(16.187,15.545) C38(17.102,15.545) D3(-17.102,15.545) D4(-16.187,15.545) D5(-15.273,15.545) D6(-14.359,15.545) D7(-13.444,15.545) D12(-8.872,15.545) D13(-7.958,15.545) D14(-7.043,15.545) D15(-6.129,15.545) D16(-5.215,15.545) D17(-4.3,15.545) D18(-3.386,15.545) D19(-2.471,15.545) D22(0.272,15.545) D23(1.186,15.545) D24(2.101,15.545) D25(3.015,15.545) D26(3.929,15.545) D27(4.844,15.545) D28(5.758,15.545) D29(6.673,15.545) D30(7.587,15.545) D31(10.701,14.63) D32(11.615,14.63) D33(12.53,14.63) D34(13.444,14.63) D35(14.359,14.63) D36(15.273,14.63) D37(16.187,14.63) D38(17.102,14.63) E4(-16.187,14.63) E5(-15.273,14.63) E6(-14.359,14.63) E7(-13.444,14.63) E8(-12.53,14.63) E9(-11.615,14.63) E10(-10.701,14.63) E11(-9.787,14.63) E12(-8.872,14.63) E13(-7.958,14.63) E14(-7.043,14.63) E15(-6.129,14.63) E16(-5.215,14.63) E17(-4.3,14.63) E18(-3.386,14.63) E19(-2.471,14.63) E20(-1.557,14.63) E21(-0.643,14.63) E22(0.272,14.63) E23(1.186,14.63) E24(2.101,14.63) E25(3.015,14.63) E26(3.929,14.63) E27(4.844,14.63) E28(5.758,14.63) E29(6.673,14.63) E30(7.587,14.63) E31(10.701,13.716) E32(11.615,13.716) E33(12.53,13.716) E34(13.444,13.716) E35(14.359,13.716) E36(15.273,13.716) E37(16.187,13.716) E38(17.102,13.716) F4(-16.187,13.716) F5(-15.273,13.716) F6(-14.359,13.716) F7(-13.444,13.716) F8(-12.53,13.716) F9(-11.615,13.716) F10(-10.701,13.716) F11(-9.787,13.716) F12(-8.872,13.716) F13(-7.958,13.716) F14(-7.043,13.716) F15(-6.129,13.716) F16(-5.215,13.716) F17(-4.3,13.716) F18(-3.386,13.716) F19(-2.471,13.716) F20(-1.557,13.716) F21(-0.643,13.716) F22(0.272,13.716) F23(1.186,13.716) F24(2.101,13.716) F25(3.015,13.716) F26(3.929,13.716) F27(4.844,13.716) F28(5.758,13.716) F29(6.673,13.716) F30(7.587,13.716) F31(10.701,12.802) F32(11.615,12.802) F33(12.53,12.802) F34(13.444,12.802) F35(14.359,12.802) F36(15.273,12.802) F37(16.187,12.802) F38(17.102,12.802) F39(18.016,12.802) G4(-16.187,12.802) G5(-15.273,12.802) G6(-14.359,12.802) G7(-13.444,12.802) G8(-12.53,12.802) G9(-11.615,12.802) G10(-10.701,12.802) G11(-9.787,12.802) G12(-8.872,12.802) G13(-7.958,12.802) G14(-7.043,12.802) G15(-6.129,12.802) G16(-5.215,12.802) G17(-4.3,12.802) G18(-3.386,12.802) G19(-2.471,12.802) G20(-1.557,12.802) G21(-0.643,12.802) G22(0.272,12.802) G23(1.186,12.802) G24(2.101,12.802) G25(3.015,12.802) G26(3.929,12.802) G27(4.844,12.802) G28(5.758,12.802) G29(6.673,12.802) G30(7.587,12.802) G31(10.701,11.887) G32(11.615,11.887) G33(12.53,11.887) G34(13.444,11.887) G35(14.359,11.887) G36(15.273,11.887) G37(16.187,11.887) G38(17.102,11.887) G39(18.016,11.887) G40(18.931,11.887) H4(-16.187,11.887) H5(-15.273,11.887) H6(-14.359,11.887) H7(-13.444,11.887) H8(-12.53,11.887) H9(-11.615,11.887) H10(-10.701,11.887) H11(-9.787,11.887) H12(-8.872,11.887) H13(-7.958,11.887) H14(-7.043,11.887) H15(-6.129,11.887) H16(-5.215,11.887) H17(-4.3,11.887) H18(-3.386,11.887) H19(-2.471,11.887) H20(-1.557,11.887) H21(-0.643,11.887) H22(0.272,11.887) H23(1.186,11.887) H24(2.101,11.887) H25(3.015,11.887) H26(3.929,11.887) H27(4.844,11.887) H28(5.758,11.887) H29(6.673,11.887) H30(7.587,11.887) H31(10.701,10.973) H32(11.615,10.973) H33(12.53,10.973) H34(13.444,10.973) H35(14.359,10.973) H36(15.273,10.973) H37(16.187,10.973) H38(17.102,10.973) H39(18.016,10.973) H40(18.931,10.973) J4(-16.187,10.973) J5(-15.273,10.973) J6(-14.359,10.973) J7(-13.444,10.973) J8(-12.53,10.973) J9(-11.615,10.973) J10(-10.701,10.973) J11(-9.787,10.973) J12(-8.872,10.973) J13(-7.958,10.973) J14(-7.043,10.973) J15(-6.129,10.973) J16(-5.215,10.973) J17(-4.3,10.973) J18(-3.386,10.973) J19(-2.471,10.973) J20(-1.557,10.973) J21(-0.643,10.973) J22(0.272,10.973) J23(1.186,10.973) J24(2.101,10.973) J25(3.015,10.973) J26(3.929,10.973) J27(4.844,10.973) J28(5.758,10.973) J29(6.673,10.973) J30(7.587,10.973) J31(10.701,10.058) J32(11.615,10.058) J33(12.53,10.058) J34(13.444,10.058) J35(14.359,10.058) J36(15.273,10.058) J37(16.187,10.058) J38(17.102,10.058) J39(18.016,10.058) J40(18.931,10.058) K4(-16.187,10.058) K5(-15.273,10.058) K6(-14.359,10.058) K7(-13.444,10.058) K8(-12.53,10.058) K9(-11.615,10.058) K10(-10.701,10.058) K11(-9.787,10.058) K12(-8.872,10.058) K13(-7.958,10.058) K14(-7.043,10.058) K15(-6.129,10.058) K16(-5.215,10.058) K17(-4.3,10.058) K18(-3.386,10.058) K19(-2.471,10.058) K20(-1.557,10.058) K21(-0.643,10.058) K22(0.272,10.058) K23(1.186,10.058) K24(2.101,10.058) K25(3.015,10.058) K26(3.929,10.058) K27(4.844,10.058) K28(5.758,10.058) K29(6.673,10.058) K30(7.587,10.058) K31(10.701,9.144) K32(11.615,9.144) K33(12.53,9.144) K34(13.444,9.144) K35(14.359,9.144) K36(15.273,9.144) K37(16.187,9.144) K38(17.102,9.144) K39(18.016,9.144) L4(-16.187,9.144) L5(-15.273,9.144) L6(-14.359,9.144) L7(-13.444,9.144) L8(-12.53,9.144) L9(-11.615,9.144) L10(-10.701,9.144) L11(-9.787,9.144) L12(-8.872,9.144) L13(-7.958,9.144) L14(-7.043,9.144) L15(-6.129,9.144) L16(-5.215,9.144) L17(-4.3,9.144) L18(-3.386,9.144) L19(-2.471,9.144) L20(-1.557,9.144) L21(-0.643,9.144) L22(0.272,9.144) L23(1.186,9.144) L24(2.101,9.144) L25(3.015,9.144) L26(3.929,9.144) L27(4.844,9.144) L28(5.758,9.144) L29(6.673,9.144) L30(7.587,9.144) L31(10.701,8.23) L32(11.615,8.23) L33(12.53,8.23) L34(13.444,8.23) L35(14.359,8.23) L36(15.273,8.23) L37(16.187,8.23) L38(17.102,8.23) L39(18.016,8.23) M4(-16.187,8.23) M5(-15.273,8.23) M6(-14.359,8.23) M7(-13.444,8.23) M8(-12.53,8.23) M9(-11.615,8.23) M10(-10.701,8.23) M11(-9.787,8.23) M12(-8.872,8.23) M13(-7.958,8.23) M14(-7.043,8.23) M15(-6.129,8.23) M16(-5.215,8.23) M17(-4.3,8.23) M18(-3.386,8.23) M19(-2.471,8.23) M20(-1.557,8.23) M21(-0.643,8.23) M22(0.272,8.23) M23(1.186,8.23) M24(2.101,8.23) M25(3.015,8.23) M26(3.929,8.23) M27(4.844,8.23) M28(5.758,8.23) M29(6.673,8.23) M30(7.587,8.23) M32(11.615,7.315) M33(12.53,7.315) M34(13.444,7.315) M35(14.359,7.315) M36(15.273,7.315) M37(16.187,7.315) M38(17.102,7.315) M39(18.016,7.315) N4(-16.187,7.315) N5(-15.273,7.315) N6(-14.359,7.315) N7(-13.444,7.315) N8(-12.53,7.315) N33(12.53,6.401) N34(13.444,6.401) N35(14.359,6.401) N36(15.273,6.401) N37(16.187,6.401) N38(17.102,6.401) N39(18.016,6.401) P4(-16.187,6.401) P5(-15.273,6.401) P6(-14.359,6.401) P7(-13.444,6.401) P8(-12.53,6.401) P33(12.53,5.486) P34(13.444,5.486) P35(14.359,5.486) P36(15.273,5.486) P37(16.187,5.486) P38(17.102,5.486) P39(18.016,5.486) R4(-16.187,5.486) R5(-15.273,5.486) R6(-14.359,5.486) R7(-13.444,5.486) R8(-12.53,5.486) R33(12.53,4.572) R34(13.444,4.572) R35(14.359,4.572) R36(15.273,4.572) R37(16.187,4.572) R38(17.102,4.572) R39(18.016,4.572) T4(-16.187,4.572) T5(-15.273,4.572) T6(-14.359,4.572) T7(-13.444,4.572) T8(-12.53,4.572) T33(12.53,3.658) T34(13.444,3.658) T35(14.359,3.658) T36(15.273,3.658) T37(16.187,3.658) T38(17.102,3.658) T39(18.016,3.658) U6(-14.359,3.658) U7(-13.444,3.658) U33(12.53,2.743) U34(13.444,2.743) U35(14.359,2.743) U36(15.273,2.743) U37(16.187,2.743) U38(17.102,2.743) V6(-14.359,2.743) V7(-13.444,2.743) V33(12.53,1.829) V34(13.444,1.829) V35(14.359,1.829) V36(15.273,1.829) V37(16.187,1.829) V38(17.102,1.829) W5(-15.273,1.829) W6(-14.359,1.829) W7(-13.444,1.829) W33(12.53,0.914) W34(13.444,0.914) W35(14.359,0.914) W36(15.273,0.914) W37(16.187,0.914) W38(17.102,0.914) Y5(-15.273,0.914) Y6(-14.359,0.914) Y7(-13.444,0.914) Y33(12.53,0) Y34(13.444,0) Y35(14.359,0) Y36(15.273,0) Y37(16.187,0)
  oval 0.457x0.356 smd: AA3(-17.102,0) AA4(-16.187,0) AA8(-12.53,0) AA37(16.187,-0.914) AA38(17.102,-0.914) AB3(-17.102,-0.914) AB4(-16.187,-0.914) AB8(-12.53,-0.914) AB37(16.187,-1.829) AB38(17.102,-1.829) AC1(-18.931,-1.829) AC2(-18.016,-1.829) AC3(-17.102,-1.829) AC4(-16.187,-1.829) AC8(-12.53,-1.829) AC39(18.016,-2.743) AC40(18.931,-2.743) AD1(-18.931,-2.743) AD2(-18.016,-2.743) AD8(-12.53,-2.743) AD39(18.016,-3.658) AD40(18.931,-3.658) AE1(-18.931,-3.658) AE2(-18.016,-3.658) AE8(-12.53,-3.658) AE39(18.016,-4.572) AE40(18.931,-4.572) AF1(-18.931,-4.572) AF2(-18.016,-4.572) AF8(-12.53,-4.572) AF39(18.016,-5.486) AF40(18.931,-5.486) AG1(-18.931,-5.486) AG2(-18.016,-5.486) AG39(18.016,-6.401) AG40(18.931,-6.401) AH1(-18.931,-6.401) AH2(-18.016,-6.401) AH39(18.016,-7.315) AH40(18.931,-7.315) AJ1(-18.931,-7.315) AJ2(-18.016,-7.315) AJ39(18.016,-8.23) AJ40(18.931,-8.23) AK1(-18.931,-8.23) AK2(-18.016,-8.23) AK39(18.016,-9.144) AK40(18.931,-9.144) AL1(-18.931,-9.144) AL2(-18.016,-9.144) AL39(18.016,-10.058) AL40(18.931,-10.058) AM1(-18.931,-10.058) AM2(-18.016,-10.058) AM39(18.016,-10.973) AM40(18.931,-10.973) AN1(-18.931,-10.973) AN2(-18.016,-10.973) AN39(18.016,-11.887) AN40(18.931,-11.887) AP1(-18.931,-11.887) AP2(-18.016,-11.887) AP39(18.016,-12.802) AP40(18.931,-12.802) AR1(-18.931,-12.802) AR2(-18.016,-12.802) AR39(18.016,-13.716) AR40(18.931,-13.716) AT1(-18.931,-13.716) AT2(-18.016,-13.716) AT39(18.016,-14.63) AT40(18.931,-14.63) AU2(-18.016,-14.63) E1(-18.931,14.63) E2(-18.016,14.63) E3(-17.102,14.63) E39(18.016,13.716) E40(18.931,13.716) F1(-18.931,13.716) F2(-18.016,13.716) F3(-17.102,13.716) F40(18.931,12.802) G1(-18.931,12.802) G2(-18.016,12.802) G3(-17.102,12.802) H1(-18.931,11.887) H2(-18.016,11.887) H3(-17.102,11.887) J1(-18.931,10.973) J2(-18.016,10.973) J3(-17.102,10.973) K1(-18.931,10.058) K2(-18.016,10.058) K3(-17.102,10.058) K40(18.931,9.144) L1(-18.931,9.144) L2(-18.016,9.144) L3(-17.102,9.144) L40(18.931,8.23) M1(-18.931,8.23) M2(-18.016,8.23) M3(-17.102,8.23) M40(18.931,7.315) N1(-18.931,7.315) N2(-18.016,7.315) N3(-17.102,7.315) N40(18.931,6.401) P1(-18.931,6.401) P2(-18.016,6.401) P3(-17.102,6.401) P40(18.931,5.486) R1(-18.931,5.486) R2(-18.016,5.486) R3(-17.102,5.486) R40(18.931,4.572) T1(-18.931,4.572) T2(-18.016,4.572) T3(-17.102,4.572) T40(18.931,3.658) U1(-18.931,3.658) U2(-18.016,3.658) U3(-17.102,3.658) U4(-16.187,3.658) U5(-15.273,3.658) U8(-12.53,3.658) U39(18.016,2.743) U40(18.931,2.743) V1(-18.931,2.743) V2(-18.016,2.743) V3(-17.102,2.743) V4(-16.187,2.743) V5(-15.273,2.743) V8(-12.53,2.743) V39(18.016,1.829) V40(18.931,1.829) W1(-18.931,1.829) W2(-18.016,1.829) W3(-17.102,1.829) W4(-16.187,1.829) W8(-12.53,1.829) Y3(-17.102,0.914) Y4(-16.187,0.914) Y8(-12.53,0.914) Y38(17.102,0)
SMD-OSC6H30
  rect 1.524x1.422 smd: 1(-1.048,-0.847) 2(1.048,-0.847) 3(1.048,0.847) 4(-1.048,0.847)
SMD-TO-252-DGS6698H99
  rect 6.172x5.588 smd: D(0,6.808)
  rect 1.295x2.438 smd: G(-2.35,0) S(2.35,0)
SOD80CH36
  rect 0.762x1.168 smd: 1(0,1.067) 2(0,-1.067)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD523AKH28
  rect 0.559x1.016 smd: A(0,0.762) K(0,-0.762)
SOD523AKH31
  rect 0.559x1.016 smd: A(0,0.762) K(0,-0.762)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8-G3530H63
  rect 0.635x1.651 smd: 1(-1.905,-2.555) 2(-0.635,-2.555) 3(0.635,-2.555) 4(1.905,-2.555) 5(1.905,2.555) 6(0.635,2.555) 7(-0.635,2.555) 8(-1.905,2.555)
  rect 3.505x2.997 smd: 9(0,0)
SOIC8H69
  rect 0.635x1.651 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SOT23-2D4-312H46
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D8H50
  custom 0.254x0.254 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT-6-1H50
  rect 0.584x1.219 smd: 1(-0.95,-1.194) 2(0,-1.194) 3(0.95,-1.194) 4(0.95,1.194) 5(0,1.194) 6(-0.95,1.194)
SOT-6H44
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-6H58
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-23-10H44
  rect 0.762x1.143 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SPR4330-UH71
  rect 3.988x2.692 smd: 1(-1.27,0)
STF256R109H99
  round 6.502 hole 2.769: 1(0,0)
STF256R109H276
  round 6.502 hole 2.769: 1(0,0)
STF256R109H398
  round 6.502 hole 2.769: 1(0,0)
TPAD28
  round 0.711 smd: 1(0,0)
TSOIC8H44
  rect 0.356x1.524 smd: 1(-0.975,-2.819) 2(-0.325,-2.819) 3(0.325,-2.819) 4(0.974,-2.819) 5(0.975,2.819) 6(0.325,2.819) 7(-0.325,2.819) 8(-0.975,2.819)
TSOIC28-3H44
  rect 0.356x1.524 smd: 1(-4.225,-3.669) 2(-3.575,-3.669) 3(-2.925,-3.669) 4(-2.275,-3.669) 5(-1.626,-3.669) 6(-0.975,-3.669) 7(-0.325,-3.669) 8(0.325,-3.669) 9(0.975,-3.669) 10(1.626,-3.669) 11(2.275,-3.669) 12(2.925,-3.669) 13(3.575,-3.669) 14(4.225,-3.669) 15(4.225,3.669) 16(3.575,3.669) 17(2.925,3.669) 18(2.275,3.669) 19(1.626,3.669) 20(0.975,3.669) 21(0.325,3.669) 22(-0.325,3.669) 23(-0.975,3.669) 24(-1.626,3.669) 25(-2.275,3.669) 26(-2.925,3.669) 27(-3.575,3.669) 28(-4.225,3.669)
TSOIC28H48
  rect 0.356x1.524 smd: 1(-4.225,-2.805) 2(-3.575,-2.805) 3(-2.925,-2.805) 4(-2.275,-2.805) 5(-1.626,-2.805) 6(-0.975,-2.805) 7(-0.325,-2.805) 8(0.325,-2.805) 9(0.975,-2.805) 10(1.626,-2.805) 11(2.275,-2.805) 12(2.925,-2.805) 13(3.575,-2.805) 14(4.225,-2.805) 15(4.225,2.805) 16(3.575,2.805) 17(2.925,2.805) 18(2.275,2.805) 19(1.626,2.805) 20(0.975,2.805) 21(0.325,2.805) 22(-0.325,2.805) 23(-0.975,2.805) 24(-1.626,2.805) 25(-2.275,2.805) 26(-2.925,2.805) 27(-3.575,2.805) 28(-4.225,2.805)
unnamed#2
  rect 1.27x1.27 smd: (0,0)

## Nets
3.3V_ALW_1: Q51.G Q54.5 Q54.6 R413.2
3.3V_RUN_VGA_1: Q54.3 R403.2
5V_PWR: PC54.1 PG2.1 PL3.2 PTC2.1 R514.2 R1088.2 R1093.2 R1100.2 R1108.2 R1113.2
5VDDCCL: C728.1 R1117.2 U44.4 VGA1.15
5VDDCDA: C723.1 R1114.2 U44.6 VGA1.12
5VSB: PC55.1 PR91.2
12V_DUAL: C85.1 C86.1 F10.1 L16.1 PL4.1 PL5.1 PL6.1 PL7.1 PR48.2 PR49.2 PR50.2 PR73.1 R109.1 R110.1 R190.2 R191.2 R325.1 R344.1 R702.1 R707.1 R710.2 R711.2 R712.2 R814.1 R815.1 R816.1 R843.1 R844.1 R853.1 R1151.2 R1152.2 R1212.2 R1213.2 R1214.2 R1215.2 R1216.2 R1217.2 R1218.2 R1219.2 U48.1 U48.2 U48.3
12V_DUAL_1D05V_S0: C155.1 C156.1 C159.1 Q41.5 Q41.6 Q41.7 Q41.8 R190.1 R191.1
12V_DUAL_DDR_VIN: C11.1 C12.1 C13.1 C18.1 Q10.5 Q10.6 Q10.7 Q10.8 R710.1 R711.1 R712.1 TC2.1
12V_DUAL_VGACORE: PC24.1 PC61.1 PC62.2 PC63.1 PC64.1 PR48.1 PR49.1 PR50.1 PR101.1 PT2.1 PU1.5 PU1.6 PU1.7 PU1.8 PU2.5 PU2.6 PU2.7 PU2.8
12V_FAN_MIX: F9.1 PR92.2 PR93.2 R798.1
12V_MONITOR: C84.1 R114.2 R119.1 R122.2 R127.2 R129.2 R832.2 R834.2 R836.2 R842.2 R1123.2 R1124.2 R1125.2 R1126.2 R1150.2 R1152.1 R1212.1 R1213.1 R1214.1 R1215.1 R1216.1 R1217.1 R1218.1 R1219.1 U6.5 U6.6 U6.7 U6.8 U40.5 U40.6 U40.7 U40.8
12V_PWR: C213.1 L14.2 R984.1 R1223.2 R1224.2 TC19.1
12V_PWR_SENSE: R410.1 R418.2 R420.1 R984.2
12V_S0: PR93.1 PR108.1 U48.5 U48.6 U48.7 U48.8
+1.5V_PWR: C44.1 L3.2 PC3.1 R100.2 R783.1 R784.1 R785.1 R786.1 R787.1 R788.1 R789.1 R790.1 TC5.1 TC7.1
+3V_VA: C544.1 C562.1 C570.1 C572.2 L33.2 U16.23 U16.25
+5V_VGA: C724.1 C725.1 L45.2 U43.5 VGA1.9
+19V_AMP_AVCC: C283.1 R538.2 U25.12
+19V_AMP_PVCC: C682.1 C684.1 C689.1 C690.1 L16.2 R538.1 U25.13 U25.14 U25.27 U25.28
AGND: C170.2 C179.2 C184.2 C187.1 C193.2 C194.1 C195.2 C201.2 C202.2 C204.2 C206.2 C210.2 C268.2 C269.2 C283.2 C355.2 C356.2 C525.2 C544.2 C562.2 C570.2 C572.1 LOUT1.5 LOUT1.P Q46.S R249.2 R262.2 R333.2 R337.2 R368.2 R499.1 R500.1 R506.1 R515.2 R902.2 R961.2 R1220.2 R1230.2 R1231.2 R1233.2 R1234.2 TC17.2 U16.22 U16.28 U16.42 U25.4 UHS1.5
AVCC33_2136: C35.1 C36.1 C43.1 L4.2 U37.5
DVCC33_2136: C22.1 C23.1 C24.1 C27.1 C30.1 L2.2 R724.1 R725.1 R762.1 R763.2 U37.18 U37.22
