# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DIMM_CA_VREF_B: length 135.9
  TOP w0.305: DIMM2.126 159.12,147.8 v4(159.38,148.07)
  L4 w0.254: v4(159.38,148.07) 159.38,148.22 160.77,149.6 160.77,184.83 154.56,191.04 151.23,191.04 145.75,196.53 113.21,196.53 108.08,201.65 92.09,201.65 89.72,199.28 87.16,199.28 84.33,202.11 v3(84.33,206.99)
  BOTTOM w0.254: R741.2 83.54,205.7 83.36,205.88 v2(83.36,206.33) 83.36,206.74 83.62,206.99 v3(84.33,206.99)
  BOTTOM w0.508: C468.1 159.19,147.18 R845.2 159.38,147.24 v4(159.38,148.07)
  BOTTOM w0.635: C834.1 159.35,148.1 v4(159.38,148.07)
DIMM_CA_VREF_B_L: length 3.2
  BOTTOM w0.635: v2(161.54,145.27) R846.2 R847.1 160.39,146.21 159.27,146.21 R845.1
DIMM_DQ_CPU_VREF_A: length 127.3
  TOP w0.254: v3(97.54,206.23) 97,206.77 86,206.77 85.69,206.46 84.11,206.46 82.88,207.69 79.48,207.69 78.68,206.88 C39.1 78.74,206.04 78.74,205.84 82.52,202.06 82.52,193.51 81.54,192.52 81.54,185.51 CPU1.AB39
  L4 w0.254: v3(97.54,206.23) 98.76,205.01 107.74,205.01 112.55,200.2 118.28,200.2 122.81,204.73 124.38,204.73 126.34,202.78 126.34,200.36 127.23,199.48 128.28,199.48 128.29,199.49 134.15,199.49 134.17,199.48 137.79,199.48 137.94,199.63 146.94,199.63 152.7,193.86 161.72,193.86 164.26,191.32 v3(165.3,191.32)
  BOTTOM w0.254: v3(97.54,206.23) v2(98.55,206.23) ; v3(165.3,191.32) 164.66,190.67 C417.1 164.78,189.59 R793.1
DIMM_DQ_CPU_VREF_A_1: length 2.2
  BOTTOM w0.254: R795.1 165.54,189.09 C417.2 165.54,190.32 v2(165.89,190.66)
DIMM_DQ_CPU_VREF_B: length 112.6
  TOP w0.254: v3(96.65,206.23) 96.32,205.9 83.88,205.9 83.66,206.12 81.53,206.12 C40.1 81.46,206.04 81.46,204.28 83.08,202.65 83.08,188.68 81.98,187.57 CPU1.AB40
  L4 w0.254: v3(159.84,190.38) 159.84,190.38 159.84,190.38 157.3,192.92 152.2,192.92 146.05,199.07 138.18,199.07 138.02,198.92 128.51,198.92 127.64,198.04 122.87,198.04 122.4,198.51 122.4,199.65 121.56,200.49 119.36,200.49 118.51,199.64 114.06,199.64 112.32,199.64 107.89,204.07 98.81,204.07 v3(96.65,206.23)
  BOTTOM w0.254: v3(96.65,206.23) v2(96.65,205.22)
  BOTTOM w0.508: C420.1 159.51,188.64 R792.1 159.32,189.86 v3(159.84,190.38)
DIMM_DQ_CPU_VREF_B_1: length 2.1
  BOTTOM w0.254: v2(160.53,185.78) R796.1 C420.2
DIMM_DQ_VREF_A: length 7.5
  TOP w0.254: v3(162.76,187.46) 163,187.7 DIMM1.1
  BOTTOM w0.254: C419.1 R793.2 163.07,188.71 v2(162.94,188.58) ; C419.1 163.82,187.61 162.92,187.61 v3(162.76,187.46) ; C419.1 163.89,187.19 163.45,186.75 R799.2 163.61,186.32 164.36,186.32 164.55,186.13 C831.1
DIMM_DQ_VREF_A_L: length 3.5
  BOTTOM w0.254: R803.2 162.43,184.32 R802.1 162.31,184.83 v2(162.31,185.59) R799.1
DIMM_DQ_VREF_B: length 11.9
  TOP w0.254: DIMM2.1 150.29,187.7 150.45,187.86 153.93,187.86 v3(155.23,189.15)
  BOTTOM w0.508: C418.1 157.54,188.83 R792.2 158.43,187.82 R797.2
  BOTTOM w0.635: v3(155.23,189.15) 155.76,189.68 v2(156.06,189.68) 156.25,189.68 156.59,189.34 C833.1 C418.1
DIMM_DQ_VREF_B_L: length 3.3
  BOTTOM w0.508: R801.2 158.5,185.72 R800.1 158.5,185.85 R797.1
  BOTTOM w0.635: R800.1 158.42,185.77 158.42,185.42 158.24,185.24 v2(158.24,184.77)
DIMM_TMPIN2+: length 6.4
  TOP w0.127: Q35.C 141.38,140.08 Q35.B 141.38,138.95 140.84,138.41 140.84,137.83 v1(140.97,137.7) C114.1 142.37,137.39 142.37,137.13 R153.2
DIMM_TMPIN2-: length 3.9
  TOP w0.127: R154.2 142.62,137.13 142.62,137.39 C114.2 143.81,137.7 v1(143.89,137.78) 144.02,137.91 144.02,138.5 Q35.E
DISP_UTIL_CPU: length 104.5
  TOP w0.102: CPU1.E16 65.49,161.84 v3(65.07,161.41)
  L4 w0.127: v3(122.58,214.84) 121.59,213.85 121.28,213.85 119.38,211.95 114.65,211.95 113.6,213 109.41,213 109.41,213 108.26,213 107.41,213.85 104.63,213.85 102.72,211.95 96.49,211.95 92.93,208.39 83.59,208.39 79.12,203.92 79.12,200.9 76.96,198.74 76.96,190.18 77.42,189.72 77.42,180.63 76.39,179.6 76.39,177.5 75.98,177.09 75.98,175.86 73.53,173.4 72.32,173.4 68.08,169.16 66.73,169.16 65.53,167.96 65.53,166.17 65.51,166.15 65.51,161.96 65.07,161.52 v3(65.07,161.41)
  BOTTOM w0.102: v3(122.58,214.84) 123.04,215.3 125.04,215.3 v2(125.35,214.99) 125.6,214.74 R714.2
DMI_IT_MR_DN0: length 115.3
  TOP w0.102: v4(121.41,74.91) 121.54,74.79 121.54,74.41 121.76,74.19 123.16,74.19 123.33,74.36 125.62,74.36 125.66,74.31 125.94,74.31 126.19,74.56 U29.C20 ; CPU1.T3 75.93,149.59 75.93,147.64 76.26,147.31 76.26,145.28 80.55,141 85.65,141 94.21,132.44 94.21,127.14 96.44,124.91 97.69,124.91 97.79,124.81 v3(97.79,124.34)
  BOTTOM w0.102: v4(121.41,74.91) 121.54,75.04 121.54,75.27 121.17,75.64 118.99,75.64 117.88,76.74 117.88,92.55 118.41,93.07 118.41,97.33 118.41,98.35 118.41,98.79 118.41,101.37 120.1,103.07 120.1,115.3 117.32,118.08 110.29,118.08 ; 110.29,118.08 v2(110.29,117.76) ; 110.29,118.08 103.52,118.08 97.92,123.68 97.92,124.21 v3(97.79,124.34)
DMI_IT_MR_DN1: length 112.5
  TOP w0.102: CPU1.V1 77.04,147.75 77.04,145.72 80.9,141.86 86.06,141.86 95.05,132.87 95.05,127.57 95.71,126.91 96.44,126.91 v3(96.65,127.11) ; v4(120.02,76.44) 119.82,76.25 119.82,75.87 120.09,75.6 125.51,75.6 125.68,75.42 126.36,75.42 126.67,75.11 U29.D21
  BOTTOM w0.102: 115.04,118.92 117.67,118.92 120.94,115.65 120.94,102.46 119.25,100.77 119.25,92.67 118.72,92.14 118.72,78.17 119.76,77.12 119.76,76.69 v4(120.02,76.44) ; 115.04,118.92 v2(115.04,119.21) ; 115.04,118.92 104.12,118.92 101.05,121.99 101.05,124.15 98.9,126.31 98.19,126.31 97.6,126.9 96.86,126.9 v3(96.65,127.11)
DMI_IT_MR_DN2: length 109.6
  TOP w0.102: v3(120.2,77.41) 120.76,76.85 120.76,76.27 121.15,75.89 125.67,75.89 U29.B22 ; v3(100.58,127.11) 100.24,127.45 97.14,127.45 95.55,129.05 95.55,132.99 86.21,142.33 81.07,142.33 77.48,145.91 77.48,147.58 77.76,147.85 77.76,148.68 CPU1.V2
  BOTTOM w0.102: v2(114.99,121.83) 115.21,122.05 ; 115.21,122.05 109.75,127.52 100.79,127.52 100.58,127.31 v3(100.58,127.11) ; 115.21,122.05 121.34,115.92 121.34,102.3 119.65,100.61 119.65,92.44 119.12,91.91 119.12,79.31 120.55,77.89 120.55,77.77 v3(120.2,77.41)
DMI_IT_MR_DN3: length 107.1
  TOP w0.102: v3(98.55,128.13) 98.55,128.46 98.08,128.93 96.99,128.93 96.27,129.65 96.27,133.16 96.09,133.34 92.93,136.49 86.33,143.09 81.32,143.09 78.68,145.74 78.68,149.59 CPU1.W3 ; v3(121.39,78.28) 121.67,78.01 121.67,77.58 122.64,76.6 125.1,76.6 U29.A24
  BOTTOM w0.102: v3(98.55,128.13) 98.97,128.55 109.72,128.55 121.96,116.31 121.96,102.04 120.27,100.35 120.27,100.34 120.27,84.87 ; 120.27,84.87 120.27,82.57 120.69,82.16 120.69,80.34 121.67,79.35 121.67,78.56 v3(121.39,78.28) ; 120.27,84.87 v2(119.96,84.87)
DMI_IT_MR_DP0: length 115.2
  TOP w0.102: CPU1.U3 76.14,149.59 76.14,147.72 76.48,147.38 76.48,145.37 80.64,141.21 85.74,141.21 94.43,132.53 94.43,127.23 96.53,125.13 97.78,125.13 98.01,124.9 98.01,124.79 98.48,124.31 v3(98.68,124.31) ; U29.B20 125.77,74.57 123.24,74.57 123.07,74.4 121.85,74.4 121.76,74.5 121.76,74.68 122.02,74.94 v4(122.17,74.94)
  BOTTOM w0.102: v4(122.17,74.94) 121.96,74.94 121.75,75.15 121.75,75.36 121.26,75.85 120.93,75.85 ; v3(98.68,124.31) 98.65,124.34 98.44,124.34 98.13,124.03 98.13,123.77 103.61,118.29 117.41,118.29 120.31,115.39 120.31,102.98 118.62,101.29 118.62,98.44 118.62,98.44 118.62,97.88 118.62,92.99 118.1,92.46 118.1,76.83 119.08,75.85 120.93,75.85 ; 120.93,75.85 v2(120.93,76.16)
DMI_IT_MR_DP1: length 112.5
  TOP w0.102: U29.B21 126.14,75.21 125.59,75.21 125.42,75.38 120,75.38 119.61,75.78 119.61,76.21 v4(119.38,76.44) ; CPU1.U1 76.82,147.79 76.82,145.63 80.81,141.65 85.97,141.65 94.83,132.78 94.83,127.48 95.62,126.69 96.38,126.69 96.65,126.43 v3(96.65,126.25)
  BOTTOM w0.102: v3(96.65,126.25) 96.65,126.45 96.88,126.68 97.51,126.68 98.1,126.09 98.27,126.09 ; 98.27,126.09 98.81,126.09 100.84,124.06 100.84,121.9 104.03,118.7 117.58,118.7 120.72,115.56 120.72,102.55 119.03,100.86 119.03,92.76 118.5,92.23 118.5,78.08 119.55,77.03 119.55,76.6 v4(119.38,76.44) ; 98.27,126.09 v2(98.27,125.79)
DMI_IT_MR_DP2: length 109.6
  TOP w0.102: v3(120.98,77.41) 120.98,76.36 121.24,76.11 125.99,76.11 126.37,75.73 U29.C22 ; CPU1.W2 77.97,148.68 77.97,147.77 77.7,147.5 77.7,146 81.16,142.55 86.3,142.55 92.36,136.48 95.77,133.08 95.77,129.13 97.23,127.67 100.25,127.67 v3(100.58,128)
  BOTTOM w0.102: 119.34,80.5 119.34,91.82 119.87,92.35 119.87,100.52 121.56,102.21 121.56,116.01 109.84,127.73 100.85,127.73 v3(100.58,128) ; 119.34,80.5 119.34,79.4 120.15,78.59 120.77,77.98 120.77,77.63 v3(120.98,77.41) ; 119.34,80.5 v2(119.63,80.5)
DMI_IT_MR_DP3: length 107.2
  TOP w0.102: CPU1.Y3 78.89,149.61 78.89,145.83 81.41,143.31 86.42,143.31 96.48,133.25 96.48,129.74 97.08,129.14 v3(98.55,129.14) ; v3(122.17,78.28) 121.88,77.99 121.88,77.67 122.73,76.82 125.78,76.82 U29.B24
  BOTTOM w0.102: 108.05,128.76 109.81,128.76 122.18,116.4 122.18,101.95 120.49,100.26 120.49,100.26 120.49,82.66 120.9,82.25 120.9,80.43 121.89,79.44 121.89,78.56 v3(122.17,78.28) ; 108.05,128.76 v2(108.05,129.07) ; 108.05,128.76 98.93,128.76 v3(98.55,129.14)
DMI_MT_IR_DN0: length 113.2
  TOP w0.102: v4(131.15,77.07) 131.15,76.9 U29.L24 ; v3(98.82,130.03) 99.06,130.28 99.06,131.32 86.58,143.81 81.55,143.81 79.31,146.04 79.31,149.48 79.58,149.74 79.58,151.3 80.06,151.78 CPU1.AA5
  BOTTOM w0.102: v2(99.03,131.23) 99.26,131 ; 99.26,131 99.7,131.44 108.72,131.44 108.9,131.44 122.7,117.64 123.49,116.84 123.49,101.5 121.73,99.74 121.73,83.47 124.81,80.39 124.81,79.13 126.7,77.25 128.26,77.25 128.76,77.74 130.47,77.74 131.14,77.07 v4(131.15,77.07) ; 99.26,131 98.95,130.68 98.95,130.16 v3(98.82,130.03)
DMI_MT_IR_DN1: length 109
  TOP w0.102: U29.G24 128.7,76.76 129.04,77.1 v4(129.04,77.1) ; CPU1.AB4 80.51,150.31 80.51,148.68 80.23,148.4 80.23,146.01 81.64,144.6 87.56,144.6 100.97,131.2 100.97,130.31 v3(100.7,130.04)
  BOTTOM w0.102: 106.78,130.2 109.08,130.2 109.26,130.2 122.44,117.02 122.8,116.65 122.8,101.69 121.11,100 121.11,82.93 123.71,80.33 123.71,79.56 126.64,76.64 129.2,76.64 129.39,76.83 129.39,76.98 129.26,77.11 129.04,77.11 v4(129.04,77.1) ; 106.78,130.2 105.48,130.2 104.86,130.82 101.46,130.82 100.7,130.06 v3(100.7,130.04) ; 106.78,130.2 v2(106.78,130.49)
DMI_MT_IR_DN2: length 110.6
  TOP w0.102: CPU1.AC4 81.94,150.9 81.64,150.9 81.43,150.7 81.43,150.48 v3(81.5,150.42) ; U29.F26 128.21,77.65 128.45,77.89 128.45,78.14 v4(128.24,78.34)
  BOTTOM w0.102: v4(128.24,78.34) 128.37,78.22 128.37,78.05 128.09,77.77 126.97,77.77 125.45,79.29 125.45,79.89 ; v3(81.5,150.42) 81.5,150.71 81.1,151.1 80.93,151.1 80.74,150.91 80.74,148.73 80.32,148.31 80.32,147.09 79.77,146.55 79.77,145.44 88.32,136.89 88.32,135 91.26,132.06 108.46,132.06 109.16,132.06 122.95,118.26 122.96,118.26 124.05,117.17 124.12,117.1 124.12,101.24 122.36,99.48 122.36,83.77 122.74,83.39 123.99,82.14 125.23,80.9 125.45,80.68 125.45,79.89 ; 125.45,79.89 v2(125.76,79.89)
DMI_MT_IR_DN3: length 107.7
  TOP w0.102: U29.K26 130.12,77.83 v4(130.46,78.17) ; CPU1.AC2 81.98,148.84 81.82,148.68 81.66,148.68 81.42,148.44 81.42,147.61 81.55,147.49 81.55,146.9 81.46,146.81 81.22,146.81 v3(81,147.03)
  BOTTOM w0.102: v4(130.46,78.17) 130.6,78.31 130.6,78.66 130.48,78.77 128.02,78.77 125.23,81.56 125.23,83.04 123.49,84.79 ; 123.49,84.79 v2(123.27,84.57) ; 123.49,84.79 122.76,85.51 122.76,99.3 124.52,101.06 124.52,117.27 123.12,118.67 109.2,132.59 91.51,132.59 89.01,135.09 89.01,136.92 80.18,145.75 80.18,146.38 80.59,146.79 80.76,146.79 v3(81,147.03)
DMI_MT_IR_DP0: length 113.2
  TOP w0.102: CPU1.AA4 80.15,151.33 80.07,151.41 80,151.41 80,151.41 79.79,151.21 79.79,149.65 79.53,149.39 79.53,146.13 81.64,144.02 86.67,144.02 99.28,131.41 99.28,130.32 99.55,130.05 v3(99.81,130.05) ; U29.K24 130.12,76.7 v4(130.51,77.09)
  BOTTOM w0.102: v4(130.51,77.09) 130.58,77.16 130.58,77.32 130.38,77.52 128.85,77.52 128.35,77.03 126.61,77.03 124.6,79.04 124.6,80.3 121.52,83.38 121.52,99.83 123.28,101.59 123.28,116.75 123.21,116.82 108.81,131.22 100.58,131.22 ; 100.58,131.22 99.79,131.22 99.16,130.59 99.16,130.33 99.44,130.05 v3(99.81,130.05) ; 100.58,131.22 v2(100.58,130.92)
DMI_MT_IR_DP1: length 109
  TOP w0.102: v4(129.79,77.06) 129.41,76.68 U29.H24 ; v3(101.6,130.01) 101.18,130.43 101.18,131.29 89.71,142.76 87.65,144.82 81.73,144.82 80.44,146.1 80.44,148.31 80.72,148.59 80.72,150.22 80.94,150.43 81.03,150.43 81.06,150.39 CPU1.AB3
  BOTTOM w0.102: 103.58,130.6 101.55,130.6 101.3,130.35 101.3,130.14 101.42,130.01 v3(101.6,130.01) ; 103.58,130.6 104.78,130.6 105.39,129.98 109.17,129.98 122.35,116.8 122.59,116.56 122.59,101.78 120.9,100.09 120.9,82.84 123.49,80.24 123.49,79.47 126.55,76.42 129.29,76.42 129.79,76.93 v4(129.79,77.06) ; 103.58,130.6 v2(103.58,130.29)
DMI_MT_IR_DP2: length 110.6
  TOP w0.102: U29.G26 128.7,78.07 v4(128.93,78.3) ; v3(81.5,151.32) 81.95,151.78 CPU1.AC5
  BOTTOM w0.102: v4(128.93,78.3) 128.18,77.55 126.88,77.55 125.23,79.2 125.23,80.59 125.08,80.74 122.59,83.24 122.14,83.68 122.14,99.57 123.9,101.33 123.9,117.01 123.83,117.08 109.07,131.85 108.55,131.85 108.55,131.84 91.17,131.84 88.1,134.91 88.1,136.8 79.55,145.35 79.55,146.64 80.1,147.18 80.1,147.7 ; 80.1,147.7 v2(79.81,147.7) ; 80.1,147.7 80.1,148.4 80.52,148.82 80.52,151 80.84,151.32 v3(81.5,151.32)
DMI_MT_IR_DP3: length 107.6
  TOP w0.102: U29.L26 130.83,77.93 131.07,78.17 v4(131.12,78.17) ; CPU1.AC1 81.98,148.37 81.87,148.47 81.75,148.47 81.62,148.35 81.62,147.72 81.76,147.58 81.76,146.81 81.55,146.59 81.27,146.59 v3(81,146.32)
  BOTTOM w0.102: v3(81,146.32) 81,146.47 80.89,146.58 80.68,146.58 80.39,146.29 80.39,145.84 89.23,137.01 89.23,135.18 91.6,132.81 109.29,132.81 123.21,118.88 123.21,118.88 124.74,117.36 124.74,100.97 122.98,99.21 122.98,85.6 125.45,83.13 125.45,81.65 127.2,79.89 ; 127.2,79.89 128.11,78.99 130.57,78.99 130.82,78.75 130.82,78.41 131.06,78.17 v4(131.12,78.17) ; 127.2,79.89 v2(127.43,80.12)
DMICOMP: length 7.4
  TOP w0.203: U29.C13 126.37,70.67 126.02,70.31 125.56,70.31 125.54,70.33 124.75,70.33 124.29,69.86 122.61,69.86 122.4,69.66 122.4,69.05 121.92,68.56 v1(121.67,68.56) 120.93,68.56 R411.2
DMIRCOMP: length 7
  TOP w0.203: U29.B19 125.86,73.87 125.51,73.52 124.17,73.52 123.95,73.3 v1(120.52,73.3) 120.42,73.2 R382.2
DPD_AUXN: length 183.8
  TOP w0.102: v4(138.76,70.08) 139.08,69.76 U29.AG11 ; v3(120.19,198.41) 120.19,198.62 119.99,198.82 116.03,198.82 113.53,196.31 113.53,130.73 118.2,126.06 118.2,118.09 119.13,117.17 119.13,116.06 118.26,115.2 116.61,115.2 113.68,112.26 113.46,112.26 113.03,111.83 v3(113.03,111.62)
  BOTTOM w0.102: v4(138.76,70.08) 138.52,70.08 138.35,69.91 138.35,69.53 136.84,68.02 136.84,67.52 133.9,64.58 133.01,64.58 130.28,61.86 122.05,61.86 ; C415.1 127.9,198.8 125.79,198.8 125.22,198.23 123.79,198.23 123.44,198.57 123.34,198.68 120.45,198.68 v3(120.19,198.41) ; 122.05,61.86 v2(122.05,62.16) ; 122.05,61.86 121.31,61.86 120.22,62.95 120.16,63.01 119.53,63.64 119.3,63.87 118.29,63.87 113.18,68.98 113.18,110.19 112.74,110.63 112.74,111.32 v3(113.03,111.62)
DPD_AUXP: length 184.2
  TOP w0.102: v3(113.03,112.48) 113.59,112.48 116.52,115.42 118.17,115.42 118.91,116.15 118.91,117.08 117.98,118 117.98,125.97 113.31,130.64 113.31,196.4 115.94,199.03 119.99,199.03 v3(120.19,199.23) ; U29.AG10 139.16,69.05 v4(138.79,69.43)
  BOTTOM w0.102: v2(119.84,62.57) 120.07,62.8 ; 120.07,62.8 120,62.86 119.38,63.48 119.22,63.65 118.2,63.65 112.96,68.89 112.96,110.1 112.52,110.54 112.52,111.97 v3(113.03,112.48) ; 120.07,62.8 121.22,61.64 130.37,61.64 133.1,64.37 133.99,64.37 137.06,67.44 137.06,67.93 138.56,69.43 v4(138.79,69.43) ; C414.1 127.9,199.01 125.7,199.01 125.13,198.45 123.88,198.45 123.6,198.73 123.43,198.89 120.52,198.89 v3(120.19,199.23)
DPD_HPD: length 262.8
  TOP w0.102: U29.AJ4 140.61,65.62 140.93,65.31 140.93,65.05 140.29,64.41 140.29,63.5 140.74,63.05 v4(140.74,62.93)
  L3 w0.127: v3(153.97,225.56) 160.17,225.56 162.16,227.54 168.8,227.54 169.05,227.78 184.02,227.78 185.74,226.06 185.74,187.39 179.78,181.44 179.78,160.94 180.14,160.59 180.14,157.96 179.63,157.45 179.63,156.71 180.4,155.94 180.4,152.5 180.14,152.24 180.14,150.02 179.2,149.08 179.2,121.16 177.84,119.8 177.84,118.67 181.36,115.15 181.36,105.61 177.84,102.09 170.76,102.09 166.07,97.39 164.5,97.39 163.05,95.95 163.05,91.98 162.33,91.26 162.33,83.49 158.54,79.69 158.54,72.23 152.07,65.77 147.93,65.77 146.66,64.5 142.49,64.5 140.93,62.93 v4(140.74,62.93)
  BOTTOM w0.102: v3(153.97,225.56) 153.97,217.66 152.43,216.12 151.47,216.12 151.2,215.85 151.2,215.33 v2(150.9,215.03) 149.8,213.93 148.54,213.93 145.44,210.83 141.13,210.83 139.9,209.61 139.9,207.26 R730.1
DPD_LANE0N: length 123.9
  TOP w0.102: 120.5,200.53 116.95,200.53 114.6,202.88 114.6,205.04 v3(114.94,205.37) ; 120.5,200.53 v1(120.5,200.87) ; 120.5,200.53 120.74,200.53 121.35,199.92 123.25,199.92 v3(123.72,200.39) ; CPU1.C15 63.54,160.92 63.44,161.03 63.44,161.28 63.22,161.5 61.4,161.5 61.21,161.69 60.43,161.69 59.97,161.23 58.65,161.23 58.55,161.33 v3(58.55,161.9)
  L3 w0.127: v3(114.94,205.37) 114.64,205.67 114.64,206.04 112.4,208.28 92.62,208.28 90.79,206.45 83.96,206.45 81.65,204.14 78.32,204.14 72.9,198.71 72.9,196.06 66.17,189.32 59.7,189.32 57.37,186.99 57.37,164.33 56.68,163.65 56.68,161.41 57.43,160.66 57.97,160.66 58.4,161.09 58.4,161.45 58.55,161.6 v3(58.55,161.9)
  BOTTOM w0.102: v3(123.72,200.39) 124.19,199.93 124.58,199.93 126.51,201.86 127.87,201.86 C407.1
DPD_LANE0P: length 123.4
  TOP w0.102: CPU1.B15 63.1,160.92 63.22,161.04 63.22,161.19 63.13,161.28 61.31,161.28 61.12,161.47 60.52,161.47 60.06,161.01 58.56,161.01 58.33,161.24 58.33,161.45 58.23,161.55 57.79,161.55 57.69,161.65 v3(57.69,161.9) ; v3(123.72,199.25) 123.27,199.7 121.26,199.7 120.65,200.31 116.86,200.31 115.28,201.9 ; v1(115.01,201.63) 115.28,201.9 ; 115.28,201.9 114.39,202.79 114.39,205.11 v3(114.13,205.37)
  L3 w0.127: v3(57.69,161.9) 57.69,161.63 57.78,161.53 58.04,161.53 58.14,161.43 58.14,161.2 57.86,160.92 57.54,160.92 56.95,161.52 56.95,163.53 57.63,164.22 57.63,186.88 59.81,189.06 66.28,189.06 73.16,195.94 73.16,198.6 78.44,203.87 81.76,203.87 84.07,206.18 90.9,206.18 92.73,208.01 112.29,208.01 114.38,205.93 114.38,205.62 v3(114.13,205.37)
  BOTTOM w0.102: C406.1 127.87,201.64 126.6,201.64 124.67,199.71 124.19,199.71 v3(123.72,199.25)
DPD_LANE1N: length 112.3
  TOP w0.102: v3(123.72,202.68) 123.25,202.21 120.51,202.21 120.01,201.7 119.53,201.7 ; CPU1.B16 62.6,161.84 62.5,161.94 62.5,162.17 62.27,162.4 60.39,162.4 60.33,162.46 60.33,162.82 60.22,162.92 v3(59.91,162.92) ; 119.53,201.7 116.95,201.7 116.38,202.27 116.38,202.96 v3(116.68,203.25) ; 119.53,201.7 v1(119.53,202.07)
  L3 w0.127: v3(116.68,203.25) 116.4,203.54 116.4,203.83 116.23,204 116.13,204.1 113.74,204.1 112.23,205.61 101.36,205.61 99.45,207.51 93.03,207.51 91.26,205.75 85.51,205.75 76.71,196.94 68.22,188.45 60.1,188.45 58.08,186.43 58.08,166.06 60.33,163.81 60.33,163.04 60.22,162.92 v3(59.91,162.92)
  BOTTOM w0.102: C409.1 126.85,204.63 126.31,204.63 124.88,203.2 124.88,202.69 124.47,202.28 124.03,202.28 123.72,202.59 v3(123.72,202.68)
DPD_LANE1P: length 111.9
  TOP w0.102: v3(123.72,201.53) 123.27,201.99 120.6,201.99 120.1,201.49 117.93,201.49 ; v3(115.87,203.25) 116.17,202.96 116.17,202.18 116.86,201.49 117.93,201.49 ; CPU1.A16 62.18,161.84 62.28,161.94 62.28,162.08 62.18,162.18 60.34,162.18 60.3,162.14 v3(59.91,162.14) ; v1(117.93,201.13) 117.93,201.49
  L3 w0.127: v3(59.91,162.14) 59.91,162.23 60.6,162.92 60.6,163.92 58.34,166.17 58.34,186.32 60.21,188.19 68.33,188.19 76.82,196.68 85.62,205.48 91.37,205.48 93.14,207.25 99.34,207.25 101.24,205.34 112.11,205.34 113.63,203.83 116.02,203.83 116.13,203.72 116.13,203.52 v3(115.87,203.25)
  BOTTOM w0.102: v3(123.72,201.53) 123.72,201.66 124.13,202.07 124.56,202.07 125.09,202.6 125.09,203.11 126.4,204.41 126.85,204.41 C408.1
DPD_LANE2N: length 14.5
  TOP w0.102: TP6.1 52.36,159.62 52.74,159.62 57.18,164.06 60.91,164.06 61.64,163.33 63.18,163.33 63.69,162.82 CPU1.C17
DPD_LANE2P: length 14.4
  TOP w0.102: TP7.1 52.36,159.41 52.83,159.41 57.27,163.85 60.82,163.85 61.55,163.12 63.09,163.12 63.22,162.98 63.22,162.82 63.15,162.75 CPU1.B17
DPD_LANE3N: length 12.6
  TOP w0.102: TP4.1 52.36,162.16 53.36,162.16 55.78,164.58 61.97,164.58 62.78,163.77 CPU1.B18
DPD_LANE3P: length 12.5
  TOP w0.102: TP5.1 52.36,161.95 53.45,161.95 55.87,164.36 61.88,164.36 62.31,163.93 62.31,163.79 62.18,163.66 CPU1.A18
DPLL_PVDD: length 6
  TOP w0.356: v4(88.01,85.58) 88.01,85.88 U13.AF14
  BOTTOM w0.508: v2(90.22,82.91) L52.2 C830.1 87.57,83.23 C827.1 87.67,84.03 C829.1 87.67,85.04 87.99,85.35 87.99,85.56 v4(88.01,85.58)
DPLL_VDDC: length 7.5
  TOP w0.356: v4(86.53,85.62) 86.15,86 U13.AD14
  BOTTOM w0.508: L53.2 86.61,79.36 v2(86.61,80.12) C828.1 86.55,82.98 C825.1 C826.1 86.55,85.6 v4(86.53,85.62)
DPLVDS_AUXN: length 4.1
  BOTTOM w0.102: C404.2 133.04,204.19 133.04,205.8 ; v2(133.35,205.8) 133.04,205.8 ; 133.04,205.8 133.04,206.86 133.1,206.91 U37.3
DPLVDS_AUXN_1: length 8.4
  BOTTOM w0.102: v2(130.51,198.48) 130.51,198.8 ; 130.51,198.8 132.39,198.8 133.07,199.48 133.07,200.56 R762.2 R759.2 133.41,202.93 C404.1 ; 130.51,198.8 129.46,198.8 C415.2
DPLVDS_AUXP: length 4.2
  BOTTOM w0.102: v2(132.49,204.86) 132.83,204.86 ; 132.83,204.86 132.83,206.82 132.7,206.94 U37.4 ; 132.83,204.86 132.83,204.25 C405.2
DPLVDS_AUXP_1: length 8
  BOTTOM w0.102: 132.85,199.96 132.85,199.57 132.3,199.01 129.46,199.01 C414.2 ; 132.85,199.96 v2(132.56,199.96) ; 132.85,199.96 132.85,200.44 R763.1 R760.1 132.4,202.93 C405.1
DPLVDS_BL_EN: length 227.8
  TOP w0.102: R177.1 16.7,111.11 17.86,111.11 18.8,112.05 18.8,114.66 v3(18.54,114.92)
  L4 w0.127: v3(137.9,211.57) 137.9,212.1 135.7,214.3 129.28,214.3 128.89,214.69 125.73,214.69 124.83,215.59 124.83,216.08 124.55,216.35 124.03,216.35 123.67,216.71 123.07,216.71 122.59,217.19 119.98,217.19 118.79,216.01 118,216.01 117.31,215.33 114.74,215.33 114.58,215.16 109.16,215.16 104.5,219.82 97.14,219.82 96.38,220.58 73.74,220.58 69.09,225.24 52.86,225.24 51.2,223.57 51.2,216.81 50.16,215.77 50.16,173.59 43.5,166.93 43.5,164.08 41.5,162.08 40.92,162.08 29.92,151.08 29.92,148.38 29.45,147.91 29.45,142.99 29.86,142.58 29.86,136.95 29.16,136.25 29.16,134.04 19.39,124.27 19.39,115.77 v3(18.54,114.92)
  BOTTOM w0.102: v3(137.9,211.57) 137.9,211.44 137.53,211.07 137.5,211.07 v2(137.08,210.65) 136.33,209.89 135.33,209.89 135.27,209.95 U37.44
DPLVDS_EDIDCLK: length 21.5
  TOP w0.102: v3(139.85,211.77) 139.19,211.11 137.26,211.11 136.45,211.92 136.45,214.33 136.88,214.77 140.54,214.77 140.97,214.33 141.94,214.33 142.25,214.65 R50.1 142.24,214.83 R49.2 142.27,215.92 C19.1
  BOTTOM w0.102: v3(139.85,211.77) 139.37,211.29 139.01,211.29 137.72,210 v2(137.72,209.46) 137.41,209.15 U37.46
DPLVDS_EDIDCLK_C: length 3.2
  TOP w0.102: R50.2 141.36,215.9 v1(141.22,216.04) 140.61,215.43 U1.6
DPLVDS_EDIDSDA: length 10.2
  TOP w0.102: C21.1 141.08,213.78 R54.2 ; C21.1 140.09,212.54 140.72,211.92 v1(140.72,211.79) ; C21.1 139.13,212.79 R53.1 138.99,212.65 v3(138.99,211.77)
  BOTTOM w0.102: U37.45 136.77,209.55 v3(138.99,211.77)
DPLVDS_EDIDSDA_C: length 5.5
  TOP w0.102: R53.2 137.31,212.71 v1(137.08,212.48) 136.86,212.71 136.86,213.8 137.21,214.16 U1.5
DPLVDS_FWCLK: length 14.4
  TOP w0.102: R66.1 145.92,209.34 C31.1 R68.2 140.65,209.22 v3(139.7,210.17)
  BOTTOM w0.102: U37.48 137.23,208.35 v2(137.5,208.07) 139.08,208.07 139.55,208.54 139.55,210.02 v3(139.7,210.17)
DPLVDS_FWCLK_C: length 3.6
  TOP w0.102: v1(148.18,209.25) 147.79,209.25 R66.2 146.81,210.83 146.56,211.08 U2.6
DPLVDS_FWSDA: length 12.3
  TOP w0.102: R65.1 143.76,211.25 C28.1 R60.2 142.33,210.96 140.26,210.96 v3(140.23,210.98)
  BOTTOM w0.102: v3(140.23,210.98) 139.71,210.98 139.19,210.46 139.19,209.18 v2(138.89,208.87) 138.76,208.75 U37.47
DPLVDS_FWSDA_C: length 3.2
  TOP w0.102: U2.5 145.29,210.42 v1(145.16,210.3) 145.08,210.22 143.88,210.22 R65.2
DPLVDS_HPD: length 3.9
  BOTTOM w0.102: R739.1 134.42,203.93 v2(134.42,204.96) 134.42,206.4 133.9,206.91 U37.1
DPLVDS_ISPCLK: length 15.6
  BOTTOM w0.102: U37.13 128.7,208.19 127.89,207.37 127.68,207.37 126.31,206 125.5,206 125.01,205.51 124.99,205.51 124.99,205.5 124.12,204.63 v2(123.32,204.63) 122.09,204.63 120.8,205.92 120.8,207.54 R725.2 119.72,207.27 119.15,207.27 118.3,206.42 Q95.S
DPLVDS_ISPDAT: length 10.6
  BOTTOM w0.102: U37.14 128.2,208.75 127.91,208.47 127.91,208.13 126.14,206.36 125.09,206.36 v2(124.46,205.72) 122.08,205.72 Q94.S 121.38,207.14 121.41,207.17 R724.2
DPLVDS_PANEL_VCC: length 14.2
  TOP w0.102: v3(120.4,215.6) 119.43,216.57 118.62,216.57 118.3,216.89 R48.1
  BOTTOM w0.102: v3(120.4,215.6) 120.83,215.6 121.39,215.05 v2(121.39,214.11) 121.39,213.42 123.37,211.44 127.55,211.44 127.84,211.15 U37.20
DPLVDS_PIN12: length 0.7
  BOTTOM w0.203: U37.12 128.93,207.55 v3(128.83,207.65)
  vias: v1(127.99,207.32)
DPLVDS_PIN16: length 3.6
  TOP w0.254: v1(126.39,210.22) 127.18,209.43 127.51,209.43 v3(127.53,209.41)
  TOP w0.508: v3(127.53,209.41) 127.53,209.43 127.64,209.53 R67.1
  BOTTOM w0.203: U37.16 127.65,209.55 127.53,209.43 v3(127.53,209.41)
DPLVDS_PWMIN: length 9.1
  BOTTOM w0.165: U37.21 127.88,211.55 127.58,211.85 127,211.85 126.64,212.2 R713.1 R714.1 R715.1 124.59,212.66 124.71,212.53 124.71,212.18 124.56,212.02 v2(124.1,212.02) 123.7,212.02 122.57,213.15 R717.2
DPLVDS_PWMOUT: length 202.7
  TOP w0.165: R170.1 17.98,119.36 v3(18.26,119.64)
  L4 w0.165: v3(54.99,156.07) 54.99,169.45 55.66,170.13 55.66,201.06 61.34,206.74 61.34,209.15 62.55,210.36 64.16,210.36 73.18,219.38 95.89,219.38 96.65,218.62 103.62,218.62 104.37,217.86 104.37,216.74 104.7,216.41 106.21,216.41 108.66,213.96 109.01,213.96 115.08,213.96 115.24,214.12 117.81,214.12 118.5,214.81 119.29,214.81 119.35,214.87 v3(120.14,214.87)
  BOTTOM w0.165: v3(54.99,156.07) 54.69,156.07 54.46,155.84 54.46,132.57 52.77,130.88 39.29,130.88 38.36,129.96 23.16,129.96 21.84,128.63 21.84,127.03 19.18,124.36 19.18,120.56 v3(18.26,119.64) ; v3(120.14,214.87) 120.14,213.97 120.02,213.85 v2(120.02,213.72) 120.47,213.72 123.19,211.01 127.58,211.01 127.84,210.75 U37.19
DQMA0: length 36.6
  TOP w0.127: U13.E32 70.62,99.07 70.62,99.22 69.58,100.26 v4(69.49,100.26)
  L3 w0.165: v4(52.05,103.43) 52.28,103.19 52.28,103.13 52.5,102.91 52.5,102.61 52.37,102.48 52.37,102.48 52.06,102.17 51.54,102.17 51.33,102.37 51.33,103.41 51.21,103.54 50.24,103.54 50.11,103.41 50.11,102.58 49.99,102.45 49.68,102.45 49.56,102.33 49.56,101 49.68,100.87 50.04,100.87 50.16,101 50.16,101.76 50.29,101.89 50.95,101.89 51.26,101.58 51.99,101.58 52.24,101.34 52.24,101.24 52.49,100.98 52.52,100.98 52.54,100.96 53.15,100.96 54.54,99.57 54.85,99.57 55.3,99.11 55.93,99.11 56.22,99.4 56.82,99.4 57.12,99.1 57.7,99.1 57.94,99.34 59.22,99.34 59.77,98.79 66.07,98.79 66.4,99.12 66.65,99.12 67.28,99.76 67.72,99.76 68.1,99.37 68.1,99.12 68.22,98.99 68.96,98.99 69.09,99.12 69.09,99.85 v4(69.49,100.26)
  BOTTOM w0.127: v2(68.72,100.13) 69.36,100.13 v4(69.49,100.26) ; v4(52.05,103.43) 51.88,103.43 51.49,103.03 51.49,102.74 MEM3.E7
DQMA1: length 35.6
  TOP w0.127: v4(68.86,97.49) 68.94,97.57 70.58,97.57 U13.E30
  BOTTOM w0.127: MEM3.D3 54.36,103.51 54.01,103.86 54.01,104.12 53.16,104.97 52.46,104.97 52.2,104.72 52.2,104.33 51.53,103.65 50.94,103.65 50.76,103.83 50.76,105.1 50.91,105.26 51.31,105.26 51.59,105.53 51.59,106.22 51.41,106.41 51.41,107.1 52.18,107.87 57.82,107.87 61.82,103.87 61.82,101.03 v2(64.06,98.79) 64.54,98.31 66.88,98.31 67.14,98.05 67.14,97.81 67.46,97.49 v4(68.86,97.49)
DQMA2: length 36.1
  TOP w0.102: 53.54,103.95 53.87,103.62 53.87,103.25 54.23,102.89 54.52,102.89 54.74,103.11
  TOP w0.127: U13.A21 69.32,91.51 59.62,91.51 v1(59.47,91.67) 59.47,101.45 59.97,101.95 59.97,102.95 59.64,103.28 59.29,103.28 59.17,103.16 59.17,102.3 59.04,102.17 58.79,102.17 58.66,102.3 58.66,103.16 58.53,103.28 58.28,103.28 58.15,103.16 58.15,102.78 58.02,102.65 57.77,102.65 57.64,102.78 57.64,103.16 57.52,103.28 56.39,103.28 56.11,103.56 55.02,103.56 54.74,103.28 54.74,103.11 ; MEM1.D3 51.16,103.46 51.64,103.94 51.64,104.25 52.35,104.95 52.81,104.95 53.36,104.41 53.36,104.13 53.54,103.95
DQMA3: length 34.5
  TOP w0.127: v4(53.28,103.56) 53.28,103.53 54.36,102.44 MEM1.E7 ; U13.C21 69.73,91.12 68.43,91.12 68.26,91.28 67.55,91.28 v4(67.13,90.87)
  L4 w0.165: v4(53.28,103.56) 53.28,104.01 53.53,104.27 55.36,104.27 55.7,104.61 56.25,104.61 56.59,104.27 57.19,104.27 57.58,104.66 58.21,104.66 58.6,104.27 59.17,104.27 63.16,100.28 63.16,99.68 62.77,99.29 62.77,99.11 63.09,98.79 63.27,98.79 63.81,99.34 64.05,99.34 64.28,99.1 64.28,98.87 63.71,98.3 63.71,98.12 64,97.83 64.18,97.83 64.42,98.08 64.71,98.08 64.87,97.91 64.87,96.14 66.39,94.62 66.55,94.62 67.13,94.04 67.13,93.63 67.03,93.53 66.67,93.53 66.55,93.41 66.55,92.99 66.71,92.82 67.6,92.82 67.77,92.66 67.77,92.29 67.6,92.13 66.76,92.13 66.6,91.96 66.6,91.63 66.76,91.47 66.97,91.47 67.13,91.3 v4(67.13,90.87)
DQMA4: length 34.7
  TOP w0.102: U13.E13 70.68,85.14 70.35,84.81 70.08,84.81 69.93,84.87 69.57,84.87 69.42,84.81 69.25,84.81 69.03,84.95 68.43,84.95 68.29,84.81 67.99,84.81 v4(67.82,84.64)
  L4 w0.165: v4(67.82,84.64) 67.13,84.64 66.84,84.93 64.32,84.93 63.73,84.34 63.73,77.78 59.33,73.39 56.11,73.39 55.91,73.59 55.91,74.29 55.78,74.42 55.36,74.42 55.23,74.29 55.23,73.61 55.01,73.39 53.92,73.39 53.5,73.81 53.5,74.4 v4(52.67,75.23)
  BOTTOM w0.127: v4(52.67,75.23) 52.59,75.23 52.2,75.62 52.2,75.8 52.42,76.03 52.6,76.03 52.73,75.9 53.21,75.9 53.4,75.71 53.4,75.54 53.53,75.41 53.83,75.41 53.96,75.54 53.96,76.58 54.14,76.76 MEM4.E7
DQMA5: length 36.8
  TOP w0.102: 68.24,84.47 68.52,84.75 68.97,84.75 69.2,84.61 69.46,84.61 69.48,84.62 69.68,84.66 69.72,84.67 69.87,84.67 70.05,84.54 70.25,84.34 U13.D12
  TOP w0.127: 68.24,84.47 68.24,84.47 67.98,84.21 66.95,84.21 66.04,83.3 63.42,83.3 62.84,83.87 62.84,85.87 62.05,86.66 61.48,86.66 61.35,86.53 61.35,85.7 61.23,85.57 60.97,85.57 60.85,85.7 60.85,86.53 60.72,86.66 60.46,86.66 60.34,86.53 60.34,85.7 60.21,85.57 59.96,85.57 59.83,85.7 59.83,86.53 59.7,86.66 59.45,86.66 59.32,86.53 59.32,85.7 59.19,85.57 58.94,85.57 58.81,85.7 58.81,86.53 58.69,86.66 v1(58.34,86.66) 57.67,86.66 56.43,85.42 56.43,84.57 57.12,83.89 57.12,83.25 57.4,82.97 57.4,79.41 57.88,78.94 57.88,77.39 57.45,76.96 57.14,76.96 56.37,76.18 56.37,75.88 56.11,75.62 54.71,75.62 MEM2.D3
DQMA6: length 29.7
  TOP w0.127: v4(53.46,76.34) 53.46,76.35 53.84,76.35 54,76.19 54,76.04 53.74,75.78 53.21,75.78 53.03,75.96 52.37,75.96 51.79,75.38 51.63,75.38 51.43,75.58 51.43,75.71 51.73,76 51.73,76.17 51.62,76.27 51.62,76.51 51.38,76.76 MEM2.E7 ; v4(70.56,77.54) 70.95,77.93 U13.E3
  L3 w0.165: v4(53.46,76.34) 53.46,76.05 54.07,75.44 55.69,75.44 56.52,74.61 56.52,74.33 56.77,74.08 57.14,74.08 57.2,74.14 59.11,74.14 59.28,74.31 59.28,74.48 59.51,74.71 59.89,74.71 60.06,74.55 60.06,74.36 60.22,74.19 60.55,74.19 60.72,74.36 60.72,74.55 60.88,74.71 61.21,74.71 61.38,74.55 61.38,74.36 61.54,74.19 61.87,74.19 62.04,74.36 62.04,74.55 62.2,74.71 62.54,74.71 62.7,74.55 62.7,74.36 62.87,74.19 63.2,74.19 63.36,74.36 63.36,74.55 63.53,74.71 64.15,74.71 65.21,75.78 65.21,76.9 65.38,77.07 65.77,77.07 65.94,76.9 65.94,76.49 66.1,76.32 66.43,76.32 66.6,76.49 66.6,76.9 66.76,77.07 69.26,77.07 69.27,77.07 70.09,77.07 v4(70.56,77.54)
DQMA7: length 31.9
  TOP w0.127: U13.F4 71.69,78.34 71.38,78.02 71.38,77.15 v4(71.7,76.82)
  BOTTOM w0.127: MEM4.D3 51.41,75.71 51.41,75.42 52.23,74.6 52.23,73.95 54.04,72.15 56.9,72.15 57.4,71.64 59.4,71.64 v2(59.64,71.88) 59.84,72.08 63.25,72.08 65.2,74.02 71.66,74.02 73.47,75.84 73.47,76.09 73.84,76.46 73.84,76.87 73.47,77.24 72.13,77.24 v4(71.7,76.82)
DRAM_RST: length 11
  TOP w0.102: U13.L10 76.22,83.01 v4(76.68,83.01)
  BOTTOM w0.102: v4(76.68,83.01) 76.68,82.06 77.19,81.54 77.19,81.09 78.69,79.59 80.86,79.59 C839.1 81.9,79.42 v2(82.02,79.31) 82.02,78.9 81.39,78.28 R1202.1 R1205.1
DRAM_RST_R: length 3.9
  BOTTOM w0.102: R1202.2 81.62,77.73 82.04,77.73 v2(82.35,77.43) 81.29,76.37 R1203.1 C762.1
DRVON: length 91.4
  TOP w0.254: v3(16.48,166.96) 16.52,166.93 18.64,166.93 R112.2
  L3 w0.254: v3(21.49,238.31) 20.4,238.31 19.1,237.02 17.09,237.02 16.33,236.25 16.33,225.05 v3(15.72,224.44) 15.72,223.86 17.63,221.95 17.63,203.67 15.04,201.08 v3(14.58,201.08)
  L4 w0.254: v3(14.58,201.08) 14.58,200.61 13,199.03 13,194.38 14.05,193.34 14.05,183.45 16.48,181.01 16.48,169.48 15.88,168.87 15.88,167.57 v3(16.48,166.96)
  BOTTOM w0.203: v3(21.49,238.31) 21.39,238.31 20.77,238.93 U35.13
  BOTTOM w0.254: v3(14.58,201.08) 14.3,201.36 v2(14.3,202.42) 14.3,203.58 R750.1 ; C379.1 22.14,238.31 v3(21.49,238.31) ; R701.1 14.73,225.44 v3(15.72,224.44)
DRX0N: length 7.3
  BOTTOM w0.102: C407.2 129.43,201.86 129.76,201.86 129.88,201.98 129.88,203.58 130.63,204.33 130.63,204.83 ; 130.63,204.83 130.63,206.37 131.1,206.84 U37.8 ; 130.63,204.83 v2(130.33,204.83)
DRX0P: length 7.8
  BOTTOM w0.102: v2(130.4,203.06) 130.1,203.06 ; 130.1,203.06 130.1,203.49 130.84,204.24 130.84,206.28 131.5,206.93 U37.7 ; 130.1,203.06 130.1,201.89 129.84,201.64 129.43,201.64 C406.2
DRX1N: length 4.9
  BOTTOM w0.102: C409.2 128.42,204.63 129.16,204.63 129.45,204.92 129.45,205.6 ; v2(129.13,205.6) 129.45,205.6 ; 129.45,205.6 129.45,205.94 130.3,206.79 U37.10
DRX1P: length 5.4
  BOTTOM w0.102: 129.16,204.41 128.42,204.41 C408.2 ; 129.16,204.41 v2(129.16,204.1) ; 129.16,204.41 129.25,204.41 129.67,204.83 129.67,205.85 130.7,206.88 U37.9
DSWVRMEN: length 7
  TOP w0.102: R281.2 145.15,91.11 v1(144.68,90.64) 144.15,90.1 144.15,89.93 142.37,88.15 142.37,86.05 U29.AM41
EAPD_DEPOP: length 72.3
  TOP w0.203: v3(144.68,48.55) 144.68,48.6 144.08,49.2 R484.1 ; v3(175.26,90.81) 175.26,90.81 U16.14
  BOTTOM w0.203: v3(144.68,48.55) 144.78,48.65 144.78,48.67 150.45,54.34 v2(152.53,54.34) 153.8,55.61 160.72,55.61 164.3,59.2 164.75,59.2 166.01,60.46 166.01,60.91 172.11,67 172.11,73.53 172.19,73.61 172.19,73.93 172.62,74.36 172.62,77.81 171.58,78.85 171.58,82.03 170.88,82.72 170.88,83.49 168.66,85.71 168.66,91.68 170.31,93.33 172.75,93.33 v3(175.26,90.81)
EAPD_DEPOP_1: length 4.7
  TOP w0.102: R485.1 R484.2 144.15,50.21 144.15,50.85 R483.1 v1(143.64,52.56)
EAPD_DEPOP_2: length 3.9
  TOP w0.254: v1(148.21,49.64) 147.96,49.39 R485.2 145.8,50.47 Q62.2
FAN_CTL3: length 79.9
  TOP w0.165: U24.48 53.67,50.78 v3(53.42,50.53) ; R533.1 115.59,40.5 115.59,41.5 113.74,43.34 113.74,48.57 v3(113.92,48.75)
  L4 w0.165: v3(113.92,48.75) 113.54,49.13 110.36,49.13 101.94,57.55 85.12,57.55 82.29,54.72 75.05,54.72 73.58,53.25 67.43,53.25 66.04,51.87 65.71,51.87 54.78,51.87 53.44,50.53 v3(53.42,50.53)
  BOTTOM w0.165: v2(114.41,48.1) 113.92,48.59 v3(113.92,48.75)
FAN_TAC3: length 76.9
  TOP w0.165: R488.2 104.07,50.04 108.64,50.04 109.09,49.59 113.36,49.59 v3(114.05,50.28) ; U24.38 v3(57.67,53.33)
  L4 w0.165: v3(114.05,50.28) 110.49,50.28 102.16,58.61 84.97,58.61 81.88,55.52 74.72,55.52 73.25,54.05 65.22,54.05 64,52.84 58.27,52.84 57.78,53.33 v3(57.67,53.33)
  BOTTOM w0.165: v2(115.7,49.51) 114.81,49.51 v3(114.05,50.28)
FDI_COMP: length 7.1
  TOP w0.254: v3(75.11,150.4) 74.66,150.84 CPU1.R4
  BOTTOM w0.305: R830.2 75.44,154.24 v2(75.44,151.37) 75.44,150.72 v3(75.11,150.4)
FDI_CSYNC: length 166
  TOP w0.102: v3(57.99,157.41) 57.99,142.03 82.31,117.71 v3(84.58,117.71) ; v3(65.05,162.3) 64.61,161.85 CPU1.D16 ; U29.L2 131.04,64.28 129.71,62.95 129.71,61.28 129.18,60.74 129.18,57.97 128.41,57.2 128.41,55.99 v3(128.06,55.64)
  BOTTOM w0.102: v3(57.99,157.41) 59.25,157.41 64.14,162.3 v3(65.05,162.3) ; v3(84.58,117.71) v2(88.14,117.71) 97.42,117.71 107.88,107.26 107.88,93.06 107.12,92.29 107.12,67.33 119.04,55.41 127.83,55.41 v3(128.06,55.64)
FDI_INT: length 173.1
  TOP w0.102: v3(128.82,55.59) 128.64,55.77 128.64,57.1 129.41,57.87 129.41,60.65 129.94,61.18 129.94,62.9 131.34,64.3 131.34,65 131.05,65.3 U29.L3 ; CPU1.D18 v3(64.15,163.21) ; v3(85.47,117.08) 82.62,117.08 56.16,143.54 56.16,162.08 v3(57.43,163.35)
  BOTTOM w0.102: v3(85.47,117.08) v2(92.89,117.08) 97.74,117.08 107.65,107.16 107.65,93.15 106.89,92.39 106.89,67.23 118.94,55.18 128.41,55.18 v3(128.82,55.59) ; v3(57.43,163.35) 57.56,163.48 63.88,163.48 v3(64.15,163.21)
FDI_RCOMP: length 3.5
  TOP w0.203: v3(129.64,64.08) 129.64,64.1 130.41,64.88 U29.K2
  BOTTOM w0.203: R988.2 130.97,65.26 v2(130.3,64.6) 129.79,64.08 v3(129.64,64.08)
FDI_TX_DN0: length 164.2
  TOP w0.102: CPU1.B14 62.78,160.14 62.33,160.58 61.34,160.58 59.63,158.87 59.63,141.01 81.43,119.21 84.33,119.21 84.65,118.89 84.65,118.72 84.4,118.47 v3(84.16,118.47) ; U29.N1 131.74,64.08 130.59,62.93 130.59,61.07 130.15,60.63 130.15,57.87 130.59,57.43 130.59,56.66 130.3,56.37 129.92,56.37 v3(129.67,56.63)
  BOTTOM w0.102: v3(129.67,56.63) 129.67,56.45 129.54,56.32 126.01,56.32 125.75,56.07 119.26,56.07 107.74,67.58 107.74,92.04 108.5,92.8 108.5,107.51 96.53,119.49 93.52,119.49 ; 93.52,119.49 84.96,119.49 84.62,119.15 84.62,118.64 84.45,118.47 v3(84.16,118.47) ; 93.52,119.49 v2(93.52,119.8)
FDI_TX_DN1: length 161.8
  TOP w0.102: v3(83.78,120.13) 83.78,120.32 83.45,120.65 80.88,120.65 60.31,141.21 60.31,158.61 61.37,159.67 62.92,159.67 63.16,159.43 63.16,159.22 63.29,159.09 CPU1.C13 ; v3(131.32,56.98) 131.61,57.27 131.61,57.68 130.8,58.49 130.8,60.1 131.35,60.65 131.35,62.92 132.26,63.83 132.26,64.06 132.44,64.24 132.44,64.73 U29.P2
  BOTTOM w0.102: 86.77,120.59 84.03,120.59 83.78,120.34 v3(83.78,120.13) ; 86.77,120.59 v2(86.77,120.28) ; 86.77,120.59 96.02,120.59 108.91,107.71 108.91,92.63 108.15,91.87 108.15,67.75 118.63,57.27 131.03,57.27 v3(131.32,56.98)
FDI_TX_DP0: length 164.2
  TOP w0.102: CPU1.A14 61.86,160.01 62.27,160.01 62.37,160.11 62.37,160.24 62.24,160.37 61.43,160.37 59.84,158.78 59.84,141.1 81.52,119.43 84.42,119.43 84.86,118.98 84.86,118.66 v3(85.05,118.47) ; v3(129.67,55.76) 130.06,56.16 130.39,56.16 130.81,56.57 130.81,57.51 130.36,57.96 130.36,60.54 130.81,60.98 130.81,62.84 132.02,64.06 132.02,64.61 131.8,64.83 U29.N2
  BOTTOM w0.102: v3(129.67,55.76) 129.33,56.1 126.1,56.1 125.84,55.85 119.17,55.85 107.52,67.49 107.52,92.13 108.29,92.89 108.29,107.42 96.44,119.28 89.92,119.28 ; v3(85.05,118.47) 84.84,118.69 84.84,119.06 85.05,119.28 89.92,119.28 ; 89.92,119.28 v2(89.92,118.98)
FDI_TX_DP1: length 161.8
  TOP w0.102: CPU1.B13 62.95,159.26 62.95,159.34 62.83,159.45 61.46,159.45 60.53,158.52 60.53,141.3 80.97,120.86 83.58,120.86 v3(83.79,121.07) ; U29.P3 132.41,65.19 132.72,64.89 132.72,64.63 132.66,64.58 132.66,64.15 132.47,63.97 132.47,63.74 131.57,62.83 131.57,60.56 131.01,60.01 131.01,58.58 131.83,57.77 131.83,57.39 v3(132.21,57.01)
  BOTTOM w0.102: 89.31,120.81 96.11,120.81 109.12,107.8 109.12,92.54 108.36,91.78 108.36,67.84 118.71,57.49 131.72,57.49 v3(132.21,57.01) ; 89.31,120.81 v2(89.31,121.12) ; 89.31,120.81 84.06,120.81 v3(83.79,121.07)
FP_CBL_DET: length 3.9
  TOP w0.203: v1(53.37,54.29) 53.31,54.24 53.31,53.6 52.87,53.16 U24.50
  TOP w0.508: v1(53.37,54.29) 52.98,54.67 52.98,54.93 52.87,55.04 R458.1
FP_RST_PCH_N: length 189.9
  TOP w0.102: v4(131.77,84.41) 131.77,84.41 131.59,84.22 131.59,83.42 U29.N36
  L4 w0.127: v3(66.8,203.06) 66.48,203.06 66.14,202.71 64.19,202.71 58.76,197.28 58.76,187.86 60.39,186.23 60.39,185.16 57.58,182.36 57.58,169.22 56.76,168.4 56.76,149.21 79.27,126.7 93.24,126.7 97.16,122.79 101.09,122.79 103.74,125.44 117.54,125.44 131.06,111.91 131.06,110.14 131.13,110.08 131.13,109.6 130.79,109.27 129.58,109.27 v3(126.19,105.88)
  BOTTOM w0.102: R744.1 66.55,203.31 v3(66.8,203.06) ; v4(131.77,84.41) 131.71,84.47 131.71,87.86 130.38,89.19 129.49,89.19 127,91.67 127,97.3 127.3,97.61 127.3,97.69 127.41,97.79 127.41,97.93 127.43,97.95 127.43,98.71 127.43,98.72 127.43,99.09 127.43,99.34 R869.1 128.12,100.94 128.12,102.37 v2(128,102.49) 127.03,103.46 126.39,103.46 126.11,103.74 126.11,105.8 v3(126.19,105.88)
FWH_ID0: length 5.4
  TOP w0.102: LPC1.6 126.3,42.82 127.73,44.25 R509.2
G_H_DDCDA_1: length 22.3
  TOP w0.102: U34.3 34.8,8.44 35.43,9.08 35.43,11.16 v3(34.42,12.18)
  BOTTOM w0.102: R1114.1 32.51,22.42 C722.1 31.7,21.46 R1115.2 30.02,18.82 30.02,11.99 30.8,11.21 v2(33.27,11.21) 33.45,11.21 v3(34.42,12.18)
G_H_DDCSCL_1: length 8.5
  TOP w0.102: U34.6 32.37,11.05 v3(30.99,12.43)
  BOTTOM w0.102: v3(30.99,12.43) 31.01,12.46 v2(32.16,12.46) 32.94,13.24 R1117.1 32.49,14.02 32.49,14.93 C727.1 32.98,16.39 R1116.2
GPIO17_THERMAL_INT: length 36
  TOP w0.102: R345.2 110.61,79.93 109.35,81.19 109.35,81.45 109.29,81.51 109.29,81.57 109.22,81.64 109.16,81.64 109.08,81.72 108.7,81.72 108.5,81.52 108.08,81.52 v1(107.77,81.21) 105.99,79.44 103.37,79.44 R1186.2 R1183.2 96.08,80.18 94.87,78.98 92.33,78.98 91.74,78.38 88.44,78.38 88.15,78.67 87.35,78.67 87.09,78.41 86.81,78.41 86.55,78.67 85.75,78.67 85.49,78.41 85.21,78.41 84.72,78.9 84.24,78.9 83.99,79.16 81.27,79.16 81.02,79.4 81.02,79.54 80.69,79.87 79.3,79.87 78.97,79.54 U13.R6
GPIO19_CTF: length 57.3
  TOP w0.102: R329.2 111.32,82.28 v1(109.88,82.28) v3(108.84,82.28) ; U13.M2 76.55,74.97 76.99,74.53 77.15,74.53 v4(77.17,74.51) 77.19,74.49 77.38,74.49 77.51,74.36 77.61,74.36 77.95,74.02 77.95,73.55 78.27,73.24 78.49,73.24 78.74,72.98 R1185.1
  L4 w0.127: v3(86.56,75.09) 93.32,75.09 94.4,74.01 100.57,74.01 v3(108.84,82.28)
  BOTTOM w0.102: v4(77.17,74.51) 77.05,74.39 76.55,74.39 76.17,74.02 76.17,73.14 74.96,71.92 74.96,70.8 76.96,68.79 79.95,68.79 80.03,68.87 82.28,68.87 84.32,70.91 84.32,72.17 84.28,72.21 84.28,73 86.37,75.09 v3(86.56,75.09)
GPIO19_CTF_R: length 10.1
  TOP w0.102: D7.3 112.84,79.53 R329.1 112.84,82.55 v1(113.21,82.91) 113.64,82.91 113.86,82.7 R391.1 ; D7.3 110.74,80.77 R345.1 ; D7.3 112.09,78.79 R356.1
GPIO_8_ROMSO: length 45.5
  TOP w0.102: v3(89.15,74.15) 89.51,73.8 v1(89.51,71.41) 89.51,69.83 90.12,69.22 90.12,62.15 89.36,61.39 89.36,58.58 90.29,57.64 91.92,57.64 92.36,58.09 R1169.1 ; U13.P10 78.35,82.72 78.89,82.18 v4(78.89,82.15)
  L3 w0.127: v3(89.15,74.15) 93.09,78.09 93.09,78.29 93.08,78.3 93.08,78.84 93.09,78.85 93.09,82.53 92.84,82.79 79.53,82.79 v4(78.89,82.15)
GPIO_9_ROMSI: length 25.8
  TOP w0.102: v3(86.87,76.18) 87.19,75.87 90.68,75.87 v1(94.5,72.04) 95.12,71.42 R1171.2 ; v4(78.11,75.98) 77.8,76.29 77.78,76.29 77.55,76.52 77.55,76.86 77.68,76.99 77.68,77.28 77.65,77.31 77.65,77.77 77.68,77.8 77.68,77.87 U13.P4
  BOTTOM w0.102: v3(86.87,76.18) 84,73.31 83.9,73.31 83.4,72.81 81.2,72.81 79.7,74.3 79.37,74.3 79.09,74.59 79.08,74.59 78.79,74.88 78.79,75.29 v4(78.11,75.98)
GPIO_10_ROMSCK: length 23.4
  TOP w0.102: U13.P2 78.15,76.77 v4(78.08,76.7) ; v3(85.98,76.18) 86.64,75.52 89.97,75.52 v1(92.25,73.24) 93.98,71.51 R1170.2
  BOTTOM w0.102: v3(85.98,76.18) 85.34,75.55 85.34,75.04 83.31,73.01 81.28,73.01 79.78,74.51 79.46,74.51 79.07,74.89 79.07,75.7 v4(78.08,76.7)
GPIO_22_ROMCS#: length 46.7
  TOP w0.102: v3(89.92,74.28) 90.55,73.64 v1(90.55,69.88) 90.55,62.09 89.59,61.13 89.59,58.67 90.17,58.09 R1168.1 ; v4(76.53,81.62) 77.01,81.14 U13.N8
  L3 w0.127: v3(89.92,74.28) 93.34,77.71 93.34,78.36 93.31,78.4 93.31,78.75 93.34,78.78 93.34,82.66 92.95,83.06 78.54,83.06 77.11,81.62 v4(76.53,81.62)
GPIO_SVC: length 5.5
  TOP w0.102: U13.AJ11 89.77,83.54 90.12,83.19 93.45,83.19 TP165.1
GPIO_SVD: length 4.8
  TOP w0.102: U13.AK12 90.61,83.88 93.8,83.88 TP163.1
GPIO_SVT: length 4
  TOP w0.102: TP164.1 94.24,83.54 U13.AL11
GPIO_VGA_03_DATA: length 12.5
  TOP w0.102: R1165.1 103.13,82.28 103.36,82.51 103.57,82.51 RN9.2 103.81,87.54 v1(104.11,87.83) 105.16,88.88 107.69,88.88 108.56,88.02 108.56,87.71 Q123.4
GPIO_VGA_03_DATA_R: length 21.7
  TOP w0.102: R1165.2 v1(100.2,82.28) 97.82,82.28 96.34,80.81 81.41,80.81 81.08,81.14 U13.U8
GPIO_VGA_04_CLK: length 7.5
  TOP w0.102: R1166.1 102.62,81.26 103.5,82.15 104.09,82.15 104.34,82.4 104.34,82.63 RN9.1 104.47,83.88 v1(105.19,84.6) 105.77,85.18 106.94,85.18 Q123.1
GPIO_VGA_04_CLK_R: length 22.3
  TOP w0.102: U13.U7 81.14,80.34 81.47,80.01 83.75,80.01 84.08,79.68 84.08,79.54 84.41,79.21 94.34,79.21 95.71,80.58 96.73,80.58 97.05,80.91 v1(98.42,80.91) 98.43,80.91 101.31,80.91 R1166.2
GPU_CLKA0_T: length 3.1
  TOP w0.102: R215.2 R209.2 45.34,100.38 C158.2 43.69,100.38 v1(43.5,100.19)
GPU_CLKA1_T: length 3.2
  TOP w0.102: R352.2 44.33,79.6 v1(44.2,79.74) 44,79.93 C207.1 R341.2
GPU_DMINUS: length 52.9
  TOP w0.127: 67.26,55.99 69.12,55.99 75.44,62.31 75.44,64.18 C245.2 76.46,65.21 Q53.E 79.19,65.21 79.77,65.78 79.77,66.44 81.93,68.6 81.93,69.64 83.25,70.96 83.25,75.34 82.02,76.56 79.88,76.56 79.75,76.7 U13.T2 ; 67.26,55.99 66.1,55.99 62.29,52.18 61.65,52.18 59.92,50.46 56.46,50.46 56.07,50.85 U24.42 56.07,52.88 55.92,53.02 55.92,53.65 57.28,55 57.28,55.09 C255.2 ; 67.26,55.99 v1(67.26,55.66)
GPU_DPLUS: length 54.2
  TOP w0.127: v1(69.52,57.24) 69.76,56.99 ; 69.76,56.99 69.01,56.24 66,56.24 62.19,52.43 61.54,52.43 59.82,50.71 56.57,50.71 56.47,50.81 U24.41 56.47,52.83 56.25,53.05 56.17,53.13 56.17,53.54 57.53,54.9 57.53,55.09 C255.1 ; 69.76,56.99 75.18,62.41 75.18,64.82 C245.1 75.69,66.02 76.84,67.18 Q53.B 78.08,66.19 Q53.C 79.16,66.19 81.67,68.7 81.67,69.75 82.99,71.07 82.99,75.23 81.92,76.31 79.78,76.31 79.41,76.68 79.41,78 U13.T4
GPU_GPIO16: length 5.4
  TOP w0.102: U13.M4 76.55,78.02 76.88,77.69 76.88,77.4 76.83,77.36 76.83,75.42 76.99,75.27 77.57,74.69 TP155.1
GPU_SCL: length 4.1
  TOP w0.102: U13.R1 78.95,75.53 79.07,75.41 79.07,74.9 80.17,73.8 TP149.1
GPU_SDA: length 6.8
  TOP w0.102: TP150.1 81.06,72.37 79.78,73.65 79.78,73.87 78.87,74.79 78.87,75.33 78.71,75.48 78.71,76.91 78.62,77 78.62,77.17 arc(78.64,77.26) 78.68,77.34 78.95,77.61 U13.R3
GPU_THERM_SHUTDOWN*: length 100.8
  TOP w0.102: R354.1 108.27,79.7 108.28,79.71 108.31,79.71 v1(108.31,79.77) 108.9,80.36 v3(108.9,80.45) ; PR18.1 v3(51,143.82)
  L4 w0.127: v3(108.9,80.45) 108.99,80.45 109.69,81.15 109.69,102.34 98.44,113.59 83.54,113.59 53.3,143.82 v3(51,143.82)
GPU_THERMAL_INT: length 91.6
  TOP w0.102: v3(43.54,41.62) 43.16,41.62 42.91,41.87 42.91,42.42 43.04,42.55 v1(43.54,42.55) 43.61,42.55 44.59,41.58 U24.87 ; v3(101.6,77.33) 101.66,77.39 R1184.2 101.6,78.28 R1183.1
  L3 w0.127: v3(101.6,77.33) 101.6,75.41 100.33,74.14 100.33,72.01 98.95,70.62 98.95,69.54 89.35,59.94 86.69,59.94 83.66,62.98 76.74,62.98 76.22,62.98 72.23,58.99 66.51,58.99 63.07,55.55 62.96,55.55 47.5,55.55 42.96,51.01 42.96,46.03 43.9,45.09 43.9,41.99 v3(43.54,41.62)
GPU_VREFG: length 7.2
  TOP w0.254: v4(85.92,86.7) 85.92,86.77 U13.AC16
  BOTTOM w0.508: v4(85.92,86.7) 85.95,86.67 86.56,86.67 86.72,86.52 88.7,86.52 v2(88.82,86.39) 89.29,85.93 89.29,85.77 R1210.2 C558.1 R1211.1
GPU_WAKEB: length 7.6
  TOP w0.102: U13.AJ27 90.09,96 90.42,96 90.62,95.8 90.62,95.4 90.81,95.21 91.21,95.21 93.22,93.2 94.61,93.2 v1(94.67,93.25) 94.79,93.13 R1187.2
GPU_XO_IN: length 18.8
  TOP w0.102: R1190.1 v1(101.85,91.68) 100.58,92.95 97.6,92.95 97.19,92.54 94.11,92.54 93.72,92.92 93.22,92.92 92.97,92.67 88.41,92.67 88.21,92.47 86.01,92.47 85.68,92.14 U13.AC22
GPU_XO_IN2: length 18.2
  TOP w0.102: R1191.1 100.71,91.55 v1(100.58,91.68) 99.97,92.29 96.67,92.29 96.64,92.31 94.05,92.31 93.64,92.72 93.3,92.72 92.8,92.21 91.65,92.21 91.31,91.87 88.04,91.87 87.97,91.81 85.08,91.81 U13.AB22
GPUPG_1: length 7.2
  TOP w0.254: Q55.D R433.1 R428.2 52.09,64.35 52.91,63.53 Q56.G 52.91,61.55 v1(52.92,61.54)
GPUPG_2: length 5.1
  TOP w0.254: R422.2 R423.1 53,66.63 v1(53.8,66.63) 54.54,66.63 R426.1 54.72,65.68 Q56.D
GPUPG_3: length 18.6
  TOP w0.254: Q57.4 64.77,58.4 v1(64.26,57.9) 60.54,57.9 60.39,58.05 59.66,58.05 57.02,60.69 57.02,63.86 55.61,65.28 R426.2 C239.1
GREEN_CRT: length 35.1
  TOP w0.102: v3(32.82,18.58) 32.82,18.63 32.7,18.74 C349.1 32.63,19.49 L21.2
  L3 w0.127: v3(46.55,18.9) 47.85,17.6 53.09,17.6 54.07,16.61 54.07,13.31 VGA1.2
  BOTTOM w0.102: v3(46.55,18.9) 46.33,19.12 46.33,19.38 46.38,19.44 46.38,20.36 44.71,22.03 44.48,22.03 43.09,23.43 42.39,23.43 40.92,24.9 38.64,24.9 38.13,24.39 37.78,24.39 37.39,24 U43.3 36.53,23.01 35.32,21.8 35.32,21.63 v2(35.01,21.32) 32.82,19.13 v3(32.82,18.58)
H_CPURST_N: length 35.9
  TOP w0.102: R61.1 67.11,209.92 R63.1 67.18,209.28 66.8,208.9 v1(66.8,208.64) 66.8,207.02 66.44,206.66 R72.2 66.39,206.5 C38.1 68.49,205.98 71.64,205.98 77.19,200.43 77.19,197.97 74.63,195.4 74.63,189.46 72.4,187.24 72.4,185.75 72.83,185.32 CPU1.M39
H_CPURST_SIO_N: length 2.7
  BOTTOM w0.102: Q102.E v2(56.55,41.93) 56.71,41.77 R1032.2
H_CPURST_SIO_N_1: length 6.1
  BOTTOM w0.102: Q102.B 58.57,43.41 58.57,47.58 58.17,47.99 R1017.1 59.04,48.31 v2(59.11,48.37)
H_DRAMPWRGD: length 177.2
  TOP w0.102: v3(126.87,121.95) 126.42,122.41 126.42,124.62 125.98,125.05 125.98,190.81 127.79,192.61 127.79,201.89 128.47,202.57 128.47,204.76 v3(127.13,206.1) ; v4(137.44,91.53) 137.82,91.14 137.82,90.42 138.02,90.21 138.02,87.58 138.63,86.98 138.63,86.64 138.51,86.52 138.51,84.7 138.21,84.4 U29.AE38
  L4 w0.127: v3(126.87,121.95) 135.58,113.25 135.58,108.55 135.55,107.28 135.49,107.22 135.49,99.6 v3(135.61,99.48)
  BOTTOM w0.102: v4(137.44,91.53) 137.44,93.86 137.61,94.04 137.61,95.35 137.77,95.51 137.77,96.49 137.52,96.74 137.52,97.28 137.72,97.49 137.72,97.86 136.11,99.48 v3(135.61,99.48) ; v3(127.13,206.1) 126.91,206.1 126.46,205.65 125.65,205.65 125.08,205.08 125.08,204.57 v2(124.59,204.07) 124.58,204.08 122.18,204.08 120.29,202.19 118.08,202.19 117.58,201.69 114.6,201.69 112.09,204.2 90.93,204.2 90.11,205.03 88.07,205.03 86.3,203.25 R757.2 86.3,202.11 R764.1 R765.1
H_DRAMPWRGD_CPU: length 37.2
  TOP w0.102: v3(88.84,169.06) CPU1.AK21
  BOTTOM w0.102: v3(88.84,169.06) 88.84,169.17 88.23,169.77 85.23,169.77 84.84,170.16 84.84,178.04 84.66,178.21 84.66,182.53 84.69,182.56 84.69,184.76 84.34,185.11 84.34,198.11 v2(85.43,199.21) 86.22,199.99 R764.2
H_PECI: length 235.7
  TOP w0.102: v3(123.52,88.76) 123.35,88.58 121.85,88.58 119.35,91.08 118.93,91.08 118.77,91.24 118.77,91.91 118.27,92.41 R269.2 ; R473.1 v3(66.27,53.32) 66.34,53.32 66.88,53.86 v1(66.88,54.06) ; v3(74.21,183.69) CPU1.N37
  L3 w0.127: v3(74.21,183.69) 74.1,183.69 73.65,184.14 64.88,184.14 64.87,184.13 61.34,184.13 59.94,185.53 v3(59.94,185.78) ; v3(66.27,53.32) 67.86,54.91 68.91,54.91 70.33,56.33 89.67,56.33 93.91,60.58 102.25,60.58 116.2,74.53 116.2,75.06 120.02,78.87 120.02,80.12 121.15,81.25 121.15,81.35 121.79,81.99 121.79,84.5 122.22,84.93 122.22,85.06 122.24,85.07 122.24,87.47 v3(123.52,88.76)
  L4 w0.127: v3(123.52,88.76) 123.08,89.2 123.08,90.64 116.46,97.27 116.46,103.23 97.28,122.41 97,122.41 93.09,126.32 79.11,126.32 60.69,144.74 60.69,144.78 56.5,148.97 56.5,168.63 57.2,169.33 57.2,182.66 59.94,185.4 v3(59.94,185.78)
H_PM_SYNC_0: length 194
  TOP w0.102: v3(75.12,181.87) CPU1.P36 ; U29.F40 127.61,85.31 127.61,86.15 126.83,86.92 126.83,86.93 126.59,87.17 126.46,87.17 126.24,87.39 120.96,87.39 v1(120.6,87.74) 120.35,87.99 v3(119.77,87.99)
  L4 w0.127: v3(119.77,87.99) 119.89,87.99 120.28,88.39 120.28,89.61 114.55,95.34 114.55,102.47 93.47,123.55 80.1,123.55 56.05,147.61 56.05,168.82 56.74,169.52 56.74,188.05 57.66,188.96 57.66,197.26 64.44,204.03 68.75,204.03 70.57,202.21 70.57,190.06 74.68,185.96 74.68,182.31 v3(75.12,181.87)
