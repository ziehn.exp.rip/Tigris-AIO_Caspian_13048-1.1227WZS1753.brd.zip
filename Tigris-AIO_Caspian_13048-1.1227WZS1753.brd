# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Nets (continued)
M_MAA_A13: CPU1.AY10 DIMM1.119
M_MAA_A14: CPU1.AT20 DIMM1.80
M_MAA_A15: CPU1.AU21 DIMM1.78
M_MAA_B0: CPU1.AL19 DIMM2.98
M_MAA_B1: CPU1.AK23 DIMM2.97
M_MAA_B2: CPU1.AM22 DIMM2.96
M_MAA_B3: CPU1.AM23 DIMM2.95
M_MAA_B4: CPU1.AP23 DIMM2.92
M_MAA_B5: CPU1.AL23 DIMM2.91
M_MAA_B6: CPU1.AY24 DIMM2.90
M_MAA_B7: CPU1.AV25 DIMM2.86
M_MAA_B8: CPU1.AU26 DIMM2.89
M_MAA_B9: CPU1.AW25 DIMM2.85
M_MAA_B10: CPU1.AP18 DIMM2.107
M_MAA_B11: CPU1.AY25 DIMM2.84
M_MAA_B12: CPU1.AV26 DIMM2.83
M_MAA_B13: CPU1.AR15 DIMM2.119
M_MAA_B14: CPU1.AV27 DIMM2.80
M_MAA_B15: CPU1.AY28 DIMM2.78
M_ODT_A0: CPU1.AW10 DIMM1.116
M_ODT_A1: CPU1.AY8 DIMM1.120
M_ODT_B0: CPU1.AM17 DIMM2.116
M_ODT_B1: CPU1.AL16 DIMM2.120
M_RAS_A_N: CPU1.AU12 DIMM1.110
M_RAS_B_N: CPU1.AM18 DIMM2.110
M_SBS_A0: CPU1.AV12 DIMM1.109
M_SBS_A1: CPU1.AY11 DIMM1.108
M_SBS_A2: CPU1.AT21 DIMM1.79
M_SBS_B0: CPU1.AK17 DIMM2.109
M_SBS_B1: CPU1.AL18 DIMM2.108
M_SBS_B2: CPU1.AW28 DIMM2.79
M_SCKE_A0: CPU1.AV22 DIMM1.73
M_SCKE_A1: CPU1.AT23 DIMM1.74
M_SCKE_B0: CPU1.AW29 DIMM2.73
M_SCKE_B1: CPU1.AY29 DIMM2.74
M_SCS_A_N0: CPU1.AU14 DIMM1.114
M_SCS_A_N1: CPU1.AV9 DIMM1.121
M_SCS_B_N0: CPU1.AP17 DIMM2.114
M_SCS_B_N1: CPU1.AN15 DIMM2.121
M_WE_A_N: CPU1.AU11 DIMM1.113
M_WE_B_N: CPU1.AK16 DIMM2.113
MAA0: MEM1.N3 MEM2.N3 MEM3.N3 MEM4.N3 U13.K17
MAA1: MEM1.P7 MEM2.P7 MEM3.P7 MEM4.P7 U13.J20
MAA2: MEM1.P3 MEM2.P3 MEM3.P3 MEM4.P3 U13.H23
MAA3: MEM1.N2 MEM2.N2 MEM3.N2 MEM4.N2 U13.G23
MAA4: MEM1.P8 MEM2.P8 MEM3.P8 MEM4.P8 U13.G24
MAA5: MEM1.P2 MEM2.P2 MEM3.P2 MEM4.P2 U13.H24
MAA6: MEM1.R8 MEM2.R8 MEM3.R8 MEM4.R8 U13.J19
MAA7: MEM1.R2 MEM2.R2 MEM3.R2 MEM4.R2 U13.K19
MAA8: MEM1.T8 MEM2.T8 MEM3.T8 MEM4.T8 U13.J14
MAA9: MEM1.R3 MEM2.R3 MEM3.R3 MEM4.R3 U13.K14
MAA10: MEM1.L7 MEM2.L7 MEM3.L7 MEM4.L7 U13.J11
MAA11: MEM1.R7 MEM2.R7 MEM3.R7 MEM4.R7 U13.J13
MAA12: MEM1.N7 MEM2.N7 MEM3.N7 MEM4.N7 U13.H11
MAA13: MEM1.T3 MEM2.T3 MEM3.T3 MEM4.T3 U13.G20
MAA_BA0: MEM1.M2 MEM2.M2 MEM3.M2 MEM4.M2 U13.J16
MAA_BA1: MEM1.N8 MEM2.N8 MEM3.N8 MEM4.N8 U13.L15
MAA_BA2: MEM1.M3 MEM2.M3 MEM3.M3 MEM4.M3 U13.G11
MB_REG_PG: Q106.6 Q109.3 Q109.6 Q111.6 R566.2 U24.109
MB_REG_PG_1: Q111.2 R1075.1 R1082.2
MB_REG_PG_2: Q109.5 R1042.1 R1049.2
MB_REG_PG_3: Q109.2 R1057.2 R1058.1
MB_SKU_ID0: R318.1 R322.2 U29.N32
MB_SKU_ID1: R233.1 R234.2 U29.M40
MB_SKU_ID2: R871.1 R872.2 U29.AV34
MCLK: RN5.2(A) U24.115
MDA0: MEM3.F8 U13.K27
MDA1: MEM3.F7 U13.J29
MDA2: MEM3.H3 U13.H30
MDA3: MEM3.E3 U13.H32
MDA4: MEM3.G2 U13.G29
MDA5: MEM3.F2 U13.F28
MDA6: MEM3.H8 U13.F32
MDA7: MEM3.H7 U13.F30
MDA8: MEM3.D7 U13.C30
MDA9: MEM3.C8 U13.F27
MDA10: MEM3.B8 U13.A28
MDA11: MEM3.A7 U13.C28
MDA12: MEM3.A3 U13.E27
MDA13: MEM3.A2 U13.G26
MDA14: MEM3.C2 U13.D26
MDA15: MEM3.C3 U13.F25
MDA16: MEM1.A2 U13.A25
MDA17: MEM1.C2 U13.C25
MDA18: MEM1.A3 U13.E25
MDA19: MEM1.C3 U13.D24
MDA20: MEM1.A7 U13.E23
MDA21: MEM1.D7 U13.F23
MDA22: MEM1.B8 U13.D22
MDA23: MEM1.C8 U13.F21
MDA24: MEM1.G2 U13.E21
MDA25: MEM1.E3 U13.D20
MDA26: MEM1.H3 U13.F19
MDA27: MEM1.F2 U13.A19
MDA28: MEM1.H8 U13.D18
MDA29: MEM1.H7 U13.F17
MDA30: MEM1.F7 U13.A17
MDA31: MEM1.F8 U13.C17
MDA32: MEM4.F8 U13.E17
MDA33: MEM4.H8 U13.D16
MDA34: MEM4.F7 U13.F15
MDA35: MEM4.H7 U13.A15
MDA36: MEM4.H3 U13.D14
MDA37: MEM4.G2 U13.F13
MDA38: MEM4.E3 U13.A13
MDA39: MEM4.F2 U13.C13
MDA40: MEM2.C3 U13.E11
MDA41: MEM2.A3 U13.A11
MDA42: MEM2.A2 U13.C11
MDA43: MEM2.C2 U13.F11
MDA44: MEM2.A7 U13.A9
MDA45: MEM2.B8 U13.C9
MDA46: MEM2.D7 U13.F9
MDA47: MEM2.C8 U13.D8
MDA48: MEM2.E3 U13.E7
MDA49: MEM2.H3 U13.A7
MDA50: MEM2.F2 U13.C7
MDA51: MEM2.G2 U13.F7
MDA52: MEM2.H8 U13.A5
MDA53: MEM2.F7 U13.E5
MDA54: MEM2.H7 U13.C3
MDA55: MEM2.F8 U13.E1
MDA56: MEM4.D7 U13.G7
MDA57: MEM4.C8 U13.G6
MDA58: MEM4.A2 U13.G1
MDA59: MEM4.A7 U13.G3
MDA60: MEM4.B8 U13.J6
MDA61: MEM4.C2 U13.J1
MDA62: MEM4.C3 U13.J3
MDA63: MEM4.A3 U13.J5
MDAT: RN5.1(A) U24.116
ME_CNTL: R419.2 R903.1 R914.2 U29.W35
ME_CNTL1: Q52.B R419.1
ME_CNTL2: Q52.E R421.2
MEM_CALRP0: R1201.2 U13.K25
MEM_COMP: R104.1 U4.3
MEM_REG_PG: Q106.3 R567.2 U24.111
MEM_REG_PG_1: Q106.5 R1029.1 R1030.2
MEM_REG_PG_2: Q106.2 R1037.2
MEM_RST: MEM1.T2 MEM2.T2 MEM3.T2 MEM4.T2 R1203.2 R1204.2
MIC2-L: C176.1 U16.47
MIC2-L_1: C176.2 R1121.1
MIC2-R: C175.1 U16.48
MIC2-R_1: C175.2 R1122.1
MIC2-VREFO-L: R265.1 U16.1
MIC2-VREFO-R: R324.1 U16.30
MIC-CAP: C201.1 U16.36
MLPS_EN#: R1193.1 U13.R5
MPCIE_DISABLE_N: R9.1 R923.1 U29.AG35
MPV18: C786.1 C790.1 C791.1 L50.2 U13.L8
MVREFDA: C760.1 R1197.1 R1199.2 U13.K26
MVREFSA: C761.1 R1198.1 R1200.2 U13.J26
NGFF_ALERT_N: NGFF1.62 R16.2
NGFF_BT_DISABLE: R8.1 R258.2 U29.AD40
NGFF_CLKREQ0_N: NGFF1.53 R676.1
NGFF_CLKREQ1_N: NGFF1.68 R17.2
NGFF_DETECT_PCIE: R374.2 R1155.2 U29.AT27
NGFF_DETECT_PCIE_C: NGFF1.51 R1155.1 R1208.1
NGFF_DETECT_USB: R346.2 R1154.2 U29.AR30
NGFF_DETECT_USB_C: NGFF1.1 R1154.1 R1209.1
NGFF_PCIE0_RXN: NGFF1.43 R664.1
NGFF_PCIE0_RXP: NGFF1.41 R659.1
NGFF_PCIE0_TXN: NGFF1.37 R672.1
NGFF_PCIE0_TXP: NGFF1.35 R669.1
NGFF_PCIE1_RXN: NGFF1.67 R685.1
NGFF_PCIE1_RXP: NGFF1.65 R680.1
NGFF_PCIE1_TXN: NGFF1.61 R27.1
NGFF_PCIE1_TXP: NGFF1.59 R24.1
NGFF_PEWAKE0_N: NGFF1.55 NGFF1.70 R19.2 R20.1
NGFF_POWER_CTRL: R15.1 R385.1 U29.AN22
NGFF_POWER_CTRL_1: Q3.G R11.2 R15.2
NGFF_POWER_CTRL_V2: C864.1 Q128.B R1228.1
NGFF_REFCLKN0: NGFF1.49 R23.1
NGFF_REFCLKN1: NGFF1.73 R26.1
NGFF_REFCLKP0: NGFF1.47 R22.1
NGFF_REFCLKP1: NGFF1.71 R25.1
NGFF_W_DISABLE1_N: NGFF1.56 R9.2
NGFF_W_DISABLE2_N: NGFF1.54 R8.2
OCP_6: Q119.D Q120.G R1146.2 R1149.1
OCP_7: Q118.G Q120.D R1143.1 R1144.2 U46.4
OCP_7_1: Q118.D R1147.1
ODTA0: MEM1.K1 MEM3.K1 U13.L18
ODTA1: MEM2.K1 MEM4.K1 U13.K16
OSD_BIST_N: R94.1 R1063.2
OSD_BIST_N_1: Q20.B R94.2
OSD_DN: C312.1 R569.1 R571.1 U29.AM28
OSD_DN_R: D11.3 PWRCN1.9 R571.2
OSD_MENU: C703.1 R1078.1 R1083.1 U29.AT31
OSD_MENU_R: D21.3 PWRCN1.10 R1083.2
OSD_UP: C694.1 R1061.2 R1062.1 R1063.1 U29.AV29
OSD_UP_R: D20.3 PWRCN1.8 R1062.2
P25_GND: R475.1 U22.25 U23.25
P_GNT_N1: R335.1 U29.AU31
P_GNT_N2: R342.1 U29.AV31
P_GNT_N3: R916.1 U29.R30
P_INTA_N: RN2.1(A) U29.AU29
P_INTB_N: RN2.3(A) U29.AU27
P_INTC_N: RN2.2(A) U29.AW28
P_INTD_N: RN2.4(A) U29.AV27
P_PME#: R927.2 U29.AA31
PANEL_ON_1: R33.2 R36.1 R40.1 R41.2
PANEL_ON_2: Q7.B R40.2
PANEL_ON_3: C401.1 Q91.D R707.2 R708.1 U36.3
PANEL_ON_4: Q7.C Q90.G Q91.G R700.1 R702.2
PANEL_ON_5: Q90.D R706.1
PANEL_SEL1_CABLE: CONVT1.8 R164.2 R166.2
PANEL_SEL1_CABLE_PCH: R164.1 U29.AK28
PANEL_SEL2_CABLE: CONVT1.11 R185.2 R186.2
PANEL_SEL2_CABLE_PCH: R185.1 U29.AW33
PANEL_SEL3_CABLE: CONVT1.12 R188.2 R189.2
PANEL_SEL3_CABLE_PCH: R188.1 U29.AP28
PB_IN_SW1: D10.3 PWRCN1.5 R549.1
PC_SPKR_DET: R455.1 U24.54
PCH_1D05V_PG: Q86.3 R211.2 R634.1 U15.1
PCH_1D05V_PG_R: C366.1 R633.2 R634.2 U35.1
PCH_AUD_MUTE: R224.1 U29.AJ40
PCH_AUD_RST_N: R469.1 R925.2 U29.AC32
PCH_AUD_RST_N_1: Q62.5 R469.2
PCH_DPWROK: R480.2 U24.28 U29.AV38
PCH_GP8: R863.2 R873.1 R878.2 R879.2
PCH_GP27_PU: R313.1 R321.1 U29.AU34
PCH_GP33_PU: R381.2 R387.2 U29.AV26
PCH_GPIO20: R220.1 U29.P37
PCH_INTRUDER_L: INTRU1.1 R279.2
PCH_INTRUDER_N: R273.2 R279.1 U29.AR41
PCH_INTVRMEN: R298.2 R307.2 U29.AV36
PCH_JTAG_PWR: R862.2 R864.1 R865.1 R866.1
PCH_JTAG_RST_R: C160.1 R216.2 R217.1 R218.1 U29.W37
PCH_JTAG_TCK: C173.1 R254.1 U29.Y40
PCH_JTAG_TDI: R866.2 R891.1 TP112.1 U29.W39
PCH_JTAG_TDO: R864.2 R889.1 TP110.1 U29.Y38
PCH_JTAG_TMS: R865.2 R890.1 TP111.1 U29.W40
PCH_LVDS_BL_ADJ: R715.2 U29.AP2
PCH_MEPWROK_R: R287.2 U29.AA32
PCH_PCIECLKRQ1_N: R833.1 R1153.1 U29.P39
PCH_PCIECLKRQ5_N: Q1.D R223.1 U29.AA36
PCH_PCIECLKRQ5_N_1: Q1.S R2.2 R676.2
PCH_PCIECLKRQ6_N: Q2.D R905.1 U29.W32
PCH_PCIECLKRQ6_N_1: Q2.S R6.2 R17.1
PCH_RI: R911.1 U29.AE36
PCH_RSMRST_N: R275.2 R280.1 U29.AM40
PCH_RTCRST_DOWN: BTRST1.1 R314.1
PCH_RTCRST_PULLUP: BTRST1.2 C189.1 R297.1 R306.2 U29.AR38
PCH_RTCX1: C205.1 R312.1 U29.AN40 X1.4
PCH_RTCX2: C191.1 R300.2 R312.2 U29.AN39
PCH_SATA_LED_1: Q67.B Q68.C R504.2
PCH_SATA_LED_2: PWRCN1.3 Q67.C Q70.C
PCH_SATA_LED_N: R271.1 R507.1 U29.J39
PCH_SATA_LED_R: Q68.B R507.2
PCH_SLP_M_N: TP117.1 U29.AN37
PCH_SRTCRSTB_PULLUP: C188.1 R296.1 R297.2 R305.2 U29.AR39
PCH_SYSPWROK: C548.1 R887.2 R888.2 U29.W31
PCIAUX_GATE: R527.2 U24.92
PCIE_CALR_RX: R1162.1 U13.AA22
PCIE_CALR_TX: R1161.1 U13.Y22
PCIE_RST#: NGFF1.52 NGFF1.66 R1009.1
PCIRST1#: R457.2 R459.2 R460.2 U24.51
PCIRST2#: R1009.2 R1011.2 R1012.2 U24.52
PECI_PCH: C174.1 R269.1 U29.G40
PECI_READY: R1004.2 U24.31
PECI_REQ_N: R266.1 R1019.1 U29.G38
PECI_SIO_R: R473.2 U24.30
PEG_C_RXN0: C736.1 U13.AG31
PEG_C_RXN1: C741.1 U13.AF28
PEG_C_RXN2: C750.1 U13.AF26
PEG_C_RXN3: C738.1 U13.AD26
PEG_C_RXN4: C747.1 U13.AB25
PEG_C_RXN5: C744.1 U13.Y24
PEG_C_RXN6: C737.1 U13.AB26
PEG_C_RXN7: C749.1 U13.Y26
PEG_C_RXP0: C740.1 U13.AH30
PEG_C_RXP1: C748.1 U13.AG29
PEG_C_RXP2: C743.1 U13.AF27
PEG_C_RXP3: C745.1 U13.AD27
PEG_C_RXP4: C739.1 U13.AC25
PEG_C_RXP5: C751.1 U13.Y23
PEG_C_RXP6: C746.1 U13.AB27
PEG_C_RXP7: C742.1 U13.Y27
PEG_C_TXN0: C139.1 CPU1.L2
PEG_C_TXN1: C152.1 CPU1.M3
PEG_C_TXN2: C137.1 CPU1.K3
PEG_C_TXN3: C150.1 CPU1.J2
PEG_C_TXN4: C135.1 CPU1.H3
PEG_C_TXN5: C148.1 CPU1.G2
PEG_C_TXN6: C133.1 CPU1.F3
PEG_C_TXN7: C146.1 CPU1.E2
PEG_C_TXP0: C140.1 CPU1.L1
PEG_C_TXP1: C153.1 CPU1.M2
PEG_C_TXP2: C138.1 CPU1.K2
PEG_C_TXP3: C151.1 CPU1.J1
PEG_C_TXP4: C136.1 CPU1.H2
PEG_C_TXP5: C149.1 CPU1.G1
PEG_C_TXP6: C134.1 CPU1.F2
PEG_C_TXP7: C147.1 CPU1.E1
PEG_COMP: CPU1.P3 R831.2
PEG_RXN0: C736.2 CPU1.L5
PEG_RXN1: C741.2 CPU1.K6
PEG_RXN2: C750.2 CPU1.J5
PEG_RXN3: C738.2 CPU1.H6
PEG_RXN4: C747.2 CPU1.G5
PEG_RXN5: C744.2 CPU1.F6
PEG_RXN6: C737.2 CPU1.E5
PEG_RXN7: C749.2 CPU1.D4
PEG_RXP0: C740.2 CPU1.L4
PEG_RXP1: C748.2 CPU1.K5
PEG_RXP2: C743.2 CPU1.J4
PEG_RXP3: C745.2 CPU1.H5
PEG_RXP4: C739.2 CPU1.G4
PEG_RXP5: C751.2 CPU1.F5
PEG_RXP6: C746.2 CPU1.E4
PEG_RXP7: C742.2 CPU1.D3
PEG_TXN0: C139.2 U13.AE31
PEG_TXN1: C152.2 U13.AD28
PEG_TXN2: C137.2 U13.AC31
PEG_TXN3: C150.2 U13.AB28
PEG_TXN4: C135.2 U13.AA31
PEG_TXN5: C148.2 U13.Y28
PEG_TXN6: C133.2 U13.W31
PEG_TXN7: C146.2 U13.V28
PEG_TXP0: C140.2 U13.AF30
PEG_TXP1: C153.2 U13.AE29
PEG_TXP2: C138.2 U13.AD30
PEG_TXP3: C151.2 U13.AC29
PEG_TXP4: C136.2 U13.AB30
PEG_TXP5: C149.2 U13.AA29
PEG_TXP6: C134.2 U13.Y30
PEG_TXP7: C147.2 U13.W29
PHASE1_R: PG4.1 PR45.2 PR46.2
PLTRST*_SIO: R1034.1 U24.14
PLTRST_CPU_N: R72.1 R638.1 U29.F41
PLTRST_CPU_N1: Q11.5 Q11.6 R57.2
PLTRST_CPU_N2: Q11.3 R61.2 R62.2
PLTRST_CR: R457.1 U39.14
PLTRST_LAN_N: R1012.1 U26.19
PLTRST_N: R59.1 R1032.1 R1034.2 U29.AA37
PLTRST_N_R: C25.1 Q11.2 R55.2 R59.2
PLTRST_SL_N: D7.2 LPC1.3 Q61.D R459.1 R472.1 R1159.1 R1160.2
PLTRST_TPM_N: Q61.S R471.2 R472.2 U22.16 U23.16
PM_DPRSLPVR: PR7.1 PR15.2 PR17.1
PORTC_SPK_L: C267.1 U16.43
PORTC_SPK_L_1: C267.2 R511.1
PORTC_SPK_R: C279.1 U16.44
PORTC_SPK_R_1: C279.2 R526.1
PRIVACY_MSR_EN_N: R646.1 XDPC1.60
PRW_VGA_CORE_RBIAS: PR9.1 U9.3
PS_0: C227.2 R388.1 R394.1 U13.AC19
PS_1: C593.2 R943.1 R948.1 U13.AD19
PS_2: C200.1 R294.1 R303.1 U13.AE17
PS_3: C565.1 R935.2 R940.1 U13.AE20
PSI#: PR3.1 PR4.2 PR10.2
PSID_D: L8.2 Q37.D R155.1
PSID_D_1: Q36.B R155.2 R156.1
PSID_G: Q36.C Q37.G R150.2
PSPWRGD: ATX2.4 C116.1 R160.2 R161.2 R562.1
PW_CLEAR: PSWD1.2 R947.1 U29.AM36
PWM1: R666.1 U17.2 U35.12
PWM1_BT: R704.1 U17.1
PWM1_BT_1: C400.1 R704.2
PWM1_EN: R701.2 U17.3
PWM1_HG: R34.1 U17.8
PWM1_HG_1: Q8.4 Q12.4 R29.1 R34.2
PWM1_LG: Q5.4 Q6.4 U17.5
PWM1_LX: C400.2 G1.1 L1.1 Q5.5 Q5.6 Q5.7 Q5.8 Q6.5 Q6.6 Q6.7 Q6.8 Q8.1 Q8.2 Q8.3 Q12.1 Q12.2 Q12.3 R28.2 R29.2 U17.7
PWM1_SNB: C10.1 R28.1
PWM1_VCC: C395.2 R694.2 U17.4
PWM2: R657.1 U35.10 U38.2
PWM2_BT: R779.1 U38.1
PWM2_BT_1: C410.1 R779.2
PWM2_EN: R750.2 U38.3
PWM2_HG: R88.1 U38.8
PWM2_HG_1: Q21.4 Q23.4 R84.2 R88.2
PWM2_LG: Q16.4 Q17.4 U38.5
PWM2_LX: C410.2 G3.1 L5.1 Q16.5 Q16.6 Q16.7 Q16.8 Q17.5 Q17.6 Q17.7 Q17.8 Q21.1 Q21.2 Q21.3 Q23.1 Q23.2 Q23.3 R79.2 R84.1 U38.7
PWM2_SNB: C42.2 R79.1
PWM2_VCC: C403.2 R729.2 U38.4
PWM3: R662.1 U5.2 U35.11
PWM3_BT: R108.1 U5.1
PWM3_BT_1: C67.1 R108.2
PWM3_EN: R112.1 U5.3
PWM3_HG: R813.1 U5.8
PWM3_HG_1: Q24.4 Q25.4 R812.2 R813.2
PWM3_LG: Q27.4 Q28.4 U5.5
PWM3_LX: C67.2 G6.1 L6.1 Q24.1 Q24.2 Q24.3 Q25.1 Q25.2 Q25.3 Q27.5 Q27.6 Q27.7 Q27.8 Q28.5 Q28.6 Q28.7 Q28.8 R111.2 R812.1 U5.7
PWM3_SNB: C71.2 R111.1
PWM3_VCC: C75.2 R113.1 U5.4
PWM4: R655.1 U35.9
PWR2_PRSN_1: Q110.2 R1059.2 R1064.1
PWR2_PRSN_2: Q110.5 Q110.6 R1060.2
PWR2_PRSNT: Q110.3 R565.2 U24.108
PWR_5V_BOOT1_1: PC49.1 PR90.1
PWR_DEBUG: CPU1.N40 Q9.3 R64.1 R73.2 R74.2
PWR_DEBUG_1: Q9.5 Q9.6 R37.2
PWR_DEBUG_N: C20.1 Q9.2 R38.2 R42.2 R47.2 R51.1
PWR_LED_YELLOW_1: R1027.2 R1031.1
PWR_LED_YELLOW_C: PWRCN1.2 Q103.D R1031.2 R1033.1
PWR_VGA_CORE_BOOT1: PR43.1 U9.19
PWR_VGA_CORE_COMP: PC4.2 PC6.1 PC7.2 PC8.1 PR1.2 PR13.2 U9.7
PWR_VGA_CORE_DPRSLPVR: PR17.2 U9.39
PWR_VGA_CORE_FB: PC8.2 PR8.2 PR20.1 PR21.1 U9.8
PWR_VGA_CORE_FB2: PC4.1 PC5.2 U9.9
PWR_VGA_CORE_IMON: PC59.2 PR98.1 PR99.2 U9.18
PWR_VGA_CORE_ISEN1: PC10.2 PR12.2 PR46.1 U9.11
PWR_VGA_CORE_ISEN2: PR11.2 PR12.1 U9.10
PWR_VGA_CORE_ISUM+: PC15.1 PC16.1 PR34.1 PR41.1 PR42.1 PR45.1 U9.15
PWR_VGA_CORE_ISUM-: PC14.1 PR16.2 U9.14
PWR_VGA_CORE_LGATE1A: PU3.4 PU4.4 U9.23
PWR_VGA_CORE_LGATE1B: TP9.1 U9.24
PWR_VGA_CORE_NTC: PC9.1 PR60.2 U9.5
PWR_VGA_CORE_ON: PC12.1 PR18.2 PR19.2 U9.38
PWR_VGA_CORE_PGOOD: PR14.1 U9.1
PWR_VGA_CORE_PHASE1: PC19.1 PG4.2 PL1.1 PR114.1 PU1.1 PU1.2 PU1.3 PU2.1 PU2.2 PU2.3 PU3.5 PU3.6 PU3.7 PU3.8 PU4.5 PU4.6 PU4.7 PU4.8 U9.21
PWR_VGA_CORE_PSI#: PR10.1 U9.2
PWR_VGA_CORE_RTN: PC13.2 PC57.1 PC59.1 PR22.1 PR29.2 PR99.1 U9.13
PWR_VGA_CORE_SNB1: PC65.1 PR114.2
PWR_VGA_CORE_UGATE1: PR105.2 U9.20
PWR_VGA_CORE_UGATE1_R: PR105.1 PU1.4 PU2.4
PWR_VGA_CORE_VCCP: PC17.1 PC18.1 PR44.1 U9.25
PWR_VGA_CORE_VDD: PC58.1 PR95.2 PR98.2 U9.16
PWR_VGA_CORE_VID0: PR39.2 U9.31
PWR_VGA_CORE_VID1: PR37.2 U9.32
PWR_VGA_CORE_VID2: PR35.2 U9.33
PWR_VGA_CORE_VID3: PR32.2 U9.34
PWR_VGA_CORE_VID4: PR30.2 U9.35
PWR_VGA_CORE_VID5: PR25.2 U9.36
PWR_VGA_CORE_VID6: PR23.2 U9.37
PWR_VGA_CORE_VIN: PC60.2 PR101.2 U9.17
PWR_VGA_CORE_VSEN: PC11.2 PC13.1 PC56.1 PR21.2 PR27.2 PR28.2 U9.12
PWR_VGA_CORE_VSUM-: PC10.1 PC15.2 PC16.2 PC20.2 PR16.1 PR41.2 PR47.1 PR51.2
PWR_VGA_CORE_VW: PC7.1 PR13.1 U9.6
PWRBTN_N: C297.1 R549.2 R697.1 R1001.2 U24.34 U29.AK41
PWRCN_DET_N: PWRCN1.6 R340.1 R349.1 U29.N34
PWRGD_3V: DB1.1 Q119.G R162.1 R287.1 R456.2 U29.AT40
PWRGD_3V_B_1: Q59.B Q60.D R440.2
PWRGD_3V_LL: C262.1 Q59.C R449.2 R456.1 R478.1
PWRGOOD_GPU: R1158.2 U13.N10
PWROK3: R441.2 R449.1 R454.1
PWROK3_1: R454.2 U24.57
PX_EN: TP159.1 U13.AB16
Q46_PIN2: Q101.2 R1018.2
Q46_PIN3: Q99.G Q100.G Q101.3 R1015.2
Q46_PIN6: Q101.4 Q101.6
Q54_B: Q22.B R97.2
Q54_C: Q22.C R103.1
QF2_1: QF1.2 R873.2
QF2_2: QF1.5 QF1.6 R880.2
QSAN_0: MEM3.G3 U13.H27
QSAN_1: MEM3.B7 U13.A27
QSAN_2: MEM1.B7 U13.C23
QSAN_3: MEM1.G3 U13.C19
QSAN_4: MEM4.G3 U13.C15
QSAN_5: MEM2.B7 U13.E9
QSAN_6: MEM2.G3 U13.C5
QSAN_7: MEM4.B7 U13.H4
QSAP_0: MEM3.F3 U13.H28
QSAP_1: MEM3.C7 U13.C27
QSAP_2: MEM1.C7 U13.A23
QSAP_3: MEM1.F3 U13.E19
QSAP_4: MEM4.F3 U13.E15
QSAP_5: MEM2.C7 U13.D10
QSAP_6: MEM2.F3 U13.D6
QSAP_7: MEM4.C7 U13.G5
RASA0#: MEM1.J3 MEM3.J3 U13.G22
RASA1#: MEM2.J3 MEM4.J3 U13.G17
RED_CRT: C350.1 L22.2 U43.6 VGA1.1
REMOTE2+: C60.2 C253.1 Q26.E R153.1 U24.43
REMOTE2-: C60.1 C253.2 Q26.B Q26.C R154.1 U24.44
RING2: C204.1 Q42.2 R336.2 U16.31 UHS1.3
ROM_CS#: R1167.2 R1168.2 U49.1
ROM_SI_D3: R1171.1 U49.5
ROM_SLK_D4: R1170.1 U49.6
ROM_SO_C4: R1169.2 U49.2
RSMRST*_R: Q60.G R448.2
RSMRST_N: R275.1 R445.2 R448.1 R453.1 R1051.1
RSMRST_SIO_N_1: R453.2 U24.58
RT8243_3D3VFB: PC46.2 PG5.1 PR82.2
RT8243_5VFB: PC50.1 PC51.2 PG2.2 PR89.2 PU6.20
RT8243_BOOT1: PR90.2 PU6.19
RT8243_BOOT2: PR80.1 PU6.7
RT8243_BOOT2_1: PC44.2 PR80.2
RT8243_ENLDO: PR117.2 PU6.12
RT8243_ENTRIP1: PR87.2 PU6.2
RT8243_ENTRIP1_1: C291.1 Q73.G R550.2
RT8243_ENTRIP1_2: PR87.1 Q73.D R1055.1
RT8243_ENTRIP2: PU6.4 R539.1
RT8243_ENTRIP2_1: C276.1 Q69.G R514.1
RT8243_ENTRIP2_2: Q69.D R519.1 R539.2
RT8243_FB1: PC51.1 PR88.1 PR89.1 PU6.1
RT8243_FB2: PC46.1 PR82.1 PR84.1 PU6.5
RT8243_HG1: PR118.2 Q77.4
RT8243_HG2: PR116.1 Q65.4
RT8243_LDO3: PC48.1 PG1.1 PU6.15
RT8243_LDO5: PC47.1 PG6.1 PU6.14
RT8243_LGATE1: PU6.16 Q81.4
RT8243_LGATE2: PU6.10 Q64.4
RT8243_PGOOD: PR81.2 PU6.6 R523.1
RT8243_PHASE1: PC49.2 PL3.1 PR91.1 PU6.17 Q77.1 Q77.2 Q77.3 Q81.5 Q81.6 Q81.7 Q81.8
RT8243_PHASE2: PC44.1 PL2.2 PR115.1 PU6.9 Q64.5 Q64.6 Q64.7 Q64.8 Q65.1 Q65.2 Q65.3
RT8243_TON: PR86.1 PU6.3
RT8243_UGATE1: PR118.1 PU6.18
RT8243_UGATE2: PR116.2 PU6.8
RT8243SECFB: PC45.2 PR83.1 PR85.1 PU6.13
RTCX_L: R300.1 X1.1
RTL_ISOLATE_N: Q66.6 R494.2 R497.1 U26.20
RTL_ISOLATE_N_1: C289.1 Q66.5 R544.1 R548.2
RTL_ISOLATE_N_2: Q66.2 Q66.3 R498.2
S_LVDS_BL_EN: R173.1 R174.1 R175.1 R176.2 R177.2
S_PANEL_ON: R41.1 R48.2
S_TXE0+: LVDS1.13 U37.31
S_TXE0-: LVDS1.12 U37.32
S_TXE1+: LVDS1.16 U37.29
S_TXE1-: LVDS1.15 U37.30
S_TXE2+: LVDS1.19 U37.27
S_TXE2-: LVDS1.18 U37.28
S_TXE3+: LVDS1.23 U37.23
S_TXE3-: LVDS1.22 U37.24
S_TXEC+: LVDS1.21 U37.25
S_TXEC-: LVDS1.20 U37.26
S_TXO0+: LVDS1.2 U37.41
S_TXO0-: LVDS1.1 U37.42
S_TXO1+: LVDS1.4 U37.39
S_TXO1-: LVDS1.3 U37.40
S_TXO2+: LVDS1.6 U37.37
S_TXO2-: LVDS1.5 U37.38
S_TXO3+: LVDS1.11 U37.33
S_TXO3-: LVDS1.10 U37.34
S_TXOC+: LVDS1.9 U37.35
S_TXOC-: LVDS1.8 U37.36
SA0_DIM0: DIMM1.197 R848.1
SA0_DIM1: DIMM2.197 R851.1
SA1_DIM0: DIMM1.201 R852.1
SA1_DIM1: DIMM2.201 R850.2
SATA1GP: R272.2 R274.1 U29.J40
SATA2GP: R268.2 R282.2 U29.H40
SATA3GP: R242.2 R243.1 U29.N41
SATA4GP: R264.1 U29.M39
SATA5GP: R237.1 U29.N40
SATA__RXN0_C: C254.2 HDD1.5
SATA__RXN5_C: C222.2 ODD1.5
SATA__RXP0_C: C256.2 HDD1.6
SATA__RXP5_C: C224.2 ODD1.6
SATA__TXN0_C: C252.2 HDD1.3
SATA__TXN5_C: C220.2 ODD1.3
SATA__TXP0_C: C251.2 HDD1.2
SATA__TXP5_C: C218.2 ODD1.2
SATAHDR_RX_DN0: C254.1 U29.B28
SATAHDR_RX_DN5: C222.1 U29.C27
SATAHDR_RX_DP0: C256.1 U29.A28
SATAHDR_RX_DP5: C224.1 U29.B27
SATAHDR_TX_DN0: C252.1 U29.F31
SATAHDR_TX_DN5: C220.1 U29.G28
SATAHDR_TX_DP0: C251.1 U29.H31
SATAHDR_TX_DP5: C218.1 U29.F28
SATARBIAS_PCH: R316.2 U29.D33
SB3V: C8.1 C9.1 C215.1 C539.1 C591.1 C633.1 C676.2 C702.1 C717.1 F6.1 MEJ1.1 PC1.1 PC72.1 Q4.S Q58.D Q80.S Q125.D R2.1 R6.1 R10.1 R21.1 R57.1 R82.1 R98.1 R201.1 R216.1 R223.2 R232.1 R251.2 R256.2 R257.2 R258.1 R260.2 R276.1 R277.1 R278.2 R383.1 R385.2 R415.1 R421.1 R430.1 R431.2 R440.1 R445.1 R482.2 R492.2 R493.2 R495.2 R498.1 R501.1 R513.1 R527.1 R663.1 R703.1 R862.1 R867.2 R868.2 R878.1 R880.1 R903.2 R905.2 R908.2 R909.2 R910.2 R911.2 R920.2 R921.2 R922.2 R923.2 R925.1 R926.2 R927.1 R933.2 R937.2 R1010.1 R1015.1 R1028.1 R1040.1 R1065.1 R1090.1 R1096.1 RN5.5(B) RN5.6(B) RN5.7(B) RN5.8(B) U24.27 U29.AH18 U29.AH20 U29.AH22 U29.AJ20 U29.AK20 U29.AM33 U29.AN33 U29.AP35 U29.AW26 U29.P20
SB5V: C732.1 D18.1 PC26.1 PC38.2 PR71.1 PU5.6 Q112.D R106.1 R161.1 R210.1 R536.1 R573.2 R791.1 R794.1 R860.2 R979.1 R1027.1 R1050.1 R1066.1 R1074.1 R1077.2 R1141.1 R1144.1 U14.6 U46.5 U47.3
SD_CD#: C446.1 MEMCD1.10 U39.20
SD_CLK: MEMCD1.5 R128.2
SD_CLK_C_1: C461.1 R128.1 R838.2
SD_CLK_C_2: R838.1 U39.27
SD_CMD: MEMCD1.2 R839.2
SD_CMD_C: R839.1 U39.28
SD_DAT0: MEMCD1.7 R837.2
SD_DAT0_C: R837.1 U39.25
SD_DAT1: MEMCD1.8 R835.2
SD_DAT1_C: R835.1 U39.24
SD_DAT2: MEMCD1.9 R841.2
SD_DAT2_C: R841.1 U39.30
SD_DAT3: MEMCD1.1 R840.2
SD_DAT3_C: R840.1 U39.29
SD_LDO_EN: R819.2 R820.1 U39.13
SD_LED: TP89.1 U39.22
SD_WP: MEMCD1.11 U39.21
SENSE_B: R331.2 R332.2 U16.33
SER_IRQ: R270.1 U22.27 U23.27 U24.127 U29.G39
SIDE_USB3_RX1+: L10.3 SSUSB1.6 U10.2 U10.9
SIDE_USB3_RX1-: L10.2 SSUSB1.5 U10.1 U10.10
SIDE_USB3_RX2+: L13.3 SSUSB2.6 U11.2 U11.9
SIDE_USB3_RX2-: L13.2 SSUSB2.5 U11.1 U11.10
SIDE_USB3_TX1+: L9.3 SSUSB1.9 U10.5 U10.6
SIDE_USB3_TX1-: L9.2 SSUSB1.8 U10.4 U10.7
SIDE_USB3_TX2+: L12.3 SSUSB2.9 U11.5 U11.6
SIDE_USB3_TX2-: L12.2 SSUSB2.8 U11.4 U11.7
SIO_ATXPG: R562.2 R1067.2 U24.123
SIO_ATXPG_C: C696.1 R1067.1 R1080.1
SIO_GREEN: Q103.G R1024.2 R1028.2 R1036.1 U24.24
SIO_GREEN_GP000: R1024.1 U24.2
SIO_HDD_LED: R537.2 R540.1 U24.89
SIO_HDD_LED_1: Q70.B R540.2
SIO_LVDS_BL_ADJ: R168.2 R461.1 R717.1 U24.49
SIO_PECI_REQ_N: Q102.C R1019.2 U24.20
SIO_PROCHOT_R_N: R451.2 U24.36
SIO_PSON_N: Q98.G R158.1 R463.1 U24.53
SIO_PSON_N_C: R158.2 R159.1
SIO_PSON_N_C_1: Q121.G R1139.2
SIO_PSON_N_C_2: Q121.D Q122.G R1138.2
SIO_PSON_N_C_3: Q122.D R1133.2 R1135.1
SIO_PSON_N_C_4: Q115.1 R1135.2
SIO_PSON_N_C_5: C734.2 C735.1 Q115.3 R1136.2 R1137.1 U48.4
SIO_SMBCLK1: R492.1 TP166.1 U24.70
SIO_SMBCLK2: R481.2 R482.1 U24.26
SIO_SMBDAT1: R495.1 TP167.1 U24.72
SIO_SMBDAT2: R493.1 R496.2 U24.25
SIO_SPKR: R561.1 R898.1 U24.125
SIO_TACH3: R450.1 U24.39
SIO_YELLOW: Q107.G R1033.2 R1040.2 U24.23
SLEEVE: C206.1 Q42.1 Q46.D R323.2 U16.32 UHS1.4
SLEEVE_G: Q46.G Q49.D R380.2 R386.1
SLP_S3_N: R204.1 R578.1 R632.1 R1014.1 U24.121 U29.AK40
SLP_S3_N_1: Q87.2 R632.2
SLP_S3_N_2: Q86.5 R658.2
SLP_S3_N_3: Q87.6 R658.1 R663.2 R667.1
SLP_S3_N_4: Q89.B R667.2
SLP_S3_N_Q46: Q101.5 R1014.2
SLP_S3_N_R1: Q79.G R578.2 R590.2 R1139.1
SLP_S4_N: R107.1 R563.2 R1048.1 U29.AT35
SLP_S4_N_G: Q72.G Q108.C R536.2 R1045.2 R1048.2
SLP_S4_N_R: C50.1 R107.2 U4.2
SLP_S4_SIO: R563.1 R564.1 U24.69 U24.122
SLP_S5_N: R564.2 U29.AA35
SLP_SUSB: U24.71 U29.AK38
SLP_WLAN_N: R11.1 R283.1 U29.AL39
SMB_ALERT_N: R16.1 R922.1 U29.AG31
SMB_CLK_MAIN: DIMM1.202 DIMM2.202 Q93.S Q123.6 R521.1 U24.81 XDPC1.53
SMB_CLK_RESUME: C551.1 R14.1 R513.2 U24.80 U29.AG36
SMB_DATA_MAIN: DIMM1.200 DIMM2.200 Q92.S Q123.3 R505.1 U24.79 XDPC1.51
SMB_DATA_RESUME: C552.1 R12.1 R501.2 U24.78 U29.AG32
SMBUS_ISP: Q92.G Q93.G Q94.G Q95.G U29.L38
SMLICLK_PCH: C545.1 R481.1 R921.1 U29.AK36
SMLIDATA_PCH: C578.1 R496.1 R933.1 U29.AK33
SMLINK0_CLK: R909.1 U29.AE32
SMLINK0_DATA: R910.1 U29.AE35
SP_CTS_N: RN7.4(A) U24.101
SP_DCD_N: RN6.4(A) U24.96
SP_DSR_N: RN6.3(A) U24.97
SP_DTR_N: RN7.3(A) U24.102
SP_RI_N: RN7.2(A) U24.103
SP_RTS_N: RN6.1(A) U24.99
SP_RXD_N: RN6.2(A) U24.98
SP_TXD_N: Q111.3 R568.2 R574.2
SP_TXD_N_1: Q111.5 R1076.2
SP_TXD_SIO: R568.1 U24.100
SPEED_100*_CON: R596.2 RJ1.13
SPEED_100_N: C319.1 D12.K R596.1 U26.26
SPEED_1000*_CON: R595.2 RJ1.14
SPEED_1000_N: C338.1 D13.K R595.1 U26.25
SPI_CLK: R182.1 R241.2
SPI_CLK_1: R182.2 SRCON1.6 U12.6
SPI_CLK_R: R241.1 U29.U39
SPI_CS0_N: R240.2 SRCON1.1 U12.1
SPI_CS0_N_R: R240.1 U29.R38
SPI_CS1_N: TP115.1 U29.R35
SPI_IO2: R179.1 R180.2 R267.2
SPI_IO2_R: R267.1 U29.U40
SPI_IO3: R183.1 R184.2 R906.2
SPI_IO3_R: R906.1 U29.U37
SPI_MISO: R178.1 R917.2
SPI_MISO_R: R917.1 U29.R36
SPI_MISO_ROM_1: R178.2 SRCON1.2 U12.2
SPI_MOSI: R181.1 R239.2
SPI_MOSI_1: R181.2 SRCON1.5 U12.5
SPI_MOSI_R: R238.1 R239.1 U29.P40
SPI_WP_N_1: R179.2 SRCON1.3 U12.3
SPKR: R228.1 R895.1 R913.2 U29.R32
SPKR_1: R893.1 R895.2 R898.2
SPKR_DET: L56.1 R1156.2 U29.AV9
SPKR_DET_C: L56.2 SPK1.6
SPKR_IN_L: C274.2 C278.2 U25.6
SPKR_IN_R: C287.2 U25.31
SPKR_L+_C: C331.1 C332.1 L42.2 R589.1 SPK1.1
SPKR_L+_SNB: C316.1 R589.2
SPKR_L-_C: C325.1 C330.1 L41.2 R588.1 SPK1.2
SPKR_L-_SNB: C314.1 R588.2
SPKR_OUT_L+: C294.2 L42.1 U25.16
SPKR_OUT_L-: C301.2 L41.1 U25.18
SPKR_OUT_R+: C296.2 L43.1 U25.25
SPKR_OUT_R-: C302.2 L44.1 U25.23
SPKR_R+_C: C328.1 C329.1 L43.2 R587.1 SPK1.3
SPKR_R+_SNB: C315.1 R587.2
SPKR_R-_C: C326.1 C327.1 L44.2 R586.1 SPK1.4
SPKR_R-_SNB: C313.1 R586.2
SPV10: C785.1 C787.1 C789.1 L51.2 U13.H8
SPV18: C788.1 C792.1 C793.1 L49.2 U13.H7
SST_CTL_R: R953.2 U29.AJ31
SST_HOLDJ_1: R183.2 SRCON1.7 U12.7
SUS3V_FON_N: R1023.1 U24.56
SUS3V_ON_N: R1020.1 U24.74
SUS5V_ON_N: R1038.1 R1039.2 U24.73
SUS_ACK_EN_N: Q74.1 R535.1 R551.1 U24.94
SUS_LED_GREEN_1: R1043.1 R1050.2
SUS_LED_GREEN_C: PWRCN1.4 Q107.D R1036.2 R1043.2
SUS_PWR_ACK: C706.1 R259.2 R551.2 R572.1 R1068.2 R1072.2 U29.AJ37
SUS_PWR_ACK_5V_DUAL: R1069.1 R1071.1 R1073.1
SUS_PWR_ACK_5V_DUAL_L: C705.1 Q74.5 R1073.2
SUS_PWR_ACK_BJT: Q74.2 R543.2 R547.2
SUS_PWR_ACK_BJT_L: Q74.3 R545.1 R547.1
SUS_PWR_ACK_R: Q74.6 R572.2 R573.1
SUS_STAT_N: R278.1 U29.AD37
SUS_WARNB: R252.1 R253.1 R259.1 U29.AG41
SUS_WARNB_R: R253.2 U24.68
SUSCLK: R429.1 R915.1 U29.W36
SUSCLK_1: R429.2 R435.1 R436.1 U21.1
SUSCLK_NGFF: NGFF1.50 R435.2 U21.7
SUSCLK_SIO: R436.2 U21.8 U24.19
SWR_LX: L28.1 U37.17
SWR_V12: C29.1 C32.1 C33.1 C34.1 L28.2 U37.11 U37.15 U37.43
SYS_FAN_TACH1_1: FANC1.3 R805.2 R806.2
SYS_FAN_TACH1_2: R804.1 R805.1 R807.1
SYS_FAN_TACH3_1: FANC2.2 R490.1 R491.2
SYS_FAN_TACH3_2: R488.1 R489.1 R490.2
SYSTEM_FAN_PWM1_1: D16.A FANC1.4 R810.2 R811.2
SYSTEM_FAN_PWM1_2: D9.A FANC2.1 R533.2 R534.2
TCM_BA0: R424.1 U22.9 U23.9
TCM_BA1: R425.1 U22.3 U23.3
TCM_CLK_RUN: R474.1 U22.15 U23.15
TCM_NC5#: C241.1 U22.5 U23.5
TCM_NCP: C240.1 U22.14 U23.14
TD_IREF: R987.1 U29.C3
TESTEN: R302.1 R304.1 U13.K7
TESTLOW_1: CPU1.P6 R829.1
TESTLOW_2: CPU1.N5 R828.1
TMIN_SHIFT: R251.1 R452.1 U24.33 U29.AJ39
TP3131_GVDD: C268.1 R516.1 R517.2 U25.2
TP_1P5_PCH_PWROK: M1.7 PR79.2 R479.2
TP_1P5_PCH_PWROK_1: PR79.1 TP31.1
TP_ALL_PWRGD: R523.2 TP147.1
TP_CPU_G38: CPU1.G38 TP59.1
TP_CPU_H37: CPU1.H37 TP54.1
TP_CPU_H38: CPU1.H38 TP46.1
TP_CPU_J38: CPU1.J38 TP51.1
TP_CPU_K37: CPU1.K37 TP50.1
TP_CPU_K39: CPU1.K39 TP57.1
TP_CPU_M38: CPU1.M38 TP43.1
TP_CPU_N36: CPU1.N36 TP53.1
TP_CPU_T35: CPU1.T35 TP44.1
TP_DET: R579.2 TOUCH1.1 U29.AT34
TP_DISP_J12: CPU1.J12 TP84.1
TP_DISP_K11: CPU1.K11 TP88.1
TP_GPIO52: R357.1 U29.AJ26
TP_GPU_CLKREQ#: TP158.1 U13.N7
TP_H_CATERR_N: CPU1.M36 TP60.1
TP_LPC_DRQ0_N: TP131.1 U29.AK22
TP_NGFF_COEX1: NGFF1.48 TP39.1
TP_NGFF_COEX2: NGFF1.46 TP38.1
TP_NGFF_COEX3: NGFF1.44 TP37.1
TP_NGFF_LED1: NGFF1.6 TP35.1
TP_NGFF_LED2: NGFF1.16 TP36.1
TP_NGFF_MLDIR: NGFF1.17 TP34.1
TP_PCH_A2: TP29.1 U29.A2
TP_PCH_A3: TP26.1 U29.A3
TP_PCH_AE30: TP126.1 U29.AE30
TP_PCH_AH24: TP128.1 U29.AH24
TP_PCH_AJ14: TP137.1 U29.AJ14
TP_PCH_AK14: TP141.1 U29.AK14
TP_PCH_AM34: TP120.1 U29.AM34
TP_PCH_AN16: TP19.1 U29.AW23
TP_PCH_AP18: TP18.1 U29.AV22
TP_PCH_AV13: TP17.1 U29.AT26
TP_PCH_B1: TP30.1 U29.B1
TP_PCH_B2: TP27.1 U29.B2
TP_PCH_K16: TP136.1 U29.K16
TP_PCH_K22: TP134.1 U29.K22
TP_PCH_K33: TP124.1 U29.K33
TP_PCH_K34: TP122.1 U29.K34
TP_PCH_L16: TP138.1 U29.L16
TP_PCH_L22: TP132.1 U29.L22
TP_PCH_N12: TP139.1 U29.N12
TP_PCH_P19: TP135.1 U29.P19
TP_PCH_PWM0: TP123.1 U29.AL31
TP_PCH_PWM1: TP119.1 U29.AM31
TP_PCH_PWM2: TP118.1 U29.AP31
TP_PCH_PWM3: TP12.1 U29.AV30
TP_PCH_R12: TP140.1 U29.R12
TP_PCH_U10: TP142.1 U29.U10
TP_PCH_U11: TP143.1 U29.U11
TP_PEG_A4: CPU1.A4 TP102.1
TP_PEG_B3: CPU1.B3 TP104.1
TP_PEG_C2: CPU1.C2 TP103.1
TP_PEG_D1: CPU1.D1 TP106.1
TP_RSVD_AB6: CPU1.AB6 TP101.1
TP_RSVD_AB33: CPU1.AB33 TP61.1
TP_RSVD_AB36: CPU1.AB36 TP40.1
TP_RSVD_AC8: CPU1.AC8 TP93.1
TP_RSVD_AK20: CPU1.AK20 TP70.1
TP_RSVD_AT40: CPU1.AT40 TP48.1
TP_RSVD_AU1: CPU1.AU1 TP108.1
TP_RSVD_AU27: CPU1.AU27 TP66.1
TP_RSVD_AU39: CPU1.AU39 TP49.1
TP_RSVD_AV1: CPU1.AV1 TP109.1
TP_RSVD_AV2: CPU1.AV2 TP107.1
TP_RSVD_AV20: CPU1.AV20 TP71.1
TP_RSVD_AV24: CPU1.AV24 TP67.1
TP_RSVD_AV29: CPU1.AV29 TP64.1
TP_RSVD_AW2: CPU1.AW2 TP105.1
TP_RSVD_AW12: CPU1.AW12 TP81.1
TP_RSVD_AW23: CPU1.AW23 TP69.1
TP_RSVD_AW24: CPU1.AW24 TP68.1
TP_RSVD_AW27: CPU1.AW27 TP65.1
TP_RSVD_AY18: CPU1.AY18 TP72.1
TP_RSVD_C39: CPU1.C39 TP58.1
TP_RSVD_H12: CPU1.H12 TP86.1
TP_RSVD_H14: CPU1.H14 TP77.1
TP_RSVD_H15: CPU1.H15 TP76.1
TP_RSVD_H16: CPU1.H16 TP75.1
TP_RSVD_J8: CPU1.J8 TP100.1
TP_RSVD_J9: CPU1.J9 TP98.1
TP_RSVD_J10: CPU1.J10 TP94.1
TP_RSVD_J13: CPU1.J13 TP79.1
TP_RSVD_J15: CPU1.J15 TP78.1
TP_RSVD_J16: CPU1.J16 TP74.1
TP_RSVD_J17: CPU1.J17 TP73.1
TP_RSVD_J40: CPU1.J40 TP42.1
TP_RSVD_K8: CPU1.K8 TP99.1
TP_RSVD_K12: CPU1.K12 TP87.1
TP_RSVD_K13: CPU1.K13 TP82.1
TP_RSVD_L10: CPU1.L10 TP92.1
TP_RSVD_L12: CPU1.L12 TP80.1
TP_RSVD_M10: CPU1.M10 TP83.1
TP_RSVD_M11: CPU1.M11 TP85.1
TP_RSVD_N38: CPU1.N38 TP55.1
TP_RSVD_P33: CPU1.P33 TP63.1
TP_RSVD_P37: CPU1.P37 TP47.1
TP_RSVD_R33: CPU1.R33 TP62.1
TP_RSVD_R34: CPU1.R34 TP52.1
TP_RSVD_R36: CPU1.R36 TP45.1
TP_RSVD_T34: CPU1.T34 TP56.1
TP_RSVD_U8: CPU1.U8 TP91.1
TP_RSVD_V7: CPU1.V7 TP95.1
TP_RSVD_W8: CPU1.W8 TP90.1
TP_RSVD_Y8: CPU1.Y8 TP96.1
TP_SLP_LAN_N_C: TP11.1 U29.AU36
TP_TPM_PIN6: TP144.1 U22.6 U23.6
TP_TPM_PIN7: TP145.1 U22.7 U23.7
TP_VCC12: C246.1 F2.2 R406.2 TOUCH2.1
TP_VCC12_C: F2.1 PR72.2 PR73.2 R406.1
TPA3113_SD: Q62.3 Q63.G R466.2 R486.1
TPA3113_SD1#: C258.1 Q63.D R487.2 R541.1 U25.29
TPA3131_BSNL: C301.1 U25.19
TPA3131_BSNR: C302.1 U25.22
TPA3131_BSPL: C294.1 U25.15
TPA3131_BSPR: C296.1 U25.26
TPA3131_FAULT#: R541.2 U25.30
TPA3131_GAIN: R515.1 R516.2 U25.3
TPA3131_LINN: C275.2 U25.5
TPA3131_LINN_1: C275.1 R499.2
TPA3131_MUTE: R486.2 R520.1 U25.7
TPA3131_PLIMIT: C269.1 R500.2 R517.1 U25.1
TPA3131_RINN: C277.2 U25.32
TPA3131_RINN_1: C277.1 R506.2
TPA3131_SYNC: TP32.1 U25.11
TPEV_CFG_RCOMP: CPU1.H40 R728.1
TRST_N: R560.2 U24.124
TS#_DIMM0_1: DIMM1.198 DIMM2.198 R849.1
TSVDD: C758.1 C759.1 L47.2 U13.AD17
USB3_RX1_DN: L10.1 U29.F20
USB3_RX1_DP: L10.4 U29.G20
USB3_RX2_DN: L13.1 U29.G18
USB3_RX2_DP: L13.4 U29.H18
USB3_TX1_C_DN: C120.1 U29.B18
USB3_TX1_C_DP: C119.1 U29.C18
USB3_TX1_EMI_DN: C120.2 L9.1
USB3_TX1_EMI_DP: C119.2 L9.4
USB3_TX2_C_DN: C143.1 U29.B15
USB3_TX2_C_DP: C144.1 U29.B16
USB3_TX2_EMI_DN: C143.2 L12.1
USB3_TX2_EMI_DP: C144.2 L12.4
USB_EN: C292.1 C293.1 Q75.4 R529.2
USB_EN1: Q71.G Q72.D R531.2 R542.1
USB_EN2: Q71.D R528.1 R529.1 R530.2
USB_OC1_R_N: R908.1 U29.AF37
USB_OC2_R_N: R257.1 U29.AD39
USB_PCH_DN0: TR2.4 U29.AV10
USB_PCH_DN1: TR3.1 U29.AV11
USB_PCH_DN3: TR1.4 U29.AJ16
USB_PCH_DN3_NN: TR1.3 WEBCM1.2
USB_PCH_DN4: TR13.4 U29.AU15
USB_PCH_DN4_NN: C708.1 TOUCH1.4 TR13.3
USB_PCH_DN5: TR12.1 U29.AU12
USB_PCH_DN5_NN: NGFF1.5 TR12.2
USB_PCH_DN8: TR8.4 U29.AW16
USB_PCH_DN9: TR10.4 U29.AN16
USB_PCH_DN10: TR9.4 U29.AJ18
USB_PCH_DN11: TR11.1 U29.AP18
USB_PCH_DP0: TR2.1 U29.AU10
USB_PCH_DP1: TR3.4 U29.AW11
USB_PCH_DP3: TR1.1 U29.AK16
USB_PCH_DP3_PP: TR1.2 WEBCM1.1
USB_PCH_DP4: TR13.1 U29.AV15
USB_PCH_DP4_PP: C711.1 TOUCH1.3 TR13.2
USB_PCH_DP5: TR12.4 U29.AT12
USB_PCH_DP5_PP: NGFF1.3 TR12.3
USB_PCH_DP8: TR8.1 U29.AV16
USB_PCH_DP9: TR10.1 U29.AP16
USB_PCH_DP10: TR9.1 U29.AK18
USB_PCH_DP11: TR11.4 U29.AN18
USB_PWR_CRL1: R867.1 R868.1 R892.1 R1045.1 R1056.1 U29.V41
USB_PWR_CRL1_B1: Q108.B R1056.2
USBOC01*: C480.1 R855.1 R856.2 U29.AE40
USBOC89*: C304.1 R260.1 R554.1 R556.2 U29.AF39
USBOC1011*: C321.1 R591.1 R592.2 U29.AC41
USBP0N_EXT: D6.4 SSUSB1.2 TR2.3
USBP0P_EXT: D6.3 SSUSB1.3 TR2.2
USBP1N_EXT: D6.6 SSUSB2.2 TR3.2
USBP1P_EXT: D6.1 SSUSB2.3 TR3.3
USBP8N_EXT: D14.3 TR8.3 USB3.2
USBP8P_EXT: D14.4 TR8.2 USB3.3
USBP9N_EXT: D14.1 TR10.3 USB4.2
USBP9P_EXT: D14.6 TR10.2 USB4.3
USBP10N_EXT: D15.6 TR9.3 USB5.2
USBP10P_EXT: D15.1 TR9.2 USB5.3
USBP11N_EXT: D15.4 TR11.2 USB6.2
USBP11P_EXT: D15.3 TR11.3 USB6.3
USBRBIAS_PCH: R408.2 U29.AU20 U29.AV20
USBVCC01: C117.2 C118.1 C125.2 C126.2 C838.2 D6.5 F11.2 R856.1 SSUSB1.1 SSUSB2.1 TC13.1 TC15.1
USBVCC89: C359.1 C361.2 C362.2 C363.2 D14.5 F3.2 R556.1 R1118.2 R1119.2 USB3.1 USB4.1
USBVCC1011: C354.2 C357.1 C358.2 C360.2 D15.5 F5.2 R592.1 R1118.1 R1119.1 TC22.1 USB5.1 USB6.1
USBVCCTP: C333.2 F4.2 R602.2 TOUCH1.5
V_1P5_DAC_FB: C658.1 R996.2 U29.AF2
V_1P5_DAC_FB_R: C662.1 C663.1 L40.2 R996.1
V_1P05_DSW_INT_C: C183.1 R289.2
V_1P05_DSW_INT_R: R289.1 U29.AU40 U29.AU41
V_1P05_LAN: C271.1 C273.1 C686.1 C687.1 C697.1 C698.1 C700.1 C701.1 L15.2 R522.2 U26.3 U26.8 U26.22 U26.30
V_1P05_ME: C609.1 C613.1 Q109.1 R970.2 U29.AA23 U29.AA25 U29.AA26 U29.AB22 U29.AB23 U29.AB25 U29.AB26 U29.AD17 U29.AD19 U29.AD20 U29.AD22 U29.AD23 U29.AD25 U29.AF25 U29.W26
V_1P05_PCH: C488.1 C501.1 C502.1 C503.1 C504.1 C505.1 C515.1 C619.1 C625.1 C628.1 C631.1 C632.1 C636.1 C638.1 C639.1 C651.1 C654.1 C674.1 C870.1 Q111.1 R73.1 R195.2 R196.2 R197.2 R198.2 R199.2 R756.1 R772.1 R826.1 R970.1 R999.1 R1004.1 R1017.2 R1018.1 U24.29 U29.AA16 U29.AA19 U29.AA20 U29.AB2 U29.AB16 U29.AB17 U29.AB19 U29.AB20 U29.AC12 U29.AD16 U29.AF19 U29.AF20 U29.AF22 U29.AF23 U29.AP22 U29.M14 U29.P14 U29.P16 U29.P17 U29.P22 U29.P23 U29.P25 U29.P26 U29.P28 U29.T16 U29.T19 U29.T20 U29.U12 U29.V14 U29.V16 U29.V17 U29.V19 U29.V20 U29.V22 U29.V23 U29.V25 U29.W14 U29.W16 U29.W17 U29.W19 U29.W23 U29.W25
V_1P5_PCH: C232.1 C640.1 C645.1 L40.1 R221.1 R316.1 R382.1 R411.1 R462.1 R982.1 R988.1 R1003.1 U29.A4 U29.A19 U29.A33 U29.A38 U29.A39 U29.A40 U29.B4 U29.B13 U29.B37 U29.B39 U29.C1 U29.C2 U29.K1 U29.N10 U29.N11 U29.T14
V_1P05_PECI_VCOM: CPU1.N35 TP41.1
V_1P5_RTC_INT: C198.1 U29.AW35
V_1P5_STBY_INT: C606.1 U29.AH28
V_1P05_XCK_DCB_FB_R: C250.1 C665.1 R999.2 U29.AB1
V_3_CARD: C105.1 C106.2 C438.1 MEMCD1.4 U39.17
V_3P0_BAT_VREG: C600.1 D2.3 R273.1 R281.1 R298.1 R305.1 R306.1 R386.2 R518.2 U29.AP33
V_3P3_A: C290.2 C581.1 C668.2 C669.2 C670.2 C671.2 C672.2 C677.2 C678.2 C679.1 C680.1 C691.2 C695.2 D2.1 D10.2 Q58.S Q78.5 Q78.6 Q78.7 Q78.8 Q125.S R224.2 R225.2 R283.2 R313.2 R380.1 R431.1 R466.1 R480.1 R487.1 R947.2 R1000.2 R1001.1 R1002.2 R1005.1 R1013.2 R1026.1 R1060.1 R1068.1 U24.22 U24.32 U24.45 U24.55 U24.60 U24.65 U24.77 U24.104 U24.120 U29.AV39 U29.AW38 U29.AW39
V_3P3_BG: C247.1 C659.1 R992.1 U29.AE1 U29.AW21 U29.B6
V_3P3_EPW: C127.1 C172.1 R180.1 R184.1 R192.1 R201.2 SRCON1.8 U12.8 U29.R41
V_3P3_LAN: C305.1 C309.1 C317.1 C688.1 C699.1 C709.1 C710.1 C712.1 Q80.D R548.1 R1054.1 R1065.2 R1070.1 RJ1.12 U26.11 U26.32 U28.5 U30.5
V_3P3_LAN_VDDSREG: C280.1 C281.1 R1054.2 U26.23
V_3P3_PCIVAUX: C364.1 C391.1 C398.1 C399.1 NGFF1.2 NGFF1.4 NGFF1.72 NGFF1.74 Q1.G Q2.G Q4.D R1.1 R4.1 R18.1 R21.2 TC1.1
V_5_CODEC: C193.1 C194.2 C525.1 L31.1 U16.39
V_5_LCD1: L27.1 U36.4
V_5_LCD2: F8.1 L27.2 R706.2 R709.1
V_5HDD: C169.1 C177.1 C180.1 F1.2 R295.2 R311.2 SATAP1.3 TC18.1
V_5P0_A: C683.2 D17.K L31.2 Q75.5 Q75.6 Q75.7 Q75.8 Q82.5 Q82.6 Q82.7 Q82.8 Q112.S R463.2 R535.2 R545.2 R1022.1 R1039.1 R1053.1 R1077.1 R1087.1 R1088.1 R1093.1 R1100.1 R1108.1 R1113.1
V_5P0_CONN_CRT_L: F14.1 L45.1 TP148.1
V_5P0_HDMI_CONN: C721.2 HDMI1.18 L46.1
V_5P0_HDMI_CONN_L: F13.1 L46.2
V_12_INV: C121.1 C122.2 CONVT1.1 CONVT1.2 CONVT1.4 F10.2 R853.2
V_12P0_A: ATX2.1 C113.1 C734.1 Q115.2 R422.1 R428.1 R530.1 R531.1 R553.1 R576.1 R584.1 R843.2 R844.2 R1046.1 R1047.1 R1133.1 R1136.1 R1138.1 R1146.1
V_CPU_CORE: C53.1 C54.1 C57.1 C58.1 C61.1 C62.1 C64.1 C65.1 C68.1 C69.1 C72.1 C73.1 C76.1 C77.1 C81.1 C82.1 C89.1 C90.1 C424.1 C425.1 C426.1 C427.1 CPU1.A24 CPU1.A25 CPU1.A26 CPU1.A27 CPU1.A28 CPU1.A29 CPU1.A30 CPU1.B25 CPU1.B27 CPU1.B29 CPU1.B31 CPU1.B33 CPU1.B35 CPU1.C24 CPU1.C25 CPU1.C26 CPU1.C27 CPU1.C28 CPU1.C29 CPU1.C30 CPU1.C31 CPU1.C32 CPU1.C33 CPU1.C34 CPU1.C35 CPU1.D25 CPU1.D27 CPU1.D29 CPU1.D31 CPU1.D33 CPU1.D35 CPU1.E24 CPU1.E25 CPU1.E26 CPU1.E27 CPU1.E28 CPU1.E29 CPU1.E30 CPU1.E31 CPU1.E32 CPU1.E33 CPU1.E34 CPU1.E35 CPU1.F23 CPU1.F25 CPU1.F27 CPU1.F29 CPU1.F31 CPU1.F33 CPU1.F35 CPU1.G22 CPU1.G23 CPU1.G24 CPU1.G25 CPU1.G26 CPU1.G27 CPU1.G28 CPU1.G29 CPU1.G30 CPU1.G31 CPU1.G32 CPU1.G33 CPU1.G34 CPU1.G35 CPU1.H23 CPU1.H25 CPU1.H27 CPU1.H29 CPU1.H31 CPU1.H33 CPU1.H35 CPU1.J21 CPU1.J22 CPU1.J23 CPU1.J24 CPU1.J25 CPU1.J26 CPU1.J27 CPU1.J28 CPU1.J29 CPU1.J30 CPU1.J31 CPU1.J32 CPU1.J33 CPU1.J34 CPU1.J35 CPU1.K19 CPU1.K21 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K29 CPU1.K31 CPU1.K33 CPU1.K35 CPU1.L15 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L19 CPU1.L20 CPU1.L21 CPU1.L22 CPU1.L23 CPU1.L24 CPU1.L25 CPU1.L26 CPU1.L27 CPU1.L28 CPU1.L29 CPU1.L30 CPU1.L31 CPU1.L32 CPU1.L33 CPU1.L34 CPU1.M8 CPU1.M13 CPU1.M15 CPU1.M17 CPU1.M19 CPU1.M21 CPU1.M23 CPU1.M25 CPU1.M27 CPU1.M29 CPU1.M33 CPU1.P8 G2.1 G4.1 G5.1 L1.2 L5.2 L6.2 R47.1 R652.2 TC4.1 TC6.1 TC8.1 TC10.1 TC11.1
V_CPU_VCCIO2PCH: C579.1 C598.1 C599.1 R824.1 R826.2 U29.C39
V_CPU_VCCIO_OUT: CPU1.L40 R773.2
V_CPU_VCCIO_RIGHT: C365.1 C411.1 R62.1 R629.1 R639.1 R644.1 R645.1 R648.1 R649.1 R749.1 R767.1 R769.1 R772.2 R773.1 R774.1 XDPC1.43 XDPC1.44
V_SM: C55.1 C59.1 C63.1 C66.1 C70.1 C74.1 C78.1 C79.2 C83.1 C91.1 C95.1 C103.1 C104.2 C109.1 C428.1 C430.1 C431.1 C433.1 C435.2 C436.2 C439.1 C442.1 C443.1 C444.2 C447.2 C448.1 C449.1 C450.1 C453.1 C454.1 C455.1 C457.1 C459.1 C463.1 C464.1 C465.1 C467.1 C477.1 C478.1 CPU1.AJ9 CPU1.AJ12 CPU1.AJ13 CPU1.AJ15 CPU1.AJ17 CPU1.AJ20 CPU1.AJ21 CPU1.AJ24 CPU1.AJ25 CPU1.AJ28 CPU1.AJ29 CPU1.AT17 CPU1.AT22 CPU1.AU15 CPU1.AU20 CPU1.AU24 CPU1.AV8 CPU1.AV10 CPU1.AV11 CPU1.AV13 CPU1.AV18 CPU1.AV23 CPU1.AW16 CPU1.AY9 CPU1.AY12 CPU1.AY14 DIMM1.75 DIMM1.76 DIMM1.81 DIMM1.82 DIMM1.87 DIMM1.88 DIMM1.93 DIMM1.94 DIMM1.99 DIMM1.100 DIMM1.105 DIMM1.106 DIMM1.111 DIMM1.112 DIMM1.117 DIMM1.118 DIMM1.123 DIMM1.124 DIMM2.75 DIMM2.76 DIMM2.81 DIMM2.82 DIMM2.87 DIMM2.88 DIMM2.93 DIMM2.94 DIMM2.99 DIMM2.100 DIMM2.105 DIMM2.106 DIMM2.111 DIMM2.112 DIMM2.117 DIMM2.118 DIMM2.123 DIMM2.124 PC22.1 PC23.2 Q40.D Q57.5 Q57.6 Q57.7 Q57.8 Q106.4 R138.1 R757.1 R783.2 R784.2 R785.2 R786.2 R787.2 R788.2 R789.2 R790.2 R801.1 R803.1 R846.1 R857.1 TC12.1 U41.1
V_SM_1P5_EN: C48.1 R90.2 R95.1 R97.1
V_SM_VTT: C471.1 C473.1 C475.1 C476.1 DIMM1.203 DIMM1.204 DIMM2.203 DIMM2.204 R854.1
V_VCC3P3_EN: C306.1 C307.1 Q78.4 R577.2
V_VCC3P3_EN_R: Q76.D R552.1 R576.2 R577.1
V_VCC5_EN: C340.1 C341.1 Q82.4 R593.2
V_VCC5_EN_R: Q83.D R584.2 R593.1 R601.1
V_VCCIOA_LOAD: CPU1.P4 R830.1 R831.1
VCTRL_VCC_EN: Q76.G Q79.D Q83.G R553.2 R597.1
VGA_BLUE: C345.1 L17.1 R442.1 R609.2 U29.AC3
VGA_BLUE_C_L: C346.1 L17.2 L20.1
VGA_CORE: C805.1 C806.1 C807.1 C808.1 C809.1 C810.1 C811.1 C812.1 C813.1 C814.1 C815.1 C816.1 C817.1 C818.1 C819.1 C820.1 C821.1 C822.1 C823.1 C824.1 PC73.2 PR28.1 PR52.2 PR53.2 PR55.2 PR56.2 PR57.2 PR58.2 PR59.2 PR106.2 PR107.2 PR110.2 PR111.2 PR112.2 PR113.2 U13.AA12 U13.AA15 U13.M11 U13.M13 U13.M15 U13.M16 U13.M17 U13.M18 U13.M20 U13.M21 U13.N12 U13.N15 U13.N17 U13.N20 U13.R13 U13.R16 U13.R18 U13.T12 U13.T15 U13.T17 U13.T20 U13.U11 U13.U13 U13.U16 U13.U18 U13.V15 U13.V17 U13.V20 U13.V21 U13.Y13 U13.Y16 U13.Y18 U13.Y21
VGA_CORE_PWR: C837.1 PG3.2 PL1.2 PR27.1 PR52.1 PR53.1 PR55.1 PR56.1 PR57.1 PR58.1 PR59.1 PR106.1 PR107.1 PR110.1 PR111.1 PR112.1 PR113.1 PT1.1 PT3.1 PT4.1
VGA_DACREFSET: R990.1 U29.AF5
VGA_DDC_PU: C726.1 D22.K R1115.1 R1116.1 U44.5
VGA_DET: R361.2 U29.AV28 U43.4 VGA1.4
VGA_GREEN: C343.1 L18.1 R444.1 R605.2 U29.AE2
VGA_GREEN_C_L: C347.1 L18.2 L21.1
VGA_HSYNC_3V: L23.1 U29.AH3
VGA_PCH_DDCSCL: R626.2 U29.AL2 U34.1
VGA_PCH_DDCSDA: R623.2 U29.AL3 U34.4
VGA_RED: C344.1 L19.1 R443.1 R606.2 U29.AC2
VGA_RED_C_L: C348.1 L19.2 L22.1
VGA_VSYNC_3V: L24.1 U29.AH2
VR_READY: C370.2 Q89.C Q106.1 R42.1 R55.1 R647.2 R698.1 R887.1 U35.7
VR_TT#: TP8.1 U9.4
VRAM1_VREFCA: C529.1 MEM3.M8 R885.1 R886.2
VRAM1_VREFDQ: C559.1 MEM3.H1 R924.2 R928.1
VRAM2_VREFCA: C163.1 MEM1.M8 R229.2 R230.1
VRAM2_VREFDQ: C145.1 C835.1 MEM1.H1 R202.2 R203.1
VRAM3_VREFCA: C602.1 MEM4.M8 R951.2 R957.1
VRAM3_VREFDQ: C608.1 MEM4.H1 R959.1 R960.2
VRAM4_VREFCA: C199.1 MEM2.M8 R308.2 R309.1
VRAM4_VREFDQ: C588.1 MEM2.H1 R945.1 R946.2
VRAM_ZQ1: MEM3.L8 R870.2
VRAM_ZQ2: MEM1.L8 R899.2
VRAM_ZQ3: MEM4.L8 R299.2
VRAM_ZQ4: MEM2.L8 R320.2
VREF_1: C179.1 U16.41
VREG_PCIAUX_PCH: Q3.D Q128.C R10.2 R13.1
VREG_PCIAUX_PCH_1: C7.1 PC1.2 Q4.G R13.2
VRP: C202.1 TC17.1 U16.38
VSUM_RC: PC14.2 PR34.2
VSUM_RR: PR42.2 PR51.1
VSYNC_3P3V: C353.1 L24.2 U44.1 VGA1.14
WAKE_N: R19.1 R20.2 R920.1 U26.21 U29.AK34
WEA0#: MEM1.L3 MEM3.L3 U13.G25
WEA1#: MEM2.L3 MEM4.L3 U13.H10
WEBCAM_DET: PC2.2 R30.2 U29.AV35 WEBCM1.7
XCLK_RCOMP: R982.2 U29.R11
XDP_DBRESET_N: C367.1 CPU1.G40 R744.2 XDPC1.48
XDP_PLTRST_N: R697.2 XDPC1.41
XDP_PWR_DEBUG: R35.2 R38.1 R74.1 XDPC1.45
XDP_PWRGD: R695.1 R696.2 XDPC1.39
XDP_VR_READY: C394.1 R698.2 XDPC1.47
XTAL_25M_PCH_IN: C259.1 R467.1 U29.N7 X3.3
XTAL_25M_PCH_OUT: C260.1 R467.2 U29.N6 X3.1
XTALIN: C756.1 R1188.1 U13.AM28 X5.1
XTALOUT: C757.1 R1188.2 U13.AK28 X5.3

Pads without a net: CPU1 A6 A12 AK15 AL15 AL20 AL25 AL26 AM16 AM25 AM26 AN17 AN20 AN21 AN25 AN26 AP19 AP20 AP25 AP26 AR25 AR26 AT31 AT33 AU8 AU10 AU22 AU23 AU28 AU29 AU31 AU32 AU33 AV14 AV31 AV32 AV33 AW8 AW9 AW13 AW14 AW31 AW33 AY13 B5 B6 B7 B9 B11 B12 C5 C7 C8 C9 C10 C11 D8 D10 D12 D14 E9 E11 E12 E13 E14 E15 F8 F9 F10 F11 F13 F15 G8 G10; D7 1; DIMM1 77 122 125; DIMM2 77 122 125; HDMI1 13 14; LPC1 10; MEM1 J1 J9 L1 L9 M7 T7; MEM2 J1 J9 L1 L9 M7 T7; MEM3 J1 J9 L1 L9 M7 T7; MEM4 J1 J9 L1 L9 M7 T7; NGFF1 64; Q44 3 4 5; Q45 1 2 6; Q86 1 2 6; Q87 3 4 5; RN7 1; U9 26 28 29 30; U13 AA1 AA3 AA5 AA6 AB2 AB4 AB7 AB8 AB9 AB11 AB12 AB13 AB23 AC1 AC3 AC5 AC6 AC7 AC8 AC10 AC11 AC13 AC14 AC20 AC23 AD2 AD4 AD7 AD9 AD10 AD11 AD13 AD16 AD20 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE8 AE9 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF19 AF20 AF22 AF23 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG14 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG23 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH14 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL9 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM12 AM14 AM16 AM18 AM20 AM22 AM24 AM26 G14 J8 J22 J25 K13 K30 L9 L16 L17 L29 L31 M27 M28 M30 N3 N5 N6 N9 N26 N29 N31 P7 P23 P24 P26 P27 P28 P30 R29 R31 T7 T10 T23 T24 T26 T27 T28 T30 U1 U3 U5 U6 U10 U12 U23 U24 U26 U29 U31 V2 V4 V6 V12 V27 V30 W1 W3 W5 W6 W7 W8 W9 W10 W23 W24 Y2 Y4 Y6 Y7 Y8 Y9 Y11 Y12; U16 15 16 17 34 37 45 46; U21 3 5; U22 1 2 8 12; U23 1 2 8 12; U24 5 6 13 61 62 63 64 67 76 84 85 91 93 95 105 106 107 110 112; U29 A14 A26 A31 AA6 AA7 AC10 AC11 AC35 AE6 AE7 AG6 AG7 AN14 AN20 AP14 AP20 AT17 AU17 AV14 AV18 AW14 AW18 B11 B12 B14 B26 B31 B32 B34 B35 C15 C30 C32 C34 D2 D15 D30 D35 E1 F7 F33 G3 G5 G33 H1 H2 H7 J2 J3 K5 K6 K8 K14 K18 K20 K28 L5 L14 L18 L20 L28 P5 R4 R6 R7 R40 W6 W7; U33 5 6; U35 20; U41 5 7 8; VGA1 11; X1 2 3; XDPC1 55

## Via types
v1: diameter 0.762, hole 0.381, TOP to BOTTOM, 654 vias
v2: diameter 0.66, hole 0.33, TOP to BOTTOM, 1065 vias
v3: diameter 0.559, hole 0.305, TOP to BOTTOM, 2475 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 1809 vias
v5: diameter 0.711, hole 0.406, TOP to BOTTOM, 1166 vias
v6: diameter 0.762, hole 0.305, TOP to BOTTOM, 1 via
v7: diameter 0.711, hole 0.356, TOP to BOTTOM, 1 via

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
3.3V_ALW_1: length 8.5
  TOP w0.254: R413.2 82.75,67.4 v1(83.21,66.94) 84.08,67.81 Q51.G 84.5,68.39 85.33,67.56 Q54.6 85.33,65.45 85.52,65.26 85.79,65.26 85.98,65.45 Q54.5
3.3V_RUN_VGA_1: length 8.5
  TOP w0.305: Q54.3 87.25,64.45 87.5,64.7 v3(87.5,65.39)
  TOP w0.508: v3(89.28,65.43) 89.28,66.79 88.39,67.67 88.39,68.82 v1(88.27,68.94) 87.83,69.38 R403.2
  L3 w0.508: v3(89.28,65.43) 87.54,65.43 v3(87.5,65.39)
5V_PWR: length 18.8
  TOP w0.508: R514.2 v3(105.22,45.32)
  L4 w0.508: v5(98.04,30.34) 98.04,37.07 105.22,44.24 v3(105.22,45.32)
  vias: v2(89.48,28.94) v2(97.56,25.31) v5(87.12,30.01) v5(87.12,28.99) v5(87.12,27.97) v5(87.81,31.07) v5(88.54,26.45) v5(89.66,31.12) v5(90.12,26.43) v5(91.54,30.06) v5(91.59,28.25) v5(97.13,28.86) v5(97.16,27.75) v5(97.16,26.63) v5(98.04,29.32) v5(98.04,28.3) v5(98.04,27.29)
5VDDCCL: length 20.2
  L3 w0.127: v3(39.04,16.87) 39.23,16.68 40,16.68 40.78,15.9 42.09,15.9 43.13,14.85 43.13,12.52 VGA1.15
  BOTTOM w0.102: v3(39.04,16.87) 38.96,16.95 38.18,16.95 38.09,17.04 U44.4 36.17,15.82 36.17,14.77 35.85,14.45 C728.1 R1117.2
5VDDCDA: length 35.2
  L3 w0.127: VGA1.12 53.18,8.9 51.33,10.75 51.33,11.01 49.96,12.38 49.96,13.21 45.28,17.89 45.28,20.62 44.72,21.18 43.26,21.18 43.24,21.15 v3(42.31,21.15)
  BOTTOM w0.102: R1114.2 33.75,21.54 C723.1 33.75,21 32.44,19.68 32.41,19.66 32.21,19.45 32.21,18.37 32.59,17.99 36.1,17.99 36.53,18.42 36.53,18.44 37.03,18.95 U44.6 37.89,18.95 38.92,19.97 41.15,19.97 42.31,21.14 v3(42.31,21.15)
5VSB: length 3.9
  TOP w0.635: PR91.2 PC55.1 82.04,23.17 v3(82.32,23.45)
  BOTTOM w0.254: v2(82.3,22.34) 82.3,23.43 v3(82.32,23.45)
12V_DUAL: length 134
  TOP w0.508: R1151.2 27.51,148.27 27.1,147.86 26.34,147.86 v3(25.93,147.46)
  L3 w1.016: v5(39.95,80.17) 39.95,75.97 40.17,75.75 40.17,74.07 38.73,72.63 38.53,72.63 35.79,69.88 35.79,69.81 35.07,69.09 31.33,69.09 v5(31.1,69.33) ; v5(67.49,35.67) 67.49,34.55 67.82,34.22 67.82,25.68 69.59,23.91 70.77,23.91 71.98,23.91 74.19,21.7 83.79,21.7 84.19,21.29 87.84,21.29 88.86,22.31 90.42,22.31 92.07,23.96 100.11,23.96 100.64,24.49 110.68,24.49 111.99,23.18 115.22,23.18 116.69,24.65 123.06,24.65 124.69,26.27 129.36,26.27 129.38,26.25 132.74,26.25 135.97,29.48 135.97,32.04 139.97,36.04 v5(139.97,36.33)
  L4 w1.016: v5(31.1,69.33) 30.86,69.33 28.83,71.36 v5(24.51,71.36)
  BOTTOM w0.508: v3(109.88,220.25) 110.16,220.53 111.87,220.53 111.92,220.58 R707.1 R702.1
  BOTTOM w1.016: v3(149.99,35.8) 149.45,36.33 v5(139.97,36.33)
  vias: v2(21.72,159.11) v2(23.06,59.5) v2(29.54,158.53) v2(69.39,38.9) v2(142.06,205.06) v2(154.71,214.87) v3(18.69,155.18) v5(14.02,127.85) v5(14.15,128.86) v5(15.06,128.86) v5(15.19,127.82) v5(16.03,128.86) v5(16.1,127.85) v5(17.02,128.84) v5(17.09,127.82) v5(18.03,71.99) v5(18.06,70.82) v5(21.34,57.77) v5(21.34,56.75) v5(21.35,58.78) v5(22.35,57.77) v5(22.35,56.75) v5(22.35,55.84) v5(25.07,157.29) v5(25.07,156.14) v5(25.98,157.29) v5(26.06,156.14) v5(26.95,157.29) v5(26.92,136.89) v5(26.92,135.92) v5(26.92,134.98) v5(26.97,156.17) v5(27.94,157.26) v5(27.97,156.14) v5(39.93,81.34) v5(39.98,82.51) v5(141.58,207.86) v5(141.58,206.59) v5(142.72,207.86) v5(142.72,206.59) v5(147.47,114.94) v5(148.34,114.23) v5(148.46,115.17) v5(178.94,112.89) v5(178.87,111.87) v5(178.87,110.88)
12V_DUAL_1D05V_S0:
  vias: v1(180.11,104.76)
12V_DUAL_DDR_VIN:
  vias: v2(162.36,217.13) v2(175.21,218.32) v5(160.78,215.63) v5(160.78,214.49) v5(163.58,215.63) v5(163.58,214.49) v5(164.85,215.63) v5(164.85,214.49) v5(173.99,220.07) v5(173.99,218.8) v5(173.99,217.53) v5(173.99,216.39)
12V_DUAL_VGACORE: length 19.7
  L4 w0.508: v3(33.6,136.53) 31.51,134.44 31.51,133.06 31.17,132.72 31.17,129.96 30.28,129.07 v3(27.53,129.07)
  BOTTOM w0.508: PR101.1 35.39,136.53 v3(33.6,136.53) ; v3(27.53,129.07) 23.8,129.07 22.99,128.25
  vias: v2(22.17,109.48) v2(22.43,125.23) v5(20.09,124.19) v5(20.09,123.18) v5(21.08,124.19) v5(21.11,123.17)
12V_FAN_MIX:
  vias: v2(17.04,188.88)
12V_MONITOR:
  vias: v2(20.62,151.34)
12V_PWR: length 27.8
  TOP w0.508: 25.32,81.68 TC19.1 ; TC19.1 26.38,82.74 ; TC19.1 24.27,82.74 ; TC19.1 25.32,83.79
  BOTTOM w0.381: v3(26.29,81.34) 26.29,75.88 25.32,74.91 25.32,72.86 v2(26.2,71.98) 28.18,70 32.64,70 32.93,69.71 35.43,69.71 37.34,67.8 R984.1
12V_PWR_SENSE: length 5.6
  TOP w0.254: R418.2 37.78,67.61 R420.1 38.86,68.44 R410.1 39.75,68.31 v3(39.75,67.87) 39.88,67.74 v1(39.88,66.99)
  BOTTOM w0.254: v3(39.75,67.87) 39.68,67.8 R984.2
12V_S0:
  vias: v2(14.1,119.24) v3(17.55,183.88) v3(17.53,183.02) v5(20.17,153.3) v5(20.37,161.55) v5(21.46,161.5) v5(22.56,161.53)
+1.5V_PWR: length 53.8
  TOP w0.381: PC3.1 R100.2 v3(180.97,187.31)
  TOP w0.508: 156.57,198.73 TC7.1 ; TC7.1 155.51,199.78 ; TC7.1 156.57,200.84 ; TC7.1 157.62,199.78 ; 156.51,206.63 TC5.1 ; TC5.1 155.46,207.68 ; TC5.1 157.57,207.68 ; TC5.1 156.51,208.73
  BOTTOM w0.381: v3(180.97,187.31) 180.97,185.91 180.09,185.02 178.08,185.02 177.62,185.48 177.62,192.26 177.04,192.85 177.04,193.91 171.75,199.2 v3(158.12,199.2)
  BOTTOM w0.508: TC5.1 157.57,207.68 ; TC5.1 156.51,206.63 ; TC5.1 156.51,208.73 ; TC5.1 155.46,207.68 ; 156.57,198.73 TC7.1 ; TC7.1 156.57,200.84 ; TC7.1 155.51,199.78 ; TC7.1 157.62,199.78
  vias: v2(151.23,201.71) v2(162.56,207.55) v5(160.02,205.93) v5(160.07,209) v5(160.43,211.29) v5(161.14,203.92) v5(161.59,210.27) v5(162.71,211.34) v5(162.99,202.96) v5(163.6,204.4) v5(163.86,210.22) v5(164.49,203.26) v5(164.77,211.36) v5(165.13,206.28) v5(165.4,209.46) v5(165.43,204.71) v5(165.53,207.71)
+3V_VA: length 3
  TOP w0.203: v3(175.03,86.41) 175.03,86.47 175.77,87.21 U16.23 ; v3(176.81,84.72) 176.89,84.79 176.89,85.05 176.91,85.07 176.91,85.37 177.12,85.59 U16.25
  vias: v2(175.67,85.81)
+5V_VGA: length 28.1
  TOP w0.508: VGA1.9 50.89,10.88 52.48,12.46 52.48,13.6 55.09,16.21 55.09,16.75 56.92,18.58 57.02,18.58 v3(57.07,18.63)
  L3 w0.508: VGA1.9 49.48,10.88 47.84,12.51 47.84,13.31 45.59,15.57 44.15,15.57 42.34,17.38 42.34,18.38 41.31,19.4 v3(41.31,21.54)
  BOTTOM w0.508: U43.5 40.79,22.06 v3(41.31,21.54)
  vias: v2(62.03,22.54)
+19V_AMP_AVCC: length 5.5
  TOP w0.254: v1(152.96,36.56) 153.09,36.69 C283.1
  TOP w0.305: 155.02,35.21 155.32,34.91 U25.12
  TOP w0.508: C283.1 R538.2 154.25,35.21 155.02,35.21
+19V_AMP_PVCC:
  vias: v2(163.4,32.14) v5(155.09,33.68) v5(163.45,34.15)
AGND: length 72.1
  TOP w0.203: U16.22 175.41,87.61 v3(175.01,87.21) ; U16.28 178.32,85.31 178.28,85.27 178.28,84.29 v3(178.16,84.16) ; U16.42 183.75,88.81 v3(183.9,88.96)
  TOP w0.305: R515.2 160.57,40.94 160,40.37 160,38.93 159.76,38.69 U25.4
  TOP w0.508: LOUT1.P 83.74,16.1 ; LOUT1.P 82.27,15.08 ; LOUT1.P 82.27,17.12 ; LOUT1.P 80.8,16.1 ; R1233.2 153.8,39.58 v3(153.95,39.43) 154.05,39.33 C283.2 ; Q46.S v3(201.14,77.3) ; C195.2 171.89,85.84 v3(171.89,86.67) ; UHS1.5 193.82,83.35 ; UHS1.5 192.4,84.37 ; UHS1.5 190.98,83.35 ; R337.2 179.96,81.26 180.15,81.45 C204.2 180.72,81.33 180.72,80.68 181.23,80.17 v3(181.23,80.12) C210.2 ; R506.1 164.47,42.35 165.06,42.95 R500.1 165.06,43.68 164.47,44.28 163.5,44.28 163.07,43.85 C269.2 C268.2 161.52,43.95 160.66,43.95 R499.1 160.53,43.82 160.53,42.02 v3(160.27,41.77) 160.78,41.26 R515.2 ; C194.1 184.98,86.08 185.79,86.89 C187.1 185.92,87.23 187.96,87.23 ; v3(166.93,35.87) 166.12,36.69 R1234.2 ; v3(186.08,80.45) 185.8,80.73 C201.2 185.69,81.45 R333.2 ; 75.95,11.38 LOUT1.5 ; LOUT1.5 75.95,14.32 ; LOUT1.5 77.02,12.85 ; LOUT1.5 74.88,12.85 ; v3(189.36,81.14) 188.93,81.57 C202.2 ; C206.2 175.51,79.74 v3(175.39,79.61) ; R249.2 170.69,86.47 v5(170.94,86.72)
  BOTTOM w0.508: R1230.2 69.19,9.13 v3(69.11,9.2) ; LOUT1.5 77.02,12.85 ; LOUT1.5 75.95,14.32 ; LOUT1.5 74.88,12.85 ; 193.82,83.35 UHS1.5 192.4,84.37 ; 80.8,16.1 LOUT1.P ; LOUT1.P 82.27,17.12 ; LOUT1.P 83.74,16.1 ; LOUT1.P 82.27,15.08 ; v3(189.33,85.39) 187.19,85.39 C525.2 ; 171.32,90.37 TC17.2 172.38,91.42
  vias: v1(188.37,80.25) v3(69.34,10.26) v3(73.36,11.22) v3(189.23,89.47) v3(189.38,88.71) v3(191.03,94.01) v3(192.91,92.29) v3(193.04,91.17)
AVCC33_2136: length 5.6
  TOP w0.508: C43.1 132.16,206.21 v3(132.33,206.38) ; v3(132.33,206.38) 132.02,206.7 C36.1 ; v3(132.33,206.38) 132.97,207.02 C35.1
  BOTTOM w0.203: U37.5 132.3,206.42 v3(132.33,206.38)
  vias: v1(132.77,203.13)
DVCC33_2136: length 30.6
  TOP w0.508: v5(127.28,212.43) 124.18,212.43 v3(121.41,209.66) ; v3(127.66,203.23) 127.66,204.1 127.58,204.18 ; v1(127.58,204.23) 127.58,204.18 ; 127.58,204.18 126.47,205.3 126.47,206.79 127.25,207.58 127.25,208.41 126.26,209.41 125.88,209.41 125.52,209.77 125.52,210.77
  L4 w0.508: v3(127.66,203.23) 129.74,201.15 v3(130.68,201.15) 132.64,201.15 v3(133.76,200.03)
  BOTTOM w0.203: v5(127.28,212.43) 127.46,212.43 127.94,211.95 U37.22 ; U37.18 127.53,210.35 v3(127.38,210.5)
  BOTTOM w0.508: v3(121.41,209.66) R724.1 R725.1 ; R763.2 130.94,200.9 v3(130.68,201.15) ; R762.1 134.3,200.58 v3(133.76,200.03)
