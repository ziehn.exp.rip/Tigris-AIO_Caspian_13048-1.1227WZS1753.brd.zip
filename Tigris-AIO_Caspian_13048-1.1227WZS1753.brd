# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GND_AUD: length 5.1
  TOP w0.203: v1(183.97,87.77) 183.73,88.01 U16.40
  TOP w0.305: v1(183.97,87.77) 184,87.77 184.66,87.11 C187.2
  TOP w0.508: C184.1 185.03,87.6 185.03,87.23 C187.2
V5_ALW_MON: length 6.4
  TOP w0.254: v3(60.03,44) 60.03,43.88 60.33,43.58 U24.15
  BOTTOM w0.254: R1022.2 60.85,44.87 R1025.1 60.85,42.4 Q104.3 ; R1022.2 60.64,44.88 60.02,44.26 60.02,44 v3(60.03,44) ; R1022.2 v2(61.85,44.88)
V5_ALW_MON_1: length 5.4
  BOTTOM w0.254: Q104.5 63.47,41.67 63.69,41.45 63.69,41.25 63.46,41.02 Q104.6 62.81,40.74 63.31,40.24 R1046.2 63.44,39.48 64.64,39.48 v2(64.85,39.68)
V5_ALW_MON_2: length 6.1
  BOTTOM w0.254: Q104.2 60.37,41.67 60.17,41.47 60.17,41.23 59.51,40.57 59.51,39.84 v2(59.61,39.73) 59.74,39.61 R1047.2 60.83,39.29 R1041.1 C685.1
VBAT1: length 28.1
  TOP w0.508: 102.62,219.91 BTPWR1.2 101.56,220.96
  TOP w0.889: BT1.1 76.92,215.35 81.9,220.33 100.33,220.33
VBAT1_C: length 31.2
  TOP w0.508: BTPWR1.1 102.43,223.69 R1225.2 99.63,223.63 v1(75.56,223.63) R31.1
VBAT1_R: length 9.6
  TOP w0.508: D1.A 71.93,231.05 71.93,227.32 D2.2 71.56,226.23 v3(70.68,225.35) R31.2
  BOTTOM w0.508: TP1.1 71.02,225 v3(70.68,225.35)
VBAT2: length 268.3
  TOP w0.203: U24.21 62.87,45.98
  TOP w0.508: D1.K 67.03,228.43 67.03,219.97 v5(67.94,219.06) ; v3(81.56,66.25) 81.56,64.71 79.83,62.99 77.93,62.99 67.77,52.83 67.77,47.61 67.11,46.95 67.11,43.64 65.97,42.5 65.19,42.5 64.78,42.92 64.78,43 64.8,43.02 64.8,43.56 64.58,43.78 R518.1 C272.1 63.53,45.32 62.87,45.98
  L4 w0.508: v3(103.2,73.77) 105.43,73.77 111.4,79.74 111.4,103.05 99.15,115.3 84.26,115.3 52.55,147.01 52.55,169.63 53.72,170.8 53.72,202.27 59.05,207.61 59.05,209.91 63.25,214.11 65.13,214.11 67.94,216.93 v5(67.94,219.06)
  BOTTOM w0.508: v3(103.2,73.77) 101.24,73.77 v2(100.51,73.03) 100.51,72.02 98.27,69.78 87.99,69.78 84.46,66.25 v3(81.56,66.25)
VCC: length 368.6
  TOP w0.508: R160.1 v3(14.05,144.89) ; v3(33.21,149.59) 31.56,149.59 31.09,150.06 31.09,150.96 29.74,152.31 28.47,152.31 27.41,153.37 21.39,153.37 v3(21.13,153.12) 20.5,152.49 19.86,152.49 18.33,154.02 R150.1 17.95,154.16 12.61,154.16 v3(12.47,154.02) ; 139.19,46.97 139.53,46.64 140.49,46.64 141.26,47.41 144.38,47.41 144.4,47.38 144.77,47.38 Q61.G 147.61,47.58 C263.1 ; v3(24.18,162.75) 23.7,163.23 R113.2 ; v3(43.59,136.99) 44.22,136.36 PR44.2 ; v5(33.68,147.15) 33.68,145.48 33.71,145.45 33.71,145.37 33.96,145.12 34.04,145.12 34.07,145.08 PR11.1 ; v5(57.99,28.69) 57.72,28.95 54.35,28.95 53.47,29.83 51.47,29.83 v3(51.44,29.8) ; v3(185.42,186.42) 185.42,186.41 185.03,186.41 184.78,186.17 R105.1
  TOP w1.016: LPC1.8 128.14,40.55 v5(128.14,43.47) ; FANC2.3 108.29,46.85 105.37,46.85 C266.1
  L3 w0.508: v5(33.68,147.15) 33.83,147.3 38.73,147.3 40.87,145.17 40.87,145.01 41.26,144.62 41.41,144.62 44.45,141.59 44.45,137.86 v3(43.59,136.99)
  L4 w0.508: v5(33.68,147.15) 33.68,149.12 v3(33.21,149.59) ; v3(185.42,186.42) 186.06,185.78 186.06,183.37 191.59,177.83 191.59,169.79 192.05,169.34 192.05,151.27 189.7,148.92 189.7,104.72 186.97,101.99 v3(186.97,97.52) ; v5(12.19,229.29) 16.78,229.29 v3(17.44,229.94) 15.98,231.4 15.98,234.88 16.87,235.77 17.1,235.77 v3(17.71,236.38) ; v3(21.13,153.12) 22.02,154.01 22.02,157.73 24.18,159.89 v3(24.18,162.75)
  BOTTOM w0.203: v3(17.71,236.38) 17.45,236.63 U35.21
  BOTTOM w0.356: Q111.4 47.37,32.91 47.37,31.25 48.16,30.46 50.81,30.46 51.44,29.83 v3(51.44,29.8)
  BOTTOM w0.508: PR95.1 33.44,144.2 33.88,144.64 33.88,145.59 33.68,145.79 v5(33.68,147.15) ; R694.1 v5(12.19,229.29) 10.52,229.29 9.78,230.03 R689.2 v5(5.64,231.95) ; 186.97,97.51 v2(185.42,95.96) R896.1 ; 186.97,97.51 186.97,96.02 191.08,91.91 191.08,90.76 190.5,90.18 190.5,83.63 188.54,81.67 188.52,81.67 188.37,81.52 183.16,81.52 183.01,81.37 181.11,81.37 180.29,80.54 180.29,79.03 173.35,72.09 173.35,66.04 165.27,57.95 164.82,57.95 161.23,54.37 157.98,54.37 155.19,51.57 155.19,48.35 153.13,46.29 141.76,46.29 139.52,44.05 135.58,44.05 134.94,43.42 v5(134.39,43.42) ; 186.97,97.51 v3(186.97,97.52) ; R1221.2 v3(17.44,229.94) ; R729.1 v3(5.61,206.93)
  BOTTOM w0.635: R660.1 103.7,240.08 103.35,240.43 Q88.G 101.07,241.14 97.6,241.14 95.99,242.75 95.99,244.19 v5(96.14,244.33)
  BOTTOM w1.016: v5(134.39,43.42) 134.06,43.75 133.78,43.75 133.17,44.36 132.28,44.36 132.27,44.37 131.45,44.37 131.43,44.36 131.26,44.36 131.25,44.37 130.35,44.37 130.34,44.38 129.52,44.38 129.49,44.36 129.03,44.36 v5(128.14,43.47) 127.71,43.04 v2(118.16,43.04) 112.1,43.04 FANC2.3 ; R631.2 v3(13.77,247.76)
  vias: v1(139.14,48.62) v2(12.85,86.88) v2(65.41,20.05) v2(96.09,245.42) v2(125.73,26.55) v5(5.39,87.36) v5(5.39,86.44) v5(6.3,87.36) v5(6.3,86.44) v5(9.53,47.61) v5(10.41,46.72) v5(15.42,84.41) v5(15.42,83.5) v5(16.33,84.41) v5(16.33,83.5) v5(59.94,8.75) v5(60.96,8.75) v5(95.12,244.33) v5(97.28,244.33) v5(126.16,25.28) v5(126.16,24.37) v5(127.08,25.28) v5(127.08,24.37) v5(129.72,34.55) v5(130.68,34.55) v5(137.65,11.89) v5(137.65,10.98) v5(138.57,11.89) v5(138.57,10.98)
VCC3: length 1005.2
  TOP w0.203: U16.11 177.52,92.84 v3(177.16,93.2) ; U24.4 62.33,39.18 62.74,38.77 v3(62.74,38.21)
  TOP w0.254: U29.AW9 v4(147.06,68.68) ; v4(139.22,63.63) 139.33,63.73 U29.AG1
  TOP w0.305: U21.6 158.81,60.28 158.45,60.64 157.09,60.64 R438.1 ; U29.AT5 144.08,66.53 v3(144.45,66.16) ; v4(138.16,78.26) 138.2,78.22 138.23,78.22 U29.AF26 ; v3(144.01,44.38) 143.93,44.31 143.76,44.31 143.36,43.9 U23.24 U22.24 ; U22.19 U23.19 146.61,43.42 146.82,43.63 146.82,44.12 v3(146.25,44.69)
  TOP w0.33: DIMM1.199 165.5,125.9 v5(166.7,124.7) ; DIMM2.199 150.31,125.9 151.13,125.08 v5(151.13,123.05)
  TOP w0.356: U23.10 U22.10 146.61,37.35 146.63,37.37 146.63,37.78 146.43,37.98 v3(146.23,37.98) ; v4(133.05,79.1) 133.09,79.15 133.61,79.15 U29.U30 134.33,79.38 134.91,79.38 U29.W30 135.28,79.63 v4(135.63,79.97) ; U21.6 158.81,58.3 159.11,58 160.53,58 161.16,58.63 v5(161.16,59.22)
  TOP w0.406: v3(63.42,29.6) 63.35,29.52 62.19,29.52 61.75,29.08 61.75,27.56 60.58,26.39 60.58,25.56 60.76,25.38 U32.2
  TOP w0.457: v3(51.94,57.51) 51.82,57.39 R460.1
  TOP w0.508: R54.1 142.61,214.16 143.05,214.16 v3(143.67,214.78) ; R166.1 15.28,121.9 15.28,122.07 15.73,122.51 15.89,122.51 R165.1 16.47,122.73 16.92,122.28 v5(16.97,122.28) ; v3(58.19,57.25) 58.19,57.1 R450.2 ; R68.1 143.98,208.33 v3(143.97,208.34) ; R268.1 120.46,92.51 R264.2 ; R268.1 121.64,92.43 R271.2 R272.1 123.44,93.05 123.44,93.07 123.57,93.2 123.6,93.2 v3(123.7,93.3) ; R268.1 119.24,92.43 R270.2 119.22,93.1 118.34,93.99 117.21,93.99 115.94,92.72 115.94,92.52 R266.2 ; v3(159.66,223.07) 159.66,223.53 159.96,223.82 R30.1 ; v3(35.69,48.88) 35.94,49.13 38.1,49.13 38.8,48.43 R494.1 ; R508.1 125.57,43.39 124.3,42.11 LPC1.4 ; U2.3 146.56,218.12 146.89,218.45 v3(146.89,218.47) ; 163.32,77.2 163.22,77.3 160.43,77.3 160.02,77.71 159.91,77.71 R357.2 ; R505.2 41.49,45.45 v3(40.51,45.45) ; v3(89.1,62.52) 89.1,63.74 88.41,64.43 v3(88.41,66.15) 88.41,66.64 87.5,67.55 87.47,67.55 87.04,67.99 87.04,68.01 86.66,68.39 Q51.S 85.52,68.39 84.57,69.34 83.54,69.34 83.35,69.15 82.92,69.15 R413.1 ; R579.1 v3(9.33,18.08) ; v3(14.73,39.4) 14.9,39.23 R537.1 ; v5(164.36,79.23) 166.24,79.23 167.35,78.13 172.6,78.13 173.86,79.38 173.86,81.69 173.43,82.13 v5(173.25,82.13) ; U1.3 133.65,215.43 133.32,215.76 133.32,215.99 132.85,216.45 R44.1 132.96,218.78 137.54,218.78 138.35,217.97 U1.8 140.59,217.97 141.77,216.79 R49.1 142.29,216.84 142.29,216.98 143.15,217.84 v5(143.64,217.84) ; R234.1 117.09,96.36 117.74,97.01 v3(117.93,97.01) 117.93,96.99 118.13,96.79 R235.1 ; R75.1 v3(136.08,207.43) ; v3(143.07,213.26) 142.75,212.94 R60.1 ; v3(40.64,43.54) 40.89,43.8 41.24,43.8 R521.2 ; v5(17.4,110.52) 17.4,110.52 16.72,109.84 R186.1 ; v3(153.64,78.34) 153.61,78.34 R361.1 ; R211.1 v3(151.66,99.93) PR70.1 150.69,100.77 R205.1 ; R242.1 121.21,96.39 121.21,96.93 120.77,97.37 120.61,97.37 R237.2 120.25,97.73 120.25,98.46 R220.2 120.8,98.19 R1153.2 121.96,98.19 122.22,97.93 122.24,97.93 122.73,97.43 122.73,97.42 123.37,96.78 v3(123.55,96.78) ; D5.2 27.51,150.71 28.36,150.71 R152.1 28.45,150.62 28.45,150.07 v3(28.78,149.74) ; 181.66,162.44 181.66,166.53 182.72,167.59 184.28,167.59 185.34,168.65 185.34,171.41 184.36,172.4 179.85,172.4 174.98,177.27 174.98,188.48 173.58,189.87 173.58,196.33 174.22,196.96 R90.1 ; v3(129.16,203.03) 129.26,203.13 L4.1 ; v3(53.9,57.51) R461.2 ; R176.1 12.9,110.98 v5(12.75,110.83) ; R340.2 v3(119.95,81.84) ; v3(138.94,43.16) 139.38,43.61 R476.1 ; 54.18,30.59 54.18,30.06 54.53,29.7 56.01,29.7 56.79,30.49 63.32,30.49 64.39,31.56 v3(64.39,32.32) 65.46,33.38 65.46,37.29 64.97,37.78 63.91,37.78 63.47,38.21 v3(62.74,38.21) ; R483.2 143.64,50.03 143.43,49.82 143.43,48.8 143.51,48.73 143.51,48.24 143.48,48.21 v3(143.48,48.09) ; 145.16,59.04 144.91,58.78 143.13,58.78 142.27,57.93 142.27,56.09 R470.1 141.54,54.89 R479.1 ; R1156.1 148.53,18.93 v3(148.59,18.87) ; R33.1 117.16,223.67 v5(117.83,224.34) ; v5(169.24,68.56) 169.29,68.51 169.29,65.72 163.47,59.9 163.47,59.89 163.02,59.44 163.01,59.44 162.78,59.22 v5(161.16,59.22) ; R384.1 40.29,72.88 40.29,72.78 41.75,71.32 41.75,69.36 42.29,68.82 43.48,68.82 44.37,67.93 44.37,64.3 42.16,62.09 v3(42.16,61.71) 41.33,60.87 R441.1 ; R83.1 128.78,201.34 128.78,200.62 v5(129.01,200.39) 129.17,200.39 131.04,198.52 131.04,197.14 131.53,196.64 R92.1 ; v5(17.35,109.1) 17.35,108.8 16.99,108.44 R189.1 ; v3(126.34,97.37) 126.29,97.32 126.21,97.32 125.85,96.95 125.85,96.86 125.22,96.24 R238.2 ; R534.1 118.16,39.53 118.47,39.84 v3(118.51,39.84) ; R172.1 17.55,116.95 18.16,117.56 v5(18.16,117.59) 17.78,117.59 17.4,117.97 R171.1 ; R427.1 112.75,65.34 113.1,64.99 113.1,60.31 112.34,59.55 ; R222.1 181.54,98.46 183.08,98.46 183.29,98.26 ; v3(134.04,97.55) 134.14,97.55 134.77,98.18 136.84,98.18 138.16,99.5 141.6,99.5 141.81,99.29 143.77,99.29 143.89,99.42 v3(144.5,99.42) ; C178.1 v3(6.48,91.37)
  TOP w0.559: 183.29,98.26 184.02,97.52 184.02,95.04 R247.1 183.64,94.66 183.64,94.41 183.31,94.07 183.31,93.54 v3(183.24,93.47) ; R35.1 63.86,221.01 R37.1 63.94,224.15 64.57,224.77 64.57,242 63.53,243.04 56.69,243.04 55.5,244.23 55.5,246.01 53.88,247.63 50.6,247.63 49.71,246.73 v3(49.71,246.5) ; D9.K 118.21,38.33 117.73,38.81 117.73,39.5 R534.1
  TOP w0.61: R437.1 88.38,61.71 89.1,62.43 v3(89.1,62.52)
  TOP w0.635: U2.8 v5(149.1,213.39)
  TOP w0.762: R192.2 148.29,108.01 148.97,108.7 149.35,108.7 v3(149.48,108.57) 149.48,113.71 149.76,113.99 149.76,121.68 v5(151.13,123.05) ; v5(185.42,138.79) 179.32,144.89 179.32,149.08
  L3 w0.508: v3(134.04,97.55) 133.88,97.55 130.15,93.81 130.15,88.88 128.68,87.41 128.68,84.36 127.53,83.21 127.53,82.27 v3(127.96,81.84) 127.69,81.56 127.69,80.46 128.05,80.1 130.05,80.1 130.45,79.69 v4(130.45,79.49) ; v3(64.39,32.32) 64.39,30.61 63.78,30 63.78,29.96 v3(63.42,29.6) 63.42,29.32 63.91,28.83 63.91,25.23 v3(64.39,24.75) ; v3(89.1,62.52) 89.1,62.5 88.51,61.91 87.51,61.91 84.48,64.94 77.56,64.94 69.15,64.94 62.55,58.34 59.28,58.34 v3(58.19,57.25) 57.98,57.46 57.76,57.46 57.71,57.51 v3(53.9,57.51) 53.31,58.1 52.51,58.1 51.94,57.53 v3(51.94,57.51) ; LPC1.4 124.3,41.41 ; v3(40.51,45.45) 41,45.45 42.32,44.14 42.32,38.62 v3(41.91,38.21) 41.91,36.69 45.73,32.87 45.73,30.42 v3(45.8,30.35) ; v3(119.95,81.84) 119.95,84.38 121.16,85.58 121.16,90.77 v3(123.7,93.3) 122.91,94.09 122.91,96.27 123.3,96.66 123.43,96.66 v3(123.55,96.78)
  L4 w0.508: v3(151.66,99.93) 151.56,99.93 150.83,100.66 146.65,100.66 ; v4(133.05,79.1) 132.7,78.76 131.39,78.76 131.37,78.78 131.16,78.78 v4(130.45,79.49) ; v3(119.95,81.84) 119.99,81.8 126.01,81.8 126.42,82.21 127.59,82.21 v3(127.96,81.84) ; v3(181.74,160.89) 182.43,161.58 183.26,161.58 183.87,160.98 183.87,158.96 184.66,158.18 v3(184.66,157.95) ; v3(138.79,70.77) 138.79,70.81 138.05,71.55 138.05,78.15 v4(138.16,78.26) 137.2,78.26 135.63,79.83 v4(135.63,79.97) ; v3(18.14,33.31) 15.21,36.23 15.21,39 14.99,39.23 14.9,39.23 v3(14.73,39.4) ; v3(117.93,97.01) 123.32,97.01 v3(123.55,96.78) ; v5(173.25,82.13) 173.25,82.3 172.51,83.04 171.45,83.04 169.54,84.95 169.54,92.19 170.56,93.2 v3(177.16,93.2) ; v3(54.2,50.45) 54.08,50.33 54.08,50.26 53.69,49.87 53.14,49.87 51.9,51.11 46.3,51.11 45.72,50.53 43.72,50.53 42.49,49.3 42.49,46.29 41.66,45.45 v3(40.51,45.45)
  L4 w0.762: v5(169.24,68.56) 169.24,71.38 167.78,72.84 167.78,77.57 167,78.34 165.25,78.34 v5(164.36,79.23) 165.84,80.71 165.84,81.39 164.23,82.99 164.23,89.79 164.07,89.95 164.07,93.52 171.14,100.59 176.3,100.59 176.31,100.61 177.11,100.61 178.4,101.9 178.4,102.69 178.4,102.69 178.4,109.41 177.44,110.36 177.44,116.06 179.1,117.71 179.1,122.23 180.18,123.31 180.18,130.12 185.42,135.37 v5(185.42,138.79) ; v5(151.13,123.05) 151.13,122.5 152.48,121.15 164.26,121.15 166.7,123.59 v5(166.7,124.7)
  L4 w1.27: v3(28.78,149.74) 28.45,149.41 28.45,142.64 28.91,142.19 28.91,137.65 28.21,136.96 28.21,134.43 18.44,124.66 18.44,124.52 16.97,123.05 v5(16.97,122.28) 16.97,118.77 v5(18.16,117.59) 18.16,117.56 16.61,116.01 16.61,111.31 v5(17.4,110.52)
  BOTTOM w0.203: U39.12 181.28,160.31 181.74,160.77 v3(181.74,160.89) ; v3(180.48,161.02) U39.10 ; U39.18 184.53,158.08 v3(184.66,157.95)
  BOTTOM w0.305: R869.2 126.95,98.88 126.95,97.98 126.85,97.88 126.85,97.8 126.52,97.47 126.44,97.47 v3(126.34,97.37)
  BOTTOM w0.356: 138.86,68.18 138.38,67.7 R985.1 138.33,67.38 138.33,66.58 138.04,66.29 138.04,65.69 137.61,65.26 C646.1
  BOTTOM w0.381: Q109.4 43.4,36.42 42.56,37.26 R1057.1
  BOTTOM w0.406: v3(126.34,97.37) 126.06,97.37 125.45,97.98 R322.1
  BOTTOM w0.508: R1011.1 53.85,49.62 54.2,49.97 v3(54.2,50.45) ; v3(123.55,96.78) 123.59,96.78 123.88,96.49 125.46,96.49 126.29,97.32 126.29,97.32 v3(126.34,97.37) ; R1082.1 R1081.1 52.35,31.28 52.58,31.05 v3(53.14,31.05) ; R1228.2 93.65,241.44 92.84,242.25 v3(92.84,242.96) ; R1030.1 41.59,45.05 41.15,45.5 40.66,45.5 40.57,45.45 v3(40.51,45.45) ; R1030.1 41.34,43.54 v3(40.64,43.54) 40.49,43.39 38.6,43.39 v2(38.13,43.87) 37.41,44.58 37.41,47.15 v3(35.69,48.88) 35.63,48.82 35.63,48.02 35.24,47.63 32.64,47.63 32.51,47.76 32.01,48.27 15.65,48.27 10.87,43.49 v3(9.47,43.49) ; R1030.1 41.67,43.21 41.45,42.99 41.45,41.39 R1037.1 ; R1076.1 46.23,32.55 45.8,32.11 v3(45.8,30.35) ; R811.1 8.28,181.42 8.61,181.09 v5(9.14,181.09) 10.03,181.97 D16.K ; v3(105.28,62.21) 102.84,64.65 102.84,66.02 102.18,66.68 88.95,66.68 v3(88.41,66.15) ; v3(143.48,48.09) 143.68,47.89 144.95,47.89 150.64,53.58 v2(153.92,53.58) 155.63,53.58 v3(156.97,54.92) ; C666.1 142.75,42.02 144.53,40.24 144.53,39.43 144.91,39.05 C655.1 145.15,38.48 145.44,38.19 146.02,38.19 v3(146.23,37.98) ; C666.1 143.33,44.38 v3(144.01,44.38) 144.17,44.38 144.2,44.36 144.58,44.36 144.84,44.62 C657.1 146.19,44.62 v3(146.25,44.69) 147.13,44.69 C656.1 ; C666.1 142.37,43.42 142.37,43.32 141.65,42.61 139.5,42.61 v3(138.94,43.16) 138,43.16 137.36,42.53 133.75,42.53 132.89,43.38 v5(131.86,43.38) ; C584.1 173.29,82.09 v5(173.25,82.13) 173.25,82.3 173.1,82.45 173.1,83.14 C729.1 L33.1 ; R727.1 R726.1 118.43,208.58 119.05,209.2 v5(119.28,209.2) ; v5(161.16,59.22) 160.26,60.12 C661.2 157.21,60.12 C660.1 156.41,59.8 155.75,59.8 155.72,59.78 155.17,59.78 155.15,59.8 151.76,59.8 151.19,60.38 151.19,63.55 150.62,64.12 149.1,64.12 ; v4(139.22,63.63) 138.91,63.63 138.91,63.65 C650.1 138.4,64.02 137.49,64.02 R992.2 137.36,64.15 137.36,65.16 C646.1 ; 138.86,68.18 139.03,68.18 139.39,68.54 139.39,69.25 v4(140.06,69.91) ; LPC1.4 123.26,41.44 121,41.44 119.4,39.84 v3(118.51,39.84) ; v3(136.08,207.43) 135.46,206.8 R738.2 ; R849.2 169.74,124.7 v5(166.7,124.7) 165.81,125.59 C470.1 C469.1 ; C692.1 C693.1 R1061.1 16.28,35.3 D20.2 18.14,33.44 v3(18.14,33.31) 18.14,33.32 21.03,33.32 21.49,32.85 R1078.2 ; R888.1 134.09,97.01 134.09,97.39 134.04,97.44 v3(134.04,97.55) ; R1049.1 41.44,38.87 41.91,38.4 v3(41.91,38.21) 41.86,38.16 41.86,37.31 R1057.1 ; R919.2 123.95,93.05 v3(123.7,93.3) 123.7,93.46 123.99,93.74 R913.1 124.52,93.58 125.02,93.08 125.02,93.08 R918.2 ; C472.1 151.7,125.21 C474.1 151.7,123.62 v5(151.13,123.05) 150.6,123.58 R850.1 ; v3(5.71,62.21) 9.02,62.21 9.19,62.04 34.9,62.04 34.94,62.07 41.8,62.07 v3(42.16,61.71) ; R962.2 151.84,78.6 152.23,78.98 153.05,78.98 153.44,78.6 153.44,78.55 v3(153.64,78.34) 154.18,78.34 156.21,80.37 v3(157.1,80.37) 161.56,80.37 161.7,80.51 163.08,80.51 v5(164.36,79.23) ; R642.1 50.04,245.9 49.71,246.23 v3(49.71,246.5) ; v3(183.24,93.47) 181.6,91.83 179.15,91.83 178.08,90.76 C560.1 177.37,91.27 177.37,91.56 C550.1 177.41,92.96 v3(177.16,93.2) ; R1080.2 62.73,36.64 62.86,36.64 63.4,37.18 63.4,37.72 63.01,38.11 62.84,38.11 v3(62.74,38.21) ; v3(144.5,99.42) R863.1 ; v3(9.87,29.35) 10.02,29.5 13.52,29.5 13.61,29.35 D21.2
  BOTTOM w0.559: R633.1 v3(11.07,246.85) ; R647.1 v3(22.38,247.08)
  vias: v2(8.31,108.77) v2(134.16,29.45) v2(148.21,66.79) v2(171.88,221.68) v3(6.48,92.19) v3(9.02,33.51) v3(9.02,32.75) v3(34.04,6.97) v3(182.73,163.64) v3(183.62,163.81) v4(143.08,67.12) v5(5,109.79) v5(5.03,108.67) v5(5.99,109.76) v5(6.02,108.65) v5(67.77,3.49) v5(68.73,3.51) v5(69.72,3.51) v5(70.69,3.49) v5(84.66,5.32) v5(85.62,5.34) v5(86.66,5.37) v5(100.33,246.36) v5(100.84,245.6) v5(101.35,246.36) v5(115.49,56.68) v5(116.15,56.02) v5(122.58,44.05) v5(123.55,44.03) v5(129.93,43.39) v5(130.09,29.8) v5(130.84,43.38) v5(130.92,30.34) v5(131.32,31.23) v5(141.86,11.95) v5(141.86,10.93) v5(141.86,9.92) v5(143,11.92) v5(143,10.91) v5(143,9.89) v5(146,60.13) v5(146,59.19) v5(146.53,65.67) v5(146.94,60.39) v5(146.94,59.45) v5(164.59,53.96) v5(165.25,54.59) v5(165.88,55.26) v5(170.46,221.8)
VCC3_3SB_EN_2: length 58.9
  TOP w0.254: v3(47.12,46.32) 47.65,46.32 48.65,45.32 50.93,45.32 55.33,40.92 v3(57.65,40.92) ; Q58.G 33.43,60.69 31.88,60.69 30.99,59.8 Q125.G 30.61,59.19 30.61,58.28 32.26,56.63 35.56,56.63 36.35,55.84 37.99,55.84 39.52,54.31 39.52,52.84 38.13,51.44 v3(38.13,51.29)
  BOTTOM w0.254: D19.K 50.98,43.8 R1035.2 ; D19.K 51.59,44.92 50.6,45.91 50.55,45.91 50.29,46.17 R1020.2 50.01,46.12 R1023.2 ; D19.K 51.94,44.05 53.26,44.05 C679.2 54.78,43.7 R1026.2 55.14,42.35 55.5,42 55.65,42 56.74,40.9 R1044.2 57.34,40.61 v3(57.65,40.92) ; v3(47.12,46.32) 46.97,46.47 46.49,46.47 v2(45.35,47.6) 45.14,47.81 43.88,47.81 42.19,49.5 42.19,50.01 40.91,51.29 v3(38.13,51.29)
VCC3_CAM: length 2.3
  TOP w0.762: WEBCM1.3 v5(169.49,226.98)
  vias: v2(173.96,222.36)
VCC3_HDD: length 8.5
  TOP w0.508: SATAP1.5 7.78,95.05 ; SATAP1.5 6.62,96.21 ; SATAP1.5 5.46,95.05
  TOP w1.27: SATAP1.5 8.89,92.78 R284.2
VCC5_DDC_HDMI: length 19.4
  TOP w0.102: C335.2 60.36,30.06 63.83,30.06 64.9,31.12 66.12,31.12 v1(66.22,31.02) 66.24,31 66.24,29.71 R583.1 ; C335.2 58.65,28.81 57.78,29.68 v3(57.2,29.68) ; C335.2 59.12,28.5 58.52,27.9 58.52,25.09 R599.1
  BOTTOM w0.102: D23.K 57.1,29.57 v3(57.2,29.68)
VCC5_PANEL: length 31.7
  TOP w0.254: R46.1 126.78,217.41 128.14,217.41 128.24,217.51 128.64,217.51 R1120.1
  TOP w0.508: R45.1 150.39,217.24 v3(150.39,216.37)
  L4 w0.508: v5(125.45,219.95) 125.93,219.47 127.17,219.47 127.26,219.38 127.85,219.38 128.34,218.88 138.61,218.88 141.25,216.24 150.27,216.24 v3(150.39,216.37)
  vias: v1(122.68,219.44) v2(124.7,221.69) v5(124.33,219.95)
VCC5_USB: length 148.6
  L3 w0.508: v5(39.5,15.48) 38.73,15.48 37.72,16.49 37.72,21.48 39.27,23.02 39.27,24.11 39.81,24.65 41.31,24.65 41.38,24.57 41.93,24.57 42.01,24.65 42.06,24.65 43.81,26.4 43.81,32.41 43.33,32.9 v3(43.18,32.9)
  L4 w1.016: v3(16.18,23.76) 16.36,23.76 17.5,22.62 25.23,22.62 25.23,22.61 26.29,22.61 28.78,20.13 28.78,17.99 33.15,13.62 33.15,10.52 v5(34.54,9.13)
  BOTTOM w0.508: v3(43.18,32.9) 43.23,32.9 42.98,33.16 R1071.2
  BOTTOM w1.016: v5(108.97,26.27) 108.97,26.15 106.98,24.17 106.98,23.23 100.42,16.67 94.57,16.67 91.59,19.65 72.04,19.65 69.09,16.7 69.09,12.53 66.24,9.69 66.24,9.48 63.35,6.59 46.1,6.59 42.8,9.89 42.8,12.43 39.75,15.48 v5(39.5,15.48) 38.86,15.48 35.31,11.92 35.31,9.89 v5(34.54,9.13)
  vias: v2(112.45,34.27) v2(151.46,34.76) v2(183.87,107.15) v5(111.02,34.4) v5(111.06,33.16) v5(163.86,50.58) v5(164.64,51.37) v5(164.9,50.45) v5(182.37,107.81) v5(182.5,106.79)
VCC5SB_EN_2: length 124.2
  TOP w0.254: v3(123.29,35.24) 122.78,35.24 122,34.45 122,32.32 120.27,30.59 120.27,24.97 119.14,23.83 119.14,18.64 v3(121.77,16)
  L3 w0.254: v3(51.21,39.91) 51.21,39.73 51.52,39.42 51.52,37.82 54.71,34.63 55.05,34.63 55.69,33.99 55.69,30.77 56.1,30.36 57.31,30.36 60.73,26.94 60.73,24.86 67.39,18.2 69.39,18.2 74.17,13.41 74.17,11.23 74.37,11.03 77.52,11.03 80.13,13.64 81.75,13.64 81.75,13.64 86.32,13.64 87.01,13.64 90.68,17.31 92.66,17.31 93.68,16.28 101.42,16.28 102.82,17.69 105.87,17.69 106.48,17.08 115.33,17.08 115.98,17.73 118.73,17.73 120.45,16 v3(121.77,16)
  BOTTOM w0.254: v3(51.21,39.91) 51.18,39.89 v2(50.15,39.89) C683.1 49.05,40.04 49.05,40.07 48.84,40.27 R1038.2 48.92,40.92 C681.1 50.89,40.92 R1035.1 ; v3(123.29,35.24) 123.62,34.91 Q112.G
VCC12: length 122.2
  L4 w1.27: v5(21.49,74.76) 21.49,78.28 21.18,78.58 21.18,98.69 14.99,104.89 14.99,115.93 v5(12.83,118.09) 12.83,118.8 14.38,120.35 14.38,123.45 19.53,128.61 19.53,129.35 23.27,133.08 23.27,145.98 24.23,146.95 24.23,153.32 23.33,154.22 23.33,157.61 25.22,159.5 25.22,163.18 23.88,164.53 22.2,164.53 20.14,166.58 20.14,182.53 v3(18.79,183.88)
  vias: v2(18.92,182.81)
VCC12_FAN: length 12
  TOP w1.27: v5(7.62,188.58) v5(7.62,187.18) 7.62,186.67 7.32,186.37 FANC1.2
  vias: v2(11.68,189.21)
VCC12_HDD: length 14.1
  TOP w0.508: SATAP1.1 7.78,105.05 ; SATAP1.1 6.62,106.21 ; SATAP1.1 6.62,103.89 ; SATAP1.1 5.46,105.05
  BOTTOM w1.27: SATAP1.1 11.18,105.05 13.48,107.35 F12.2
VCC12_HDD_C:
  vias: v2(19.63,106.56) v2(19.76,113.93) v5(18.52,107.12) v5(18.52,106.11)
VCC12CPU: length 201.8
  TOP w0.508: 10.12,166.36 ATX1.4 ; ATX1.4 8.93,167.55 ; ATX1.4 11.31,167.55 ; ATX1.4 10.12,168.74 ; 10.12,163.36 ATX1.3 ; ATX1.3 11.31,164.55 ; ATX1.3 10.12,165.74 ; ATX1.3 8.93,164.55 ; v3(47.12,45.2) 47.12,44.54 50.65,41 51.44,41 53.72,38.72 v3(54.61,38.72)
  L4 w0.508: v3(2.03,151.39) 1.96,151.47 1.96,161.83 v3(1.98,161.86)
  BOTTOM w0.508: ATX1.3 11.31,164.55 ; ATX1.3 10.12,163.36 ; ATX1.3 10.12,165.74 ; ATX1.3 8.93,164.55 ; v3(54.61,38.72) 54.94,38.39 54.96,38.39 55.75,37.6 R1059.1 ; v3(47.12,45.2) 46.83,45.48 46.83,45.59 46.59,45.83 46.02,45.83 45.07,46.78 43.93,46.78 43.71,46.56 43.16,46.56 41.15,48.58 41.15,50.14 40.64,50.65 38.75,50.65 37.16,49.06 36.44,49.06 35.66,49.84 8.97,49.84 8.14,49.01 5.81,49.01 2.03,52.79 v3(2.03,151.39) ; 8.93,167.55 ATX1.4 ; ATX1.4 11.31,167.55 ; ATX1.4 10.12,166.36 ; ATX1.4 10.12,168.74 ; 9.4,163.43 8.38,162.42 2.54,162.42 v3(1.98,161.86)
  BOTTOM w0.559: v3(9.88,234.55) 10.35,235.02 R677.1
  vias: v1(8.51,230.23) v1(11.84,198.69) v1(12.22,219.74) v2(3.81,195.44) v5(5.84,220.84) v5(5.84,219.82) v5(5.84,218.68) v5(5.84,217.53) v5(5.84,196.83) v5(5.84,195.82) v5(5.84,194.67) v5(5.84,193.53) v5(11.94,181.21) v5(11.96,180.27)
VCC_SENSE: length 114.9
  TOP w0.267: CPU1.E40 66.58,186.12 66.58,188.43 68.23,190.08 68.23,192 67.11,193.12 67.11,194.43 68.22,195.53 68.32,195.53 69.41,196.62 69.41,197.07 66.3,200.18 66.3,200.92 65.61,201.6 63.6,203.62 63.6,207.22 v3(64.14,207.76) 64.33,207.56 R71.1 ; v3(8.13,242.93) 12.19,242.93 14.07,241.06 18.41,241.06 20.45,239.02 20.45,238.59 21.49,237.54 26.99,237.54 30.75,241.3 34.04,241.3 44.42,230.92 44.42,223.12 46.61,220.94 v1(46.81,220.94) 48.3,219.45 49.12,219.45 49.77,218.8 v3(50.58,218.8)
  L3 w0.267: v3(50.58,218.8) 50.67,218.8 51.03,219.16 61.43,219.16 62.53,218.06 62.53,211.44 64.14,209.84 v3(64.14,207.76)
  BOTTOM w0.267: R651.1 R652.1 9.49,243.19 8.38,243.19 v3(8.13,242.93)
VCCIO2PCH: length 4.8
  TOP w0.508: v3(80.24,155.5) 81.06,154.68 CPU1.AB8
  BOTTOM w0.508: v3(80.24,155.5) 80.62,155.88 80.62,156.55 80.87,156.8 v2(80.87,156.99) 80.87,157.33 80.23,157.98 R823.2
VCCST: length 16.3
  TOP w0.356: v3(69.63,154.98) CPU1.K9
  BOTTOM w0.508: R824.2 C440.1 v2(80.16,159.41) 79.86,159.41 79.34,158.89 R823.1 78.76,158.47 78,157.71 73.6,157.71 72.33,156.44 C452.1 72.06,154.98 v3(69.63,154.98)
VCCST_PWRGD: length 35.9
  TOP w0.102: R163.1 R162.2 91.11,132.48 v3(91.96,133.32) ; v3(79.69,153.15) CPU1.Y7
  BOTTOM w0.102: v3(91.96,133.32) v2(91.96,134.45) 91.96,135.18 84.09,143.05 84.09,150.42 82.78,151.73 82.09,151.73 81.1,152.72 80.16,152.72 79.73,153.15 v3(79.69,153.15)
VDDC_CT: length 9.9
  TOP w0.254: v4(84.01,90.82) 84.53,91.34 U13.AB21 ; v4(84.01,90.82) 83.55,91.28 U13.AA21 ; v4(84.01,90.82) 84.49,90.34 U13.AB20 ; v4(84.01,90.82) 83.55,90.36 U13.AA20
  BOTTOM w0.254: v4(84.01,90.82) 84.09,90.9 C779.1 C781.1 86.35,90.9 87.02,91.58 87.25,91.58 v2(87.55,91.88) 88.34,91.88 C780.1 89.53,93.07 L48.2
VIN12V_SYS: length 21.4
  TOP w0.203: v3(94.23,39.63) 94.38,39.48 PU6.11
  L4 w0.508: v5(74.93,36.43) 76.68,38.19 86.69,38.19 v3(87.81,39.3)
  BOTTOM w0.508: v3(94.23,39.63) 92.88,39.63 92.58,39.34 PR117.1 90.26,39.34 PC70.1 90.17,39.3 PC69.1 v3(87.81,39.3)
  vias: v2(75.11,37.88) v2(77.01,41.28) v5(74.68,41.77) v5(74.68,40.75) v5(74.68,39.73) v5(75.82,41.77) v5(75.82,40.75) v5(75.82,39.73)
VIN_DET: length 6.3
  TOP w0.203: v3(55.04,49.95) 55.04,50.43 54.47,51 U24.46
  BOTTOM w0.508: v3(55.04,49.95) 54.99,49.89 R1010.2 55.45,49.07 55.6,49.22 R1008.1 C675.2 v2(57.1,50.28)
VSS_MECH: length 81.9
  TOP w0.254: v3(84.91,116.47) 74.88,106.44 71.88,106.44 68.78,103.34 68.78,99.96 69.35,99.39 U13.A32 ; U13.AM32 90.96,98.74 93.47,101.25 93.47,103.66 94.65,104.84 95.43,104.84 v3(95.76,104.5) ; v4(93.73,78.57) 92.29,77.14 U13.AM1
  L4 w0.254: v4(93.73,78.57) 94.36,79.21 94.36,100.31 95.76,101.71 v3(95.76,104.5)
  BOTTOM w0.254: v3(95.76,104.5) 95.76,105.62 v2(86.88,114.5) v3(84.91,116.47)
VSS_SENSE: length 117.6
  TOP w0.267: v3(50.73,218.05) 49.52,218.05 v1(48.77,218.8) 48.01,218.8 43.9,222.91 43.9,230.7 33.82,240.78 30.96,240.78 27.2,237.02 21.28,237.02 19.93,238.37 19.93,238.68 18.07,240.53 13.86,240.53 12,242.4 8.2,242.4 7.98,242.17 7.98,241.41 8.2,241.18 9.7,241.18 v3(10.06,241.54) ; v3(64.14,206.82) 64.84,206.82 R71.2 64.12,205.8 64.12,203.84 65.98,201.97 66.82,201.13 66.82,200.4 69.93,197.29 69.93,196.41 68.54,195.01 68.43,195.01 67.63,194.21 67.63,193.41 68.75,192.29 68.75,189.87 67.11,188.23 67.11,186.22 CPU1.F40
  L3 w0.267: v3(64.14,206.82) 63.45,207.5 63.45,209.69 62,211.13 62,217.86 61.23,218.63 51.31,218.63 v3(50.73,218.05)
  BOTTOM w0.267: v3(10.06,241.54) R656.2 11.11,242.1 11.14,242.12 C375.2 R653.1
0D95V_VGA: length 7.8
  TOP w0.508: TC16.1 115.64,108.99 ; TC16.1 113.53,108.99 ; TC16.1 114.59,110.04 ; TC16.1 114.59,107.94 ; PC21.2 118.03,109.76
  vias: v1(108.58,107.04)
0D95V_VGA_DRV: length 25.3
  TOP w0.508: PR64.1 126.74,103.99 v3(126.58,103.99) ; PR64.1 126.94,103.29 U14.5 ; PR64.1 PC31.1
  TOP w0.635: PR54.2 123.72,117.99 v1(124.21,117.51) v3(126.03,115.68)
  L4 w0.635: v3(126.58,103.99) 126.55,104.02 125.76,104.02 125.72,103.98 124.83,103.98 124.63,104.14 124.63,104.14 123.61,105.15 123.61,113.26 v3(126.03,115.68)
0D95V_VGA_DRV_1: length 6.9
  TOP w0.635: PC21.1 119.83,114.2 Q40.G 120.83,114.37 PR54.1 121.21,116.44 v1(122.68,116.44)
0D95V_VGA_EN: length 5
  TOP w0.102: U14.1 122.22,105.66 PC25.1 123.28,105.72 PR61.2 122.49,106.66 v1(122.35,106.66) 122.53,106.84 R1229.2
0D95V_VGA_FB: length 15
  TOP w0.254: PC27.2 120.68,103.26 PR69.2 121.28,102.27 121.35,102.33 U14.3 122.97,102.33 124.2,101.1 126.2,101.1 127.22,100.09 127.82,100.09 128.78,101.05 129.59,101.05 v1(129.69,101.15) 130,101.46 PR68.1 PC30.2 128.09,102.59 PC31.2
0D95V_VGA_FB_1: length 2
  TOP w0.254: v1(127.89,104.5) 128.08,104.31 PR64.2 128.14,103.48 PC30.1
0D95V_VGA_FB_2: length 3.4
  TOP w0.254: PR63.1 118.66,103.32 PR62.1 119.79,103.26 PR69.1 119.79,101.61 v1(119.38,101.2)
0D95V_VGA_FB_3: length 2.1
  TOP w0.254: v1(120.27,105.14) 120.74,104.67 PC27.1 PR62.2
0D95V_VGA_S0: length 60.7
  TOP w0.508: v3(71.63,67.29) 70.48,68.44 L51.1
  BOTTOM w0.508: 87.5,75.17 87.5,76.45 87.13,76.82 87.12,76.82 85.47,78.47 L53.1 ; 87.5,75.17 90.68,75.17 92.2,73.64 95.89,73.64 98.53,76.29 v2(98.53,77.99) 98.53,81.49 99.39,82.36 v2(99.39,85.33) v2(99.39,89.98) 99.39,95.16 98.93,95.61 ; 87.5,75.17 87.2,74.86 87.2,74.83 86.87,74.5 86.87,73.13 85.39,71.65 85.39,70.07 84.9,69.58 82.61,67.29 v2(76.78,67.29) v3(71.63,67.29)
  vias: v2(85.12,92.41) v2(89.23,94.37) v4(76.5,95.01) v4(77.62,93.58) v4(77.66,92.9) v4(78.22,92.01) v4(80.13,91.75) v4(80.94,91.86) v5(104.88,98) v5(105.03,95.87) v5(105.05,97.01)
0D95V_VGA_SS: length 3.6
  TOP w0.508: v1(127.53,100.75) 127.19,101.09 PC32.1 126.98,101.69 126.33,102.33 U14.4
1D05V_DRVH: length 8.8
  TOP w0.305: v5(163.71,103.13) 163.02,102.44 U15.9
  TOP w0.635: R208.2 169.6,101.71 169.56,101.71 v5(168.13,103.13)
  BOTTOM w0.635: v5(163.71,103.13) 163.79,103.21 v2(165.35,103.21) 168.06,103.21 v5(168.13,103.13)
1D05V_DRVH_R: length 3.5
  TOP w0.635: Q41.4 171.45,101.03 R208.1 v1(172.97,100.95)
1D05V_DRVL: length 27.4
  TOP w0.305: v5(163.7,100.67) 163.43,100.94 U15.6
  TOP w0.635: Q39.4 175.21,114.41 v5(175.08,114.28)
  BOTTOM w0.635: v5(163.7,100.67) 163.7,100.67 163.7,101.08 162.43,102.35 162.43,105.26 164.85,107.67 v2(164.85,109.71) 164.85,112.63 166.62,114.41 174.96,114.41 v5(175.08,114.28)
1D05V_EN: length 3.1
  TOP w0.254: U15.3 158.27,101.94 157.99,102.22 157.51,102.22 v1(157.45,102.17) 157.29,102 R207.2
1D05V_PWR: length 17.4
  TOP w0.254: v3(158.65,99.1) 158.23,98.68 157.35,98.68 PC33.1
  TOP w0.508: TC14.1 157.1,110.89 ; TC14.1 156.04,109.84 ; TC14.1 158.15,109.84 ; TC14.1 157.1,108.78 ; PC33.1 R212.1
  BOTTOM w0.254: v3(159.13,107.68) 159,107.68 157.84,106.51 v2(157.84,104.76) 157.84,102.12 159.16,100.8 159.16,99.61 v3(158.65,99.1)
1D05V_RF: length 5.2
  TOP w0.254: v1(156.69,98.31) 156.83,98.17 158.51,98.17 159.58,99.23 R214.1 159.58,100.25 159.36,100.47 U15.5
1D05V_SB: length 2.3
  TOP w0.635: C128.1 v1(174.24,108.7) R187.2
1D05V_SW: length 6.3
  TOP w0.305: U15.8 163.96,101.94 164.8,102.78 C141.1
  TOP w0.635: 167.67,104.66 165.79,102.78 C141.1
  vias: v1(169.16,104) v5(168.15,113.27) v5(168.28,107.81) v5(168.28,106.66) v5(169.16,113.27) v5(169.29,107.81) v5(169.29,106.66)
1D05V_TRIP: length 3.5
  TOP w0.254: v3(158.37,102.6) 158.53,102.44 U15.2
  BOTTOM w0.254: R861.2 159.77,102.98 159.45,103.3 158.96,103.3 v2(158.96,103.3) 158.95,103.3 158.68,103.3 158.37,102.98 v3(158.37,102.6)
1D05V_V5IIN: length 6
  TOP w0.305: C157.1 165.21,101.44 U15.7
  TOP w0.508: C157.1 166.78,101.51 R210.2 v1(167,102.6)
1D05V_VBST: length 3.9
  TOP w0.305: 162.34,103.77 162.46,103.65 U15.10
  TOP w0.635: 162.34,103.77 161.85,104.26 R200.1 160.66,105.01 v1(160.4,104.76)
1D05V_VBST_R: length 2.7
  TOP w0.635: C141.2 165.33,105.17 v1(165.1,105.39) 164.16,105.39 R200.2
1D05V_VFB: length 5.8
  TOP w0.254: v1(154.74,99.02) 155.02,99.3 155.02,99.5 155.66,100.15 R212.2 PC33.2 R213.1 157.73,100.31 158.86,101.44 U15.4
1D5V_VGA_S0: length 163.8
  TOP w0.203: MEM1.N9 55.9,96.09 55.67,96.09 55.35,96.41 55.01,96.41 54.77,96.66 54.77,98.03 MEM1.K8 55.23,98.48 55.23,98.72 55.56,99.06 55.56,99.62 v4(55.56,99.62) ; MEM2.K2 55.56,80.37 55.56,79.55 55.43,79.42 MEM2.H2 ; v4(55.57,84.33) 55.57,83.78 55.96,83.39 MEM2.N1 ; MEM1.H9 56.01,100.02 56.68,99.35 57.84,99.35 58.04,99.55 58.93,99.55 ; v4(49.03,100.21) 49.06,100.21 49.25,100.41 49.39,100.41 49.4,100.41 49.73,100.41 49.74,100.41 49.97,100.41 50.35,100.02 MEM1.H2 ; MEM1.D2 50.1,103.22 49.96,103.07 49.96,103.06 49.73,102.83 49.4,102.83 49.39,102.84 v4(49.14,102.84)
  TOP w0.305: 55.55,98.03 55.16,98.41 MEM1.K8 ; MEM2.D2 55.15,75.96 54.78,76.34 v4(54.78,76.37) ; MEM2.K2 55.16,80.76 v4(54.76,81.16) ; v3(57.31,76.49) 57.29,76.47 57.29,76.11 56.51,75.34 v4(56.51,75.34) 56.33,75.16 MEM2.C1 ; MEM2.H9 49.38,79.16 49.2,78.98 ; v4(49.65,72.71) 49.75,72.71 50.36,73.33 MEM2.A8 ; v4(48.75,75.25) 48.84,75.16 MEM2.C9 ; v4(48.42,77.59) 48.75,77.27 49.05,77.27 MEM2.E9 MEM2.D9 49.56,75.96 v4(49.97,75.55) ; MEM2.H2 54.76,78.76 v4(54.76,78.75) ; v4(55.57,84.33) 55.96,84.72 MEM2.R1 ; MEM1.E9 55.96,102.23 56.48,101.72 56.48,101.66 56.74,101.39 v4(56.74,101.39) ; MEM1.B2 MEM1.C1 49.43,104.02 49.11,104.34 v4(49.1,104.34) ; MEM1.H9 55.96,100.02 v4(55.56,99.62) ; v4(48.9,83.64) 49.08,83.64 49.56,83.16 MEM2.N9 ; v4(51.66,78.7) 51.48,78.7 51.16,78.38 MEM2.G7 ; v4(48.86,84.76) 48.86,84.76 MEM2.R9 ; U13.L11 75.75,83.75 v4(75.4,84.1) 75.75,84.45 U13.L12 U13.L13 ; v4(54.76,73.95) 54.76,73.96 55.16,74.36 MEM2.B2 MEM2.A1 ; MEM2.K8 50.36,80.76 v4(49.96,80.36)
  TOP w0.356: U13.L21 75.47,91.34 75.33,91.48 v4(75.24,91.48) 75.36,91.61 75.36,91.88 75.75,92.27 U13.L22 ; MEM1.F1 48.96,101.62 v4(48.93,101.59) ; v4(49.04,94.73) 49.04,94.73 49.06,94.71 49.27,94.71 49.56,94.42 MEM1.R1 ; U13.K9 74.95,81.95 v4(74.55,82.35) ; U13.H19 73.35,89.7 v4(73.73,89.32) ; v4(74.56,93.54) 74.95,93.93 U13.K24 ; v4(74.56,93.54) 74.95,93.15 U13.K23 ; v4(74.56,93.54) 74.16,93.94 U13.J24 ; v4(74.56,93.54) 74.16,93.14 U13.J23 ; v4(54.77,105.22) 55.16,105.61 MEM1.A8 ; v4(53.96,101.21) 53.96,101.17 53.97,101.16 53.97,101.06 54.22,100.82 MEM1.G7 ; U13.H16 73.02,87.67 v4(73.02,87.89) ; v4(57.21,103.83) 56.5,103.83 56.31,104.02 MEM1.C9 ; MEM1.E9 55.96,102.43 v4(55.56,102.83) 55.96,103.22 MEM1.D9 ; U13.K10 74.94,82.74 v4(74.55,82.35) ; v4(75.23,90.47) 75.27,90.47 75.4,90.34 U13.L20 ; v4(73.03,85.37) 73.08,85.32 73.08,85.25 73.35,84.98 U13.H13 ; v4(74.55,82.35) 74.16,82.74 U13.J10 ; v4(74.55,82.35) 74.15,81.95 U13.J9 ; v4(48.76,96.18) 48.77,96.17 49.35,96.17 49.5,96.02 MEM1.N1 ; 55.55,98.03 55.59,98.03 v4(55.6,98.02) ; MEM1.N9 56.37,95.61 v4(56.47,95.61) 56.47,94.93 MEM1.R9 55.99,94.42 v4(56.37,94.04) ; v4(50.76,98.02) MEM1.K2 ; v4(48.04,78.86) 49.09,78.86 49.2,78.98 ; v4(56.51,78.69) 56.51,78.1 MEM2.F1
  TOP w0.508: 48.55,88.71 48.55,87.88 v3(48.49,87.82) ; TC20.1 59.72,63.73 ; TC20.1 58.66,62.67 ; TC20.1 59.72,61.62 ; TC20.1 60.77,62.67 ; v4(56.37,94.04) 57.63,94.04 58.05,94.46 58.05,95.5 58.93,96.38 58.93,100.69 58.94,100.71 58.94,101.16 58.47,101.64 57.04,101.64 56.79,101.39 v4(56.74,101.39)
  L3 w0.508: v4(57.21,103.83) 57.16,103.78 56.51,103.78 55.82,103.09 55.82,103.09 v4(55.56,102.83) 55.38,103.01 55.38,104.61 v4(54.77,105.22) 55.1,105.55 56.08,105.55 56.54,106 56.54,106.16 56.55,106.17 v4(56.55,106.25) v3(64.26,106.25)
  L4 w0.305: v4(56.51,78.69) 55.95,79.25 55.26,79.25 v4(54.76,78.75)
  BOTTOM w0.152: v4(54.78,76.37) 54.78,76.88 55.02,77.12 55.33,77.12 55.65,76.8 55.93,76.8 MEM4.E9
  BOTTOM w0.203: v4(49.96,80.36) 49.96,80.12 49.96,79.57 MEM4.H2 ; v4(53.96,101.21) 53.96,101.17 53.96,101.17 53.96,99.86 54.21,99.61 54.69,99.61 54.7,99.6 55.12,100.02 MEM3.H2 ; v4(55.56,99.62) 55.56,98.96 55.23,98.63 55.23,98.59 55.16,98.53 MEM1.K8 ; MEM4.H2 49.96,78.75 49.08,78.75 48.42,78.1 v4(48.42,77.59) ; MEM4.H2 50.75,79.54 51.32,79.54 51.66,79.21 v4(51.66,78.7) ; MEM2.N1 55.7,83.16 55.32,82.78 55.04,82.78 54.76,82.5 v4(54.76,81.16) ; MEM3.G7 50.76,100.41 49.96,100.41 MEM3.H9
  BOTTOM w0.229: v4(55.57,84.33) 55.57,84.13 55.57,84.12 55.57,83.78 55.96,83.39 MEM2.N1
  BOTTOM w0.305: MEM2.R1 55.96,84.72 v4(55.57,84.33) ; MEM1.R1 49.35,94.42 v4(49.04,94.73) ; v4(54.76,81.16) 55.16,80.76 MEM2.K2 ; MEM2.C1 56.33,75.16 v4(56.51,75.34) ; MEM4.A1 49.65,73.48 v4(49.65,72.71) ; v4(48.42,77.59) 48.75,77.27 49.27,77.27 49.56,77.56 MEM4.F1 ; MEM4.G7 54.36,78.39 54.72,78.75 v4(54.76,78.75) ; MEM4.D2 50.23,75.82 50.23,75.79 49.99,75.55 v4(49.97,75.55) 49.97,75.53 49.74,75.3 49.71,75.3 MEM2.C9 MEM4.B2 ; 56.38,76.35 55.99,75.96 MEM4.D9 ; 56.38,76.35 55.98,76.76 MEM4.E9 ; 56.38,76.35 57.17,76.35 v3(57.31,76.49) 57.31,76.55 58.08,77.32 ; MEM4.A8 55.16,73.56 54.77,73.95 v4(54.76,73.95) ; v4(48.9,83.64) 49.38,83.16 MEM2.N9 ; MEM4.H9 56.03,79.16 56.5,78.69 v4(56.51,78.69) ; MEM2.K8 50.36,80.76 v4(49.96,80.36) ; v4(48.76,96.18) 49.4,96.18 MEM1.N1 ; MEM2.R9 48.86,84.76 v4(48.86,84.76)
  BOTTOM w0.356: v4(56.37,94.04) 55.99,94.42 MEM1.R9 ; MEM3.A1 56.14,105.62 56.55,106.03 v4(56.55,106.25) ; v4(56.74,101.39) 56.74,101.39 56.74,101.43 56.56,101.62 MEM3.F1 ; v4(50.76,98.02) MEM1.K2 ; MEM1.N9 56.37,95.61 v4(56.47,95.61) ; v4(55.56,99.62) 55.16,100.02 MEM3.H2 ; MEM3.D2 55.17,103.22 v4(55.56,102.83) ; MEM3.H9 49.23,100.02 49.04,100.21 v4(49.03,100.21) ; v4(49.6,106.5) 49.64,106.54 50.04,106.54 50.36,106.21 MEM3.A8 ; MEM1.K8 55.16,98.41 55.55,98.03 55.59,98.03 v4(55.6,98.02) ; MEM1.C9 55.99,103.99 56.32,103.99 56.41,103.91 57.06,103.91 57.14,103.83 v4(57.21,103.83) ; v4(49.1,104.34) 49.13,104.34 49.18,104.29 49.2,104.29 49.47,104.02 MEM1.C1 ; MEM2.R1 56.54,84.76 57.21,84.08 58.79,84.08 C583.1 ; MEM3.E9 49.56,102.48 49.21,102.83 49.15,102.83 v4(49.14,102.84) 49.14,102.84 49.52,103.22 MEM3.D9 ; v4(54.77,105.22) MEM3.B2
  BOTTOM w0.508: R885.2 48.37,95.8 v4(48.76,96.18) ; 46.04,86.71 46,86.75 46,87.2 45.54,87.65 43.96,87.65 43.2,86.9 43.2,82.28 44.71,80.77 44.71,80.75 R957.2 ; R1199.1 R1200.1 v2(69.88,104.19) 66.32,104.19 v3(64.26,106.25) ; R1204.1 v4(83.06,76.37) ; 57.78,78.09 56.92,78.09 56.51,78.5 v4(56.51,78.69)
  vias: v2(46.13,106.21) v2(46.51,73.09) v2(46.96,89.87) v2(59.18,79.54) v2(60.63,82.03) v2(66.07,82.89) v3(47.32,105.97) v3(47.32,104.98) v3(47.32,104.11) v3(47.34,78.13) v3(47.34,75.77) v3(47.37,76.99) v5(47.47,93.04) v5(47.47,91.69) v5(61.19,65.31) v5(62.1,65.31) v5(63.12,65.31) v5(64.14,65.31) v5(65.15,65.31)
1D8V_VGA:
  vias: v1(97.15,64.49)
1D8V_VGA_EN: length 4.4
  TOP w0.254: PU5.8 109.6,66.53 v1(110.49,67.42) PC35.1 111.41,67.39 PR78.2
1D8V_VGA_FB: length 7.1
  TOP w0.254: v1(101.7,70.29) 101.7,69.99 102.26,69.43 102.26,68.97 101.54,68.25 PR74.2 101.45,68.1 PR77.1 PC37.1 102.21,65.26 PU5.2
1D8V_VGA_POK: length 3
  TOP w0.254: R427.2 111.33,65.26 v1(110.49,65.26) PU5.7
1D8V_VGA_S0: length 98.6
  TOP w0.508: v4(95.95,91.68) R303.2 96.96,90.79 R935.1 ; L49.1 71.75,68.49 v3(71.73,68.46)
  TOP w0.635: v5(94.84,104.17) 94.61,103.95 C797.1
  TOP w1.016: v5(94.61,74.53) 95,74.15 95.3,74.15
  TOP w1.27: 95.3,74.15 99.06,70.39 PR76.2
  L3 w0.508: v3(84.71,72.82) 91.93,72.82 91.94,72.83 92.91,72.83 v5(94.61,74.53)
  L3 w0.762: v4(95.95,91.68) 94.61,93.01 94.61,103.95 v5(94.84,104.17)
  BOTTOM w0.508: v3(84.71,72.82) 84.75,72.78 84.75,70.33 82.78,68.36 82.42,68.36 v2(80.24,68.36) 76.38,68.36 74.78,69.96 74.17,69.96 ; 74.17,69.96 72.67,68.46 v3(71.73,68.46) ; 74.17,69.96 v2(74.17,71.59) 74.17,72.9 75.29,74.02 75.48,74.02 76.25,74.8 76.44,74.8 77.03,75.38 L50.1 ; L48.1 91.44,93.07 92.93,91.59 R943.2 ; L47.1 95.69,87.11 95.95,86.85 ; R943.2 R388.2 ; R943.2 93.52,91.14 93.75,90.92 94.77,90.92 95.53,91.68 v4(95.95,91.68) ; L52.1 v2(92.94,81.39) 95.82,81.39 95.95,81.26 ; 95.95,84.57 95.94,84.58 R1211.2
  BOTTOM w1.016: v5(94.61,74.53) 95.95,75.87 v2(95.95,77.86) v4(95.95,91.68)
1P5_PCH_EN: length 3.6
  TOP w0.254: R468.1 138.4,53.78 v1(137.64,53.78) 136.84,52.98 M1.8
1P05_PCH_EN: length 49.7
  TOP w0.102: R207.1 156.08,101.2 154.18,99.3 150.43,99.3 PR70.2 149.78,99.92 PC34.1 v1(150.92,97.77) 151.09,97.6 153.57,97.6 153.9,97.27 161.98,97.27 163.78,95.46 163.78,89.98 165.51,88.25 165.51,80.91 167.68,78.74 171.55,78.74 172.21,79.4 172.21,81.01 172.48,81.28 Q45.3
1P05_PCH_EN_Q48: length 37.3
  TOP w0.102: v3(153.59,98.08) 154.05,97.62 162.12,97.62 164.24,95.51 164.24,90.03 165.86,88.4 165.86,83.1 167.62,81.34 168.38,81.34 168.56,81.16 Q44.2 ; R204.2 150.7,101.85 R205.2 151.76,100.96 R206.1 C154.1 153.91,100.96 v3(154.05,100.82)
  BOTTOM w0.102: v3(153.59,98.08) v2(154.18,98.66) 154.61,99.09 154.61,100.26 v3(154.05,100.82)
1P05_PCH_EN_Q48_R: length 7.8
  TOP w0.102: PR71.2 v1(166.83,83.93) 166.75,83.85 166.75,82.71 166.97,82.5 Q44.6 167.91,81.96 168.15,81.72 169.42,81.72 170.51,80.63 Q45.5
1P5_PCH_EN_R: length 7.2
  TOP w0.102: v3(133.43,53.63) 135.41,53.63 R465.2
  BOTTOM w0.102: Q100.D 135.7,51.23 v2(133.96,52.97) 133.43,53.5 v3(133.43,53.63)
1P05_PCH_EN_R: length 3
  BOTTOM w0.102: Q99.D 139.95,51.14 R1003.2 141.98,51.14 v2(142.38,51.54)
1P5_PCH_EN_R_1: length 8.8
  TOP w0.102: R468.2 139.63,54.34 R470.2 139.89,56.12 137.9,56.12 v1(137.49,55.71) 136.6,55.71 R465.1 C257.1
1P5_PCH_FB: length 6.1
  TOP w0.254: M1.2 130.43,51.6 129.08,51.6 128.55,52.13 C261.2 R477.1 128.55,54.53 R464.1 127.73,54.73 v1(127.66,54.8)
1P5_PCH_PWR:
  vias: v2(125.53,50.91) v5(125.73,52.82) v5(126.62,53.32) v5(126.68,52.18)
1P5_PCH_VCC3:
  vias: v1(135.08,47.23)
3D3V_PWR: length 5.7
  TOP w0.356: PTC1.1 99.44,47.57 99.44,44.52 99.39,44.47 99.39,44.01 PR81.1
  vias: v2(93.52,47.58) v2(95.63,52.69) v5(92.08,50.71) v5(93.22,50.71) v5(93.98,51.55) v5(94.84,50.83) v5(95.05,46.42) v5(95.4,49.46) v5(95.48,48.35) v5(95.99,47.15) v5(96.09,51.42) v5(96.65,50.43) v5(96.6,48.24) v5(96.9,46.57) v5(97.23,49.29)
3D3V_VGA_S0: length 261.3
  TOP w0.254: U13.AB18 84.54,89.34 v4(84.03,88.84) ; v4(84.03,88.84) 84.53,88.34 U13.AB17 ; v4(84.03,88.84) 83.55,88.35 U13.AA17 ; v4(84.03,88.84) 83.55,89.32 U13.AA18
  TOP w0.356: RN9.4 104.47,80.6 v3(104.24,80.37) ; RN9.3 103.81,80.7 104.14,80.37 v3(104.24,80.37) ; Q123.5 Q123.2 108.08,83.68 106.38,81.98 106.18,81.98 105.84,81.63 105.84,81.44 104.78,80.37 v3(104.24,80.37)
  TOP w0.508: R1167.1 90.04,60.94 92.75,63.65 ; 91.82,67.8 92.75,66.88 U49.7 92.75,63.65 ; 91.82,67.8 91.76,67.87 C753.1 91.76,71.75 v3(92.2,72.2) ; 91.82,67.8 91.48,67.46 U49.8 ; PR19.1 50.5,142.68 50.98,142.2 v3(50.98,141.92) ; 92.75,63.65 94.02,62.38 U49.3 ; v4(76.5,69.86) 76.5,70.49 76.45,70.55 R398.2 76.07,70.66 R399.2 ; PR15.1 v3(51,144.97) ; v4(97.54,94.09) 97.47,94.15 R1159.2 96.57,93.14 R1187.1 ; R1186.1 102.62,78.28 R1184.1 102.55,76.5 101.73,75.68 v5(99.82,75.68) ; PR6.1 v3(46.52,146.92) ; v3(125.27,105.06) 124.98,105.06 PR61.1 ; v3(93.47,85.58) 95,87.11 v3(102.74,87.11) ; PR4.1 v3(46.51,148.21)
  L3 w0.508: v3(105.89,99.81) 107.33,101.24 107.33,113.14 v3(107.67,113.48) ; v3(93.47,85.58) 95.12,85.58 97.16,87.61 97.16,93.71 v4(97.54,94.09) ; v3(130.53,109.97) 130.53,110.35 129.77,111.11 115.93,111.11 v3(115.32,110.5)
  L4 w0.508: v3(115.32,110.5) 115.08,110.5 115.03,110.45 114.25,110.45 113.41,109.61 111.23,109.61 107.67,113.17 v3(107.67,113.48) ; v3(130.53,109.97) 130.49,109.97 130.37,109.84 126.77,109.84 124.69,107.76 124.69,105.6 125.08,105.22 125.12,105.22 v3(125.27,105.06)
  L4 w1.27: 53.77,133.18 62.74,133.18 90.12,105.8 102.79,105.8 105.89,102.7 v3(105.89,99.81) 106.17,99.53 106.17,94.47 102.74,91.04 v3(102.74,87.11) 102.74,81.87 v3(104.24,80.37) 102.86,78.99 101.79,78.99 99.82,77.02 v5(99.82,75.68)
  BOTTOM w0.508: PR104.1 50.47,135.32 v3(50.98,135.82) 50.47,136.33 PR103.1 ; v4(84.03,88.84) 84.51,88.36 C783.1 C782.1 86.37,88.36 C784.1 87.53,87.21 89.18,87.21 90.17,86.22 92.84,86.22 v3(93.47,85.58) ; PR97.1 50.47,139.38 v3(50.98,139.89) 50.47,140.4 PR96.1 ; PR102.1 50.55,137.35 50.98,137.77 v3(50.98,137.86) 50.47,138.36 PR100.1 ; v3(83.86,71.1) 82.93,71.1 81.13,69.3 79.85,69.3 79.77,69.22 77.14,69.22 v4(76.5,69.86) 76.5,70.61 76.48,70.63 ; 76.48,70.63 R397.2 77.95,70.63 R302.2 ; 76.48,70.63 R398.2 ; PR94.1 50.47,141.41 v3(50.98,141.92)
  BOTTOM w1.27: v5(99.82,75.68) 99.82,74.66 97.36,72.2 v3(92.2,72.2) v2(89.48,72.2) 87.45,72.2 v5(86.77,71.51)
  vias: v2(49.12,148.5) v2(52.73,133.82) v2(52.76,142.86)
3D3V_VGA_S0_EN: length 4.6
  TOP w0.254: Q54.2 85.98,63.23 C249.1 86.42,62.28 R437.2 86.42,60.69 v1(86.74,60.37)
3D3VSB: length 2.9
  BOTTOM w0.635: v2(80.31,50.56) 80.31,50.78 80.31,50.78 PR115.2 80.19,52.05 PC66.1
100M_DMI_PCH_DN: length 6.4
  TOP w0.102: v4(129.06,75.98) 128.7,75.62 U29.G22
  BOTTOM w0.102: 127.53,74.94 125.09,74.94 R977.1 ; 127.53,74.94 v2(127.53,74.56) ; 127.53,74.94 128.83,74.94 129.06,75.17 v4(129.06,75.98)
100M_DMI_PCH_DP: length 6.3
  TOP w0.102: v4(128.31,75.99) 127.99,75.67 U29.F22
  BOTTOM w0.102: 126.51,75.19 125.09,75.19 R973.1 ; 126.51,75.19 v2(126.51,75.51) ; 126.51,75.19 128.7,75.19 128.8,75.29 128.8,75.63 128.7,75.73 128.4,75.73 128.31,75.82 v4(128.31,75.99)
1589_BOOT: length 3.3
  TOP w0.305: R371.1 36.7,76.54 v1(36.7,75.55) 36.7,75.06 35.88,74.24 U20.1
1589_BT1: length 8
  TOP w0.635: C212.1 R371.2 38.05,76.11 38.07,76.08 38.07,75.52 v3(37.97,75.42)
  BOTTOM w0.635: D18.2 36.17,77.73 v2(36.97,76.93) 37.97,75.93 v3(37.97,75.42)
1589_COMP: length 7.3
  TOP w0.254: v1(31.01,66.91) 31.01,67.29 v3(31.5,67.78) 31.98,68.26 R417.1 32.72,68.69 C236.1 33.46,69.14 34.38,70.05 U20.7
  BOTTOM w0.254: v3(31.5,67.78) 31.49,67.78 31.49,67.8 Q98.D
1589_CP1: length 2.9
  TOP w0.254: R417.2 32.29,66.51 v1(32.47,66.33) 32.69,66.33 33.53,67.17 C238.1
1589_FB: length 8.7
  TOP w0.254: v1(35.05,66.15) 35.88,66.15 C242.2 36.13,67.48 R418.1 C238.2 35.05,67.99 C236.2 R412.1 35.75,69.14 34.88,70.01 U20.8
1589_FB1: length 2.7
  TOP w0.254: R420.2 38.86,66.15 38.61,65.9 v1(37.97,65.9) 37.53,65.9 C242.1
1589_LG: length 7.4
  TOP w0.305: U20.4 34.38,74.57 33.96,74.99 33.5,74.99
  TOP w0.508: R358.2 31.71,76.73 R362.1 29.32,76.73 v1(29.24,76.64)
  TOP w0.635: 33.5,74.99 32.79,74.99 31.8,75.98 R358.2
1589_LG12: length 3.1
  TOP w0.635: R358.1 31.8,79.47 31.51,79.76 v1(31.51,80.12) 31.51,80.62 31.45,80.68 U18.2
1589_LX: length 18.6
  TOP w0.305: v5(35.64,75.83) 35.64,75.01 35.38,74.76 U20.2
  TOP w0.508: U18.3 32.72,80.26 R348.1
  TOP w0.635: v5(35.64,75.83) 35.46,76.01 v1(35.46,77.35) 36.04,77.94 C212.2
  L3 w0.635: v5(35.64,75.83) 35.64,82.18 34.19,83.63 v5(32.36,83.63)
  BOTTOM w0.635: R952.1 33.25,82.74 v5(32.36,83.63)
1589_LX1_SNB: length 2.8
  BOTTOM w0.635: v2(29.87,83.88) C601.1 30.28,82.31 R952.2
1589_PGOOD: length 207.3
  TOP w0.102: U20.10 36.41,70.72 37.56,71.87 C226.1 R384.2 v3(38.16,73.69) 38.16,73.9 37.73,74.33 37.6,74.33 37.59,74.34 v1(37.59,74.34) ; R590.1 159.51,22.72 v3(160.27,23.48)
  L4 w0.127: v3(38.16,73.69) 37.59,73.12 37.59,65.47 27.7,55.58 27.7,41.47 28.63,40.54 28.95,40.54 29.3,40.18 29.3,37.64 30.14,36.8 30.14,32.33 32.63,29.84 32.63,26.18 35.15,23.65 35.15,23.39 35.91,22.64 38.08,22.64 42.8,17.93 42.8,17.54 44.02,16.32 44.79,16.32 47.45,18.98 48.61,18.98 49.09,19.46 52.52,19.46 52.62,19.55 53.55,19.55 53.64,19.47 55.78,19.47 57.61,21.29 59.54,21.29 59.89,20.94 59.89,19.95 62.23,17.61 65.3,17.61 66.55,16.37 73.86,16.37 74.6,15.63 79.98,15.63 80.71,14.91 87.81,14.91 90.85,17.94 92.89,17.94 93.72,17.11 101.53,17.11 102.36,17.94 106.12,17.94 107.04,17.02 114.85,17.02 115.77,17.94 118.92,17.94 120.37,16.49 121.95,16.49 122.57,15.87 126.91,15.87 128.98,17.94 131.82,17.94 131.86,17.9 134.58,17.9 v3(142.72,26.04)
  BOTTOM w0.102: v3(160.27,23.48) 159.69,24.06 159.69,24.12 158.94,24.88 152.91,24.88 152.48,25.31 145.75,25.31 145.01,26.04 v3(142.72,26.04)
1589_UG: length 3.4
  TOP w0.305: 34.54,75.45 34.88,75.11 U20.3
  TOP w0.635: R359.2 33.76,76.23 v1(34.44,75.55) 34.54,75.45
1589_UG1: length 4.9
  TOP w0.635: U18.4 33.99,80.31 R348.2 33.77,78.76 R359.1 34.95,78.75 v1(35.43,79.23)
1589_VCC: length 5.4
  TOP w0.305: U20.6 32.51,70.72 C228.1
  TOP w0.508: v3(31.29,70.72) 32,70.72 C228.1
  BOTTOM w0.508: R979.2 29.97,71.51 v2(30.33,71.15) 30.76,70.72 v3(31.29,70.72)
1589_VOS: length 6.1
  TOP w0.254: R410.2 37.72,69.52 R400.1 C229.1 37.91,70.98 v1(37.28,70.34) 36.64,70.34 36.32,70.02 35.62,70.02 35.38,70.26 U20.9
2136_HPD_C: length 7.7
  BOTTOM w0.102: v2(138.3,206.87) 137.48,206.04 R730.2 137.48,204.71 R748.1 136.68,204.64 136.47,204.85 R738.1 135.46,204.44 135.71,204.19 135.71,203.64 135.06,202.99 R739.2
62882_COMP_R: length 2.1
  TOP w0.254: v1(36.7,147.3) PC6.2 37.66,146.73 37.72,146.67 PR8.1
62882_FB_VSEN: length 2.3
  TOP w0.254: v1(31.11,142.96) 31.36,142.72 PR20.2 32.6,142.72 32.66,142.78 PC11.1
62882_NTC_R: length 56.2
  TOP w0.254: v3(24.16,106.89) 24.16,106.9 24.16,106.95 23.57,107.54 23.57,108.48 PR60.1 ; PR5.2 v3(40.77,147.3) 39.9,147.3 v1(39.85,147.25)
  L4 w0.254: v3(24.16,106.89) 23.57,107.48 23.57,126.74 30.37,133.54 30.37,134.92 32.77,137.31 32.77,141.08 32.08,141.77 32.08,145.5 32.21,145.63 32.72,146.24 32.77,146.29 39.75,146.29 v3(40.77,147.3)
62883AGND: length 16.6
  TOP w0.203: v3(41,139.51) 42.8,141.31 U9.40
  TOP w0.508: v3(41.5,146.19) 41.52,146.17 PC9.2 ; PR9.2 PC9.2 ; PC9.2 42.46,146.24 42.46,147.25 42.48,147.28 PR5.1 PR2.1 42.48,148.83 42.07,149.24 41.52,149.24 41.48,149.29 40.74,149.29 40.41,149.62 39.48,149.62 39.22,149.87 38.15,149.87 37.87,149.59 37.87,149.42 PR1.1 PC5.1 ; PC20.1 v3(35.74,131.35)
  vias: v2(36.25,132.95) v2(41.71,143.37) v3(41.02,140.57) v3(41.02,138.41) v3(42.06,139.51)
81102_COMP: length 7.9
  BOTTOM w0.254: U35.28 14.15,238.93 v2(13.21,237.98) 12.38,237.16 C380.2 11.44,236.66 10.59,236.66 10.46,236.8 R673.2 C382.1
81102_COMP_1: length 5.1
  BOTTOM w0.254: v2(7.26,240.29) 7.82,239.73 9.16,239.73 C378.2 10.54,239.57 10.54,239.7 R661.1
81102_COMP_2: length 4.7
  BOTTOM w0.254: v2(8.64,234.81) 8.95,235.12 C382.2 R673.1 8.95,237.08 9.37,237.5 10.63,237.5 R670.1
81102_CSCCOMP: length 56.5
  TOP w0.254: R52.2 41.47,215.44 41.96,215.93 41.96,231.16 40.22,232.9 27.6,232.9 23.92,229.22 21.65,229.22 21.14,229.73 20.62,229.73 20.11,229.22 16.97,229.22 14.61,231.59 v1(14.61,232.14) 14.25,232.49 14.25,233.98 v3(13.59,234.64)
  BOTTOM w0.203: U35.24 16.25,236.91 15.58,236.24 C383.2
  BOTTOM w0.254: v3(13.59,234.64) R683.1 14.45,234.69 R675.2 14.97,235.71 15.09,235.59 C383.2 15.56,235.57 C386.1
81102_CSCM_1: length 50
  TOP w0.254: R52.1 41.4,231 40.01,232.39 27.81,232.39 24.13,228.71 21.26,228.71 v1(20.88,229.09) 20.75,229.09 20.37,228.71 16.76,228.71 13.59,231.89 v3(13.59,233.6)
  BOTTOM w0.254: v3(13.59,233.6) 13.74,233.75 R683.2 14.92,233.75 15.01,233.66 R686.2
81102_CSREF: length 14.8
  TOP w0.254: v3(17.4,234.5) v1(19.35,234.5) 23.99,234.5 v3(24.38,234.11)
  BOTTOM w0.203: 17.05,236.09 U35.22
  BOTTOM w0.254: R684.2 25.06,234.04 24.99,234.11 v3(24.38,234.11) R682.2 23.5,233.45 23.56,233.38 C389.1 ; R681.2 17.67,234.5 v3(17.4,234.5) 17.42,234.53 17.42,235.72 17.05,236.09
81102_CSSUM: length 16.9
  BOTTOM w0.203: U35.23 16.65,236.68 16.47,236.5 C383.1
  BOTTOM w0.254: C383.1 16.47,234.71 C386.2 R686.1 16.45,233.44 16.14,233.13 15.49,233.13 R687.2 14.81,232.04 v2(15.52,231.33) 16.31,230.54 16.31,230.32 17.66,228.96 R693.2 22.5,228.96 R692.2
81102_DIFF: length 5.1
  BOTTOM w0.203: U35.30 14.9,239.72 14.35,240.27 v2(13.89,240.27) 13.87,240.29 R661.2
  BOTTOM w0.254: R665.2 R661.2
81102_FB: length 8.7
  BOTTOM w0.203: C380.1 12.54,238.65 12.54,238.71 v2(13.08,239.25) 13.24,239.41 14.55,239.41 14.63,239.32 U35.29
  BOTTOM w0.254: R665.1 11.14,238.71 10.95,238.52 R670.2 ; R670.2 C378.1 R668.1 ; R670.2 11.39,238.07 11.42,238.05 C380.1
