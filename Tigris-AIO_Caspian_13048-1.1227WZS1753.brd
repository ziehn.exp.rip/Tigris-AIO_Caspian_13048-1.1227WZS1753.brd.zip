# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MDA42: length 35.8
  TOP w0.102: 67.46,83.7 67.49,83.73 69.07,83.73 69.21,83.87 69.46,83.87 69.51,83.85 69.82,83.54 U13.C11
  TOP w0.127: MEM2.A2 55.43,73.56 55.56,73.43 55.56,72.9 55.82,72.63 56.07,72.63 56.33,72.9 56.33,73.88 56.45,73.99 56.92,73.99 57.04,73.87 57.04,72.91 57.26,72.69 57.57,72.69 57.67,72.79 57.67,74.09 57.79,74.21 58.05,74.21 58.16,74.32 58.16,74.78 58.05,74.89 57.61,74.89 57.42,75.07 57.42,75.22 57.72,75.51 58.52,75.51 58.6,75.59 58.6,76.1 58.52,76.18 58.23,76.18 58.13,76.28 58.13,76.66 58.23,76.77 58.66,76.77 58.83,76.94 58.83,79.44 58.66,79.61 58.16,79.61 57.96,79.81 57.96,81.4 58.07,81.51 58.38,81.51 58.52,81.66 58.52,82.08 58.38,82.22 58.06,82.22 57.96,82.32 57.96,82.68 58.13,82.85 58.67,82.85 58.67,82.85 59.03,82.85 59.16,82.97 59.16,83.31 59.29,83.44 59.54,83.44 59.67,83.31 59.67,82.97 59.8,82.85 60.05,82.85 60.18,82.97 60.18,83.31 60.3,83.44 60.56,83.44 60.68,83.31 60.68,82.97 60.81,82.85 61.07,82.85 61.19,82.97 61.19,83.31 61.32,83.44 61.57,83.44 61.7,83.31 61.7,82.97 61.83,82.85 62.17,82.85 62.41,82.61 62.41,82.33 62.57,82.16 63.12,82.16 v1(63.25,82.29) 63.57,82.61 66.37,82.61 67.46,83.7
MDA43: length 36.9
  TOP w0.102: 67.5,83.95 68.27,83.95 68.28,83.93 68.97,83.93 69.11,84.07 69.49,84.07 69.56,84.05 69.58,84.04 69.59,84.04 69.66,84.01 69.76,83.92 71.37,83.92 U13.F11
  TOP w0.127: 67.5,83.95 67.2,83.95 66.21,82.95 62.7,82.95 62.19,83.47 62.19,84.71 62.06,84.83 61.61,84.83 61.48,84.71 61.48,83.94 61.32,83.78 60.93,83.78 60.77,83.94 60.77,84.94 60.65,85.06 60.26,85.06 60.13,84.94 60.13,83.91 60.01,83.78 59.62,83.78 59.5,83.91 59.5,84.92 59.37,85.05 57.63,85.05 57.26,84.68 57.26,84.17 57.39,84.05 57.77,84.05 57.9,84.17 57.9,84.33 58.03,84.47 58.48,84.47 58.64,84.31 v1(58.64,84) 58.64,83.47 58.4,83.23 58.11,83.23 57.68,82.8 57.68,79.69 58.37,79.01 58.37,77.3 57.85,76.78 57.85,76.03 56.56,74.75 55.75,74.75 55.6,74.6 55.45,74.6 55.29,74.75 55,74.75 54.86,74.9 54.86,75.04 54.98,75.16 MEM2.C2
MDA44: length 35.8
  TOP w0.102: U13.A9 69.23,82.06 68.09,82.06 67.84,81.81 67.65,81.81 67.4,81.56
  TOP w0.127: 67.4,81.56 66.99,81.15 66.99,81.13 66.62,80.76 65.23,80.76 63.82,79.35 63.64,79.35 63.29,79.71 63.11,79.71 62.93,79.53 62.93,79.35 63.28,78.99 63.28,78.81 63.1,78.63 62.92,78.63 62.57,78.99 62.39,78.99 62.21,78.81 62.21,78.63 62.56,78.28 62.56,78.1 v1(62.31,77.84) 62.05,77.58 62.05,77.06 62.18,76.93 62.45,76.93 62.58,76.81 62.58,76.55 62.45,76.42 62.18,76.42 62.05,76.3 62.05,71.86 61.33,71.15 59.99,71.15 59.83,70.99 54.2,70.99 54.07,70.86 54.07,70.56 53.95,70.43 53.49,70.43 53.36,70.56 53.36,70.86 53.23,70.99 52.78,70.99 52.65,70.86 52.65,70.61 52.5,70.46 52.07,70.46 51.94,70.58 51.94,71.25 51.77,71.42 51.77,71.95 51.58,72.13 51.34,72.13 51.24,72.03 51.24,71.83 51.09,71.68 50.93,71.68 50.33,72.28 50.33,72.47 50.49,72.63 51.37,72.63 51.5,72.75 51.5,73.43 51.37,73.56 MEM2.A7
MDA45: length 36.2
  TOP w0.102: U13.C9 69.9,81.69 69.59,81.69 69.57,81.69 69.45,81.61 69.21,81.61 68.97,81.85 68.27,81.85 67.82,81.4 67.73,81.4 67.51,81.19
  TOP w0.127: MEM2.B8 50.7,74.36 50.82,74.23 50.82,74.23 50.82,73.42 50.82,73.42 50.82,73 50.7,72.87 50.39,72.87 50.06,72.54 50.06,72.07 50.94,71.19 51.26,71.19 51.29,71.22 51.47,71.22 51.6,71.09 51.6,70.44 51.99,70.05 52.58,70.05 52.88,70.35 53.09,70.35 53.41,70.03 54.33,70.03 54.53,70.23 54.53,70.54 54.64,70.64 55.13,70.64 55.24,70.54 55.24,70.22 55.35,70.1 55.83,70.1 55.95,70.23 55.95,70.54 56.06,70.64 56.56,70.64 56.66,70.54 56.66,70.22 56.78,70.1 57.25,70.1 57.37,70.23 57.37,70.34 57.37,70.43 57.5,70.56 58.47,70.56 58.67,70.36 60.3,70.36 60.42,70.48 60.42,70.69 60.54,70.8 60.92,70.8 61.03,70.69 61.03,70.48 61.16,70.36 61.4,70.36 62.47,71.42 62.47,72.62 62.6,72.74 62.63,72.74 62.76,72.87 62.76,73.41 62.63,73.53 62.6,73.53 62.47,73.66 62.47,74.21 v1(62.62,74.36) 62.92,74.66 62.92,77.89 65.44,80.41 66.74,80.41 67.51,81.19
MDA46: length 37.3
  TOP w0.102: 67.73,80.91 68.47,81.65 68.88,81.65 69.13,81.41 69.5,81.41 69.61,81.46 69.69,81.49 71.3,81.49 U13.F9
  TOP w0.127: MEM2.D7 50.83,75.62 50.83,75.31 50.82,75.3 50.82,75.01 50.53,74.72 50.21,74.72 50,74.5 50,73.45 49.71,73.16 49.45,73.16 49.19,72.89 49.19,72.25 51.75,69.68 61.35,69.68 63.49,71.82 v1(63.49,76.39) 63.49,77.95 65.61,80.07 66.74,80.07 67.58,80.91 67.73,80.91
MDA47: length 35.8
  TOP w0.102: U13.D8 70.22,80.81 69.67,80.81 69.58,80.85 69.54,80.87 69.24,80.87 69.17,80.86 69.17,80.85 69.13,80.84 68.05,80.84 67.92,80.71
  TOP w0.127: MEM2.C8 50.21,75.16 49.77,74.72 49.35,74.72 48.72,74.1 48.72,71.75 v1(50.58,69.88) 51.13,69.34 61.53,69.34 64.08,71.89 64.08,78.04 65.77,79.73 66.73,79.73 66.99,79.99 67.21,79.99 67.92,80.71
MDA48: length 30.3
  TOP w0.127: v4(52.59,78.31) 52.55,78.27 52.55,77.23 52.91,76.87 53.37,76.87 53.49,76.99 53.49,77.36 53.65,77.51 53.93,77.51 54.22,77.22 54.51,77.22 54.68,77.04 54.68,76.89 54.56,76.76 MEM2.E3 ; U13.E7 70.49,79.88 68.52,79.88 68.21,79.57 68.21,79.57 67.99,79.35 v4(67.93,79.35)
  L3 w0.165: v4(52.59,78.31) 53.1,78.81 53.1,79.12 53.41,79.44 53.78,79.44 54.01,79.67 54.01,80.02 54.43,80.44 57.26,80.44 57.92,81.09 58.18,81.09 58.32,80.95 58.32,80.26 58.46,80.12 58.85,80.12 59.02,80.29 59.02,80.88 59.18,81.05 67.98,81.05 68.3,80.73 69.1,80.73 69.25,80.58 69.25,80.13 69.1,79.98 68.09,79.98 67.93,79.83 v4(67.93,79.35)
MDA49: length 29.6
  TOP w0.127: MEM2.H3 54.02,79.5 54.02,80.08 53.91,80.18 53.75,80.18 53.64,80.08 53.64,79.45 53.49,79.31 53.24,79.31 53.06,79.13 53.06,78.46 v4(53.23,78.3) ; U13.A7 69.18,80.17 68.3,80.17 67.9,79.77 67.69,79.77 v4(67.26,79.35)
  L3 w0.165: v4(67.26,79.35) 67.26,80.41 67.09,80.58 63.73,80.58 63.56,80.41 63.56,79.75 63.4,79.59 63.07,79.59 62.9,79.75 62.9,80.41 62.74,80.58 62.41,80.58 62.24,80.41 62.24,79.75 62.08,79.59 61.75,79.59 61.58,79.75 61.58,80.41 61.42,80.58 61.08,80.58 60.92,80.41 60.92,79.75 60.75,79.59 60.42,79.59 60.26,79.75 60.26,80.41 60.09,80.58 59.71,80.58 59.55,80.41 59.55,79.73 59.42,79.6 57.11,79.6 56.98,79.73 56.98,80.04 56.86,80.17 54.54,80.17 54.28,79.91 54.28,79.45 54.33,79.4 54.33,79.38 54.48,79.22 54.48,79.09 54.26,78.86 54.12,78.86 53.95,79.03 53.81,79.17 53.52,79.17 53.36,79.01 53.36,78.43 v4(53.23,78.3)
MDA50: length 31.2
  TOP w0.102: U13.C7 69.5,80.66 69.44,80.67 69.28,80.67 69.18,80.64 69.02,80.48
  TOP w0.127: v4(57.18,78.7) 57.65,78.22 57.65,77.99 57.53,77.87 56.97,77.87 56.84,77.75 56.84,77.16 56.59,76.91 56.3,76.91 56.05,77.16 55.56,77.16 MEM2.F2 ; 69.02,80.48 68.03,80.48 67.32,79.77 67.09,79.77 66.84,79.52 66.84,78.9 66.41,78.47 66.41,76.03 66.28,75.9 65.94,75.9 65.81,76.03 65.81,77.75 65.68,77.87 65.38,77.87 65.25,77.75 65.25,76.06 65.13,75.93 64.8,75.93 64.67,76.06 64.67,77.89 v4(66.07,79.28)
  L3 w0.165: v4(57.18,78.7) 57.76,78.7 58.77,77.7 63.17,77.7 64.76,79.28 v4(66.07,79.28)
MDA51: length 30.4
  TOP w0.127: U13.F7 71.75,80.34 v4(71.35,79.94) ; v4(55.57,78.74) 55.57,78.57 55.35,78.36 MEM2.G2
  L3 w0.165: v4(71.35,79.94) 70.87,79.94 70.7,79.78 70.7,78.64 70.54,78.47 70.19,78.47 70.03,78.64 70.03,79.49 69.86,79.65 69.51,79.65 69.34,79.49 69.34,78.34 69.18,78.18 68.67,78.18 68.51,78.34 68.51,78.74 68.34,78.91 67.08,78.91 66.74,79.25 66.74,79.87 66.52,80.08 65.86,80.08 65.53,79.75 65.11,79.75 64.77,80.1 64.27,80.1 64.12,79.94 64.12,79.37 63.87,79.12 63.31,79.12 63.14,78.95 63.14,78.39 62.98,78.23 62.65,78.23 62.48,78.39 62.48,78.95 62.32,79.12 61.99,79.12 61.82,78.95 61.82,78.37 61.66,78.2 61.33,78.2 61.16,78.37 61.16,78.95 61,79.12 60.67,79.12 60.5,78.95 60.5,78.41 60.34,78.24 60.01,78.24 59.84,78.41 59.84,78.95 59.68,79.12 59.35,79.12 59.18,78.95 59.18,78.65 59.02,78.48 58.69,78.48 58.52,78.65 58.52,78.95 58.35,79.12 57.37,79.12 57.35,79.15 56.09,79.15 55.97,79.27 55.97,79.81 55.87,79.9 55.34,79.9 55.22,79.78 55.22,78.87 55.34,78.74 v4(55.57,78.74)
MDA52: length 28.8
  TOP w0.127: MEM2.H8 50,79.52 48.96,79.52 v4(48.87,79.44) ; U13.A5 69.23,78.74 68.21,77.72 68.21,77.59 v4(68.17,77.56)
  L3 w0.165: v4(48.87,79.44) 50.11,79.44 50.28,79.6 50.28,79.75 50.44,79.92 50.93,79.92 51.09,79.75 51.09,79.37 51.26,79.21 51.79,79.21 52.14,78.85 52.14,77.65 52.7,77.09 53.34,77.09 54.65,75.78 55.92,75.78 56.1,75.96 56.1,76.19 56.22,76.32 56.74,76.32 56.87,76.19 56.87,75.88 57.63,75.12 59.16,75.12 59.22,75.18 63.96,75.18 64.62,75.85 64.62,77.33 65.19,77.89 66.29,77.89 66.62,77.56 v4(68.17,77.56)
MDA53: length 30.8
  TOP w0.127: MEM2.F7 51.16,77.37 52.07,76.46 v4(52.07,76.45) ; v1(67.01,76.36) 67.13,76.23 v4(68.21,76.23) 68.21,76.56 68.72,77.07 69,77.07 69.76,77.83 69.76,78.07 70.02,78.33 70.54,78.33 U13.E5
  L3 w0.165: v4(68.21,76.23) 65.18,73.2 56.69,73.2 55.07,74.83 53.67,74.83 53.28,74.44 51.12,74.44 50.95,74.61 50.95,74.93 51.12,75.09 52.02,75.09 52.14,75.22 52.14,75.54 52.02,75.67 51.48,75.67 51.32,75.83 51.32,76.55 51.45,76.68 51.94,76.68 52.07,76.55 v4(52.07,76.45)
MDA54: length 29.8
  TOP w0.127: v4(52.82,76.4) 52.16,77.06 52.16,77.59 52.09,77.66 52.09,78.29 52.15,78.34 52.15,78.89 51.87,79.16 MEM2.H7 ; v4(68.87,76.63) 68.87,75.38 69.04,75.22 69.41,75.22 69.58,75.38 69.58,77.24 70.15,77.81 U13.C3
  L3 w0.165: v4(68.87,76.63) 68.76,76.74 68.05,76.74 66.88,75.58 66.65,75.58 66.37,75.85 66.14,75.85 65.91,75.62 65.91,75.38 66.18,75.11 66.18,74.88 65.95,74.64 65.71,74.64 65.35,75.01 65.12,75.01 64.88,74.77 64.88,74.54 65.25,74.18 65.25,73.94 64.98,73.67 56.75,73.67 55.26,75.17 53.84,75.17 52.82,76.18 v4(52.82,76.4)
MDA55: length 29.8
  TOP w0.127: MEM2.F8 50.36,77.56 v4(49.96,77.95) ; v4(70.09,75.9) 70.14,75.9 70.95,76.71 U13.E1
  L3 w0.165: v4(70.09,75.9) 68.6,75.9 65.42,72.72 56.66,72.72 54.82,74.56 53.83,74.56 53.21,73.93 53.21,73.82 52.61,73.23 51.19,73.23 50.4,74.01 50.4,75.74 49.96,76.18 v4(49.96,77.95)
  BOTTOM w0.127: v4(70.09,75.9) 70.09,75.9 v2(70.88,75.9)
MDA56: length 33.2
  TOP w0.127: U13.G7 72.55,80.33 v4(72.16,79.94)
  BOTTOM w0.127: v4(72.16,79.94) 71.72,79.5 69.56,79.5 68.74,80.31 65.46,80.31 65.33,80.19 65.33,79.37 65.2,79.24 64.95,79.24 64.82,79.37 64.82,80.39 64.7,80.51 64.44,80.51 64.31,80.39 64.31,79.37 64.19,79.24 63.93,79.24 63.81,79.37 63.81,80.41 63.68,80.54 63.43,80.54 63.3,80.41 63.3,79.37 63.17,79.24 62.92,79.24 62.79,79.37 62.79,80.13 62.61,80.31 v2(62.03,80.31) 61.79,80.31 61.33,79.85 61.33,79.67 61.98,79.02 61.98,78.84 61.8,78.66 61.62,78.66 60.97,79.31 60.79,79.31 60.61,79.13 60.61,78.95 61.2,78.36 61.2,78.18 61.02,78 60.84,78 60.25,78.59 60.07,78.59 59.89,78.41 59.89,78.23 60.51,77.61 60.51,77.43 60.33,77.25 60.15,77.25 59.53,77.87 59.35,77.87 57.27,75.79 56.33,75.79 56.12,75.57 54.75,75.57 MEM4.D7
MDA57: length 32.4
  TOP w0.127: U13.G6 72.17,79.16 v4(72.17,79.16)
  BOTTOM w0.127: v4(72.17,79.16) 72.14,79.13 72.14,79.09 71.69,78.64 66.1,78.64 65.98,78.51 65.98,77.37 65.85,77.24 65.6,77.24 65.47,77.37 65.47,78.77 65.34,78.9 65.09,78.9 64.96,78.77 64.96,77.37 64.83,77.24 64.58,77.24 64.45,77.37 64.45,78.75 64.33,78.88 64.07,78.88 63.94,78.75 63.94,77.37 63.82,77.24 63.56,77.24 63.44,77.37 63.44,78.38 63.27,78.55 v2(62.78,78.55) 62.26,78.55 62.01,78.3 62.01,78.12 62.58,77.55 62.58,77.37 62.4,77.19 62.22,77.19 61.65,77.76 61.47,77.76 61.29,77.58 61.29,77.4 61.74,76.96 61.74,76.78 61.56,76.6 61.38,76.6 60.93,77.05 60.75,77.05 60.57,76.87 60.57,76.69 60.92,76.34 60.92,76.16 60.74,75.98 60.56,75.98 60.22,76.33 60.04,76.33 59.73,76.02 57.99,76.02 57.4,75.44 57.22,75.44 56.58,74.79 55.53,74.79 MEM4.C8
MDA58: length 31.2
  TOP w0.127: U13.G1 72.35,76.94 72.35,76.55 72.18,76.38 72.18,75.17 73,74.36 v4(73.63,74.36)
  BOTTOM w0.127: v4(73.63,74.36) 71.32,72.04 v2(69.52,72.04) 66.96,72.04 64.38,69.46 53.88,69.46 50.81,72.54 50.81,72.85 50.36,73.29 MEM4.A2
MDA59: length 31.7
  TOP w0.127: U13.G3 72.12,77.51 72.12,76.65 71.71,76.23 v4(71.71,76.21)
  BOTTOM w0.127: MEM4.A7 54.73,73.19 57.23,73.19 57.48,73.45 57.74,73.45 57.84,73.34 57.84,72.72 57.96,72.6 58.44,72.6 58.56,72.72 58.56,73.7 59.54,74.68 v2(60.72,74.68) 61.59,74.68 61.75,74.84 62.2,74.84 62.46,74.58 62.64,74.58 62.92,74.87 62.92,75.05 62.4,75.57 62.4,75.75 62.63,75.98 62.81,75.98 63.45,75.34 63.45,75.33 63.58,75.21 63.83,75.21 63.96,75.33 63.96,75.52 64.09,75.64 65.51,75.64 65.64,75.52 65.64,75.33 65.77,75.21 66.02,75.21 66.15,75.33 66.15,76.34 66.27,76.46 66.53,76.46 66.65,76.34 66.65,75.33 66.78,75.21 67.04,75.21 67.16,75.33 67.16,76.32 67.29,76.45 67.54,76.45 67.67,76.32 67.67,75.33 67.8,75.21 68.05,75.21 68.18,75.33 68.18,75.52 68.31,75.64 68.88,75.64 69,75.53 69,75.36 69.13,75.23 69.39,75.23 69.52,75.36 69.52,76.82 69.75,77.05 70.87,77.05 v4(71.71,76.21)
MDA60: length 33.9
  TOP w0.127: v4(74.58,79.09) 74.56,79.09 74.15,79.5 U13.J6
  BOTTOM w0.127: v4(74.58,79.09) 74.58,78.26 74.41,78.09 73.85,78.09 73.72,77.96 73.72,77.8 73.6,77.67 73.34,77.67 73.22,77.8 73.22,78.7 73.09,78.83 72.83,78.83 72.71,78.7 72.71,77.78 72.58,77.66 72.33,77.66 72.2,77.78 72.2,78.05 72.07,78.18 71.82,78.18 71.69,78.05 71.69,77.76 71.56,77.63 71.31,77.63 71.18,77.76 71.18,77.96 71.06,78.09 68.11,78.09 67.72,77.69 67.72,77.03 67.5,76.82 67.27,76.82 67.15,76.95 67.15,77.53 67.02,77.66 66.77,77.66 66.64,77.53 66.64,76.95 66.51,76.82 65.71,76.82 65.58,76.69 65.58,76.13 65.45,76.01 65.2,76.01 65.07,76.13 65.07,76.69 64.95,76.82 64.69,76.82 64.57,76.69 64.57,76.13 64.44,76.01 64.18,76.01 64.06,76.13 64.06,76.69 63.93,76.82 63.68,76.82 63.55,76.69 63.55,76.25 63.42,76.12 63.17,76.12 63.04,76.25 63.04,76.69 62.91,76.82 62.29,76.82 61.86,76.38 v2(61.86,75.84) 61.86,75.48 61.59,75.21 61.08,75.21 60.96,75.34 60.96,75.44 60.83,75.56 60.16,75.56 60.04,75.44 60.04,75.16 59.91,75.03 59.26,75.03 59.14,75.16 59.14,75.56 59.04,75.66 58.08,75.66 57.43,75.02 57.43,74.37 57.06,73.99 55.53,73.99 MEM4.B8
MDA61: length 32.6
  TOP w0.127: U13.J1 74.27,77.02 v4(74.27,76.43)
  BOTTOM w0.127: MEM4.C2 50.77,74.75 51.28,74.75 51.62,74.42 51.62,73.11 54.19,70.53 59.83,70.53 60.67,71.37 62.03,71.37 62.16,71.24 62.16,70.96 62.29,70.84 62.54,70.84 62.67,70.96 62.67,71.24 62.79,71.37 63.05,71.37 63.18,71.24 63.18,70.62 63.3,70.49 63.56,70.49 63.68,70.62 63.68,71.24 63.81,71.37 64.33,71.37 65.92,72.96 v2(66.04,72.96) 66.34,73.26 71.6,73.26 73.43,75.09 73.88,75.09 74.27,75.48 v4(74.27,76.43)
MDA62: length 32.5
  TOP w0.127: v4(73.85,75.65) 73.85,76.81 73.7,76.95 73.7,77.68 73.53,77.85 73.53,78.04 73.69,78.19 73.94,78.19 74.15,77.98 U13.J3
  BOTTOM w0.127: v4(73.85,75.65) 73.52,75.32 73.34,75.32 71.66,73.64 65.76,73.64 v2(64.09,71.97) 63.83,71.71 60.46,71.71 59.75,71.01 56.58,71.01 56.46,71.14 56.46,71.61 56.33,71.74 56.07,71.74 55.95,71.61 55.95,71.14 55.82,71.01 55.57,71.01 55.44,71.14 55.44,71.6 55.31,71.73 55.06,71.73 54.93,71.6 54.93,71.14 54.8,71.01 54.46,71.01 51.88,73.6 51.88,74.61 51.32,75.16 MEM4.C3
MDA63: length 33.2
  TOP w0.127: U13.J5 74.58,78.31 74.58,76.75 74.74,76.59 74.74,76.38 74.78,76.35 74.78,76.08 75.11,75.75 75.11,75.75 v4(75.19,75.67)
  BOTTOM w0.127: v4(75.19,75.67) 74.33,74.81 73.48,74.81 71.3,72.63 66.45,72.63 66.26,72.44 66.24,72.44 v2(64.59,70.79) 63.8,70 61.46,70 61.33,70.12 61.33,70.79 61.21,70.91 60.95,70.91 60.82,70.79 60.82,70.12 60.7,70 54.14,70 51.16,72.97 MEM4.A3
MDAT: length 4.7
  TOP w0.102: U24.116 54.87,35.67 55.12,35.42 55.65,35.42 v1(56.57,34.5) 56.97,34.1 56.97,33.4 57.01,33.36 RN5.1
ME_CNTL: length 50.8
  TOP w0.102: v4(134.64,82) 134.68,82 U29.W35 ; v3(154.47,66.5) 154.41,66.5 154.38,66.54 154.3,66.54 153.95,66.88 R419.2
  L4 w0.127: v3(154.47,66.5) 154.47,69.67 152.81,71.33 152.81,72.38 151.72,73.47 151.72,73.56 149.71,75.57 149.71,82.08 148.78,83 144.36,83 142.28,85.08 138.07,85.08 137.01,84.03 136.62,84.03 134.64,82.05 v4(134.64,82)
  BOTTOM w0.102: R903.1 131.44,93.14 131.44,92.12 R914.2 132.21,91.36 132.21,91.28 133.66,89.82 133.88,89.82 135,88.71 135,85.81 v2(134.77,85.58) 134.77,85.18 135.05,84.9 135.05,82.41 v4(134.64,82)
ME_CNTL1: length 3.4
  TOP w0.102: Q52.B 155.13,68.9 154,67.77 R419.1 v1(152.62,67.77)
ME_CNTL2: length 5.2
  TOP w0.102: Q52.E 155.13,66.35 155.57,65.9 v1(155.96,65.9) 157.5,65.9 R421.2
MEM_CALRP0: length 4.9
  TOP w0.102: U13.K25 75.28,95.07 v4(75.41,95.07)
  BOTTOM w0.102: R1201.2 76.96,97.49 76.53,97.05 76.53,96.19 v4(75.41,95.07) 75.41,94.96 v2(74.8,94.34)
MEM_COMP: length 2.9
  TOP w0.102: v1(180.97,186.45) 180.17,186.45 R104.1 179.53,185.8 U4.3
MEM_REG_PG: length 17.6
  TOP w0.203: v3(50.98,39.07) 51.15,39.07 51.18,39.1 51.44,39.1 52.87,37.67 U24.111 52.87,35.44 53.34,34.97 53.34,34.53 v1(53.47,34.4)
  TOP w0.508: v1(53.47,34.4) 53.47,34.22 54,33.69 54,33.14 R567.2
  L4 w0.508: v3(43.07,40.76) 43.08,40.75 43.08,40.55 44.17,39.46 50.55,39.46 50.94,39.07 v3(50.98,39.07)
  BOTTOM w0.381: v3(43.07,40.76) 43.2,40.89 Q106.3
MEM_REG_PG_1: length 6.3
  BOTTOM w0.254: v2(42.48,44.43) R1030.2 42.74,43.29 R1029.1 44.59,41.44 44.81,41.44 45.09,41.16 45.09,40.52 45.36,40.24 Q106.5
MEM_REG_PG_2: length 4.1
  BOTTOM w0.254: Q106.2 43.63,40.24 43.34,39.95 42.87,39.95 42.53,40.29 42.53,40.46 42.28,40.72 R1037.2 42.28,42.24 v2(42.42,42.38)
MEM_RST: length 87.8
  TOP w0.102: v3(47.53,87.88) 47.53,88.79 48.34,89.6 48.55,89.6 ; 48.55,89.6 48.27,89.88 48.27,90.77 49.31,91.81 49.31,92.82 50.11,93.62 MEM1.T2 ; 48.55,89.6 49.67,89.6 50.11,89.15 51.34,89.15 51.71,89.52 v3(52.46,89.52) 52.46,90.19 52.59,90.32 56.22,90.32 56.35,90.19 56.35,89.69 56.12,89.47 56.12,88.76 55.65,88.28 55.65,86.75 55.73,86.67 55.73,86.21 55.68,86.16 55.68,86.07 MEM2.T2
  L3 w0.127: v4(79.63,74.91) 79.59,74.88 79.59,74.78 76.99,72.18 70.21,72.18 70.03,72.36 66.32,72.36 65.6,71.64 49.13,71.64 46.79,73.98 46.77,73.99 46.77,75.03 46.77,75.03 46.77,78.79 46.74,78.82 46.74,85.97 47.53,86.76 v3(47.53,87.88)
  BOTTOM w0.102: MEM3.T2 55.39,93.62 55.4,93.61 55.46,93.61 56.43,92.64 56.43,91.16 55.66,90.4 53.1,90.4 52.67,89.97 52.67,89.73 v3(52.46,89.52) 52.17,89.23 52.17,88.63 52.06,88.52 51.72,88.52 51.72,88.52 50.95,88.52 v2(50.54,88.1) 50.14,87.7 50.14,86.58 50.36,86.35 MEM4.T2 ; v4(79.63,74.91) 81.03,74.91 81.28,75.17 R1203.2 R1204.2
MIC2-L: length 7
  TOP w0.203: C176.1 188.01,91.07 184.81,91.07 v1(184.25,90.51) 183.81,90.51 183.5,90.81 U16.47
MIC2-L_1: length 3.8
  TOP w0.203: C176.2 190.93,91.14 190.93,92.69 v1(190.83,92.8) 190,92.8 R1121.1
MIC2-R: length 4.1
  TOP w0.203: C175.1 185.88,91.96 185.06,91.96 v1(184.93,91.83) 184.69,91.83 184.06,91.21 U16.48
MIC2-R_1: length 2.4
  TOP w0.203: v1(187.32,92.95) 187.32,92.03 C175.2 187.78,91.58 188.63,91.58 R1122.1
MIC2-VREFO-L: length 4.2
  TOP w0.203: U16.1 183.39,92.04 v1(183.85,92.49) 184.3,92.95 R265.1
MIC2-VREFO-R: length 3.8
  TOP w0.203: R324.1 179.51,82.93 179.05,83.39 v1(179.05,83.45) 179.02,83.48 179.02,85.37 179.12,85.48 U16.30
MIC-CAP: length 6
  TOP w0.203: 182.42,84.79 182.42,85.86 182.3,85.99 U16.36
  TOP w0.254: C201.1 184.45,83.5 v1(184.4,83.45) 183.77,83.45 182.42,84.79
MLPS_EN#: length 10.9
  TOP w0.102: U13.R5 78.5,78.29 78.5,77.44 arc(78.44,77.34) 78.42,77.23 78.42,76.92 78.51,76.82 78.51,75.4 78.66,75.24 78.66,74.7 79.58,73.79 79.58,73.54 80.14,72.98 v1(80.14,71.61) 80.14,70.56 79.09,69.52 R1193.1
MPCIE_DISABLE_N: length 231.4
  TOP w0.102: R9.1 104.02,232.9 103.9,232.77 v3(103.38,232.77) ; v4(140.11,82.1) 140.05,82.15 139.75,82.15 U29.AG35
  L3 w0.127: v3(103.38,232.77) 105.57,232.77 106.12,232.23 107.51,232.23 108.35,231.38 110.97,228.76 113.11,228.76 114.3,227.57 114.3,224.65 117.99,220.97 118.26,220.97 153.41,220.97 154.37,220.01 154.37,217.82 153.72,217.17 153.72,203.91 156.26,201.37 158.62,201.37 167.93,192.06 170.72,192.06 172.34,190.44 172.34,189.76 173.23,188.87 173.23,179.25 173.56,178.92 173.56,164.57 172.83,163.84 172.83,144.68 172.95,144.57 172.95,123.23 170.05,120.33 168.64,120.33 165.24,120.33 159.66,114.75 156.6,114.75 155.07,113.22 155.07,108.19 155.38,107.88 155.38,99.16 150.8,94.59 150.3,94.59 150.03,94.31 150.03,93.37 v4(147.19,90.53)
  BOTTOM w0.102: v4(140.11,82.1) 140.54,82.53 140.54,83.44 141.02,83.92 141.02,87.42 143.1,89.51 v2(143.64,89.51) 144.01,89.51 144.39,89.13 144.92,89.13 145.18,89.39 145.19,89.39 146.34,90.53 v4(147.19,90.53) 147.75,91.09 R923.1
MPV18: length 0.7
  TOP w0.381: U13.L8 75.86,81.14 75.48,80.76 v4(75.4,80.76)
  vias: v2(76.02,79.51)
MVREFDA: length 9.5
  TOP w0.356: v4(75.46,95.82) 75.44,95.84 75.25,95.84 U13.K26
  BOTTOM w0.508: v4(75.46,95.82) 76,96.35 76,97.27 75.76,97.51 R1197.1 C760.1 75.76,101.8 v2(75.01,102.55) 74.26,103.3 R1199.2
MVREFSA: length 12.8
  TOP w0.356: v4(74.55,95.13) 74.5,95.18 74.15,95.53 U13.J26
  BOTTOM w0.305: v2(71.62,98.55) 71.89,98.28 74.56,98.28 75.06,97.77 75.06,97.27 74.04,96.24 74.04,95.64 v4(74.55,95.13)
  BOTTOM w0.508: v2(71.62,98.55) 71.62,100.1 72.33,100.81 R1198.1 C761.1 72.64,102.54 R1200.2
NGFF_ALERT_N: length 5.9
  TOP w0.102: R16.2 105.97,229.85 v1(106.22,230.11) 106.22,230.25 106.92,230.95 108.53,230.95 109.14,231.55 NGFF1.62
NGFF_BT_DISABLE: length 243.9
  TOP w0.102: R258.2 v3(137.97,93.45) 137.16,92.64 137.16,92.44 137.16,92.43 ; R8.1 104.2,234.01 103.56,234.65 103.56,235.3 103.29,235.57 102.91,235.57 101.73,234.39 101.73,229.18 105.69,225.22 v3(105.69,223.53) ; 137.16,92.43 v1(137.13,92.43) ; 137.16,92.43 137.03,92.31 137.03,91.74 137.01,91.72 137.01,90.51 137.61,89.91 137.61,86.56 137.66,86.52 137.66,85.42 U29.AD40
  L4 w0.127: v3(137.97,93.45) 137.97,95.68 138.04,95.75 138.04,95.89 138.85,96.71 139.15,96.71 139.46,97.02 139.46,97.41 139.19,97.69 137.94,97.69 137.46,97.21 137.07,97.21 136.8,97.48 136.8,98.03 149.61,110.84 149.61,113.11 150.03,113.53 150.03,113.61 152.38,115.96 163.73,115.96 165.15,117.38 169.16,117.38 176.58,124.8 176.58,140.85 177.91,142.19 177.91,154.28 177.85,154.34 177.85,158.94 177.39,159.39 177.39,173.41 176.91,173.89 176.91,190.03 168.43,198.51 164.06,198.51 157.12,205.44 153.92,205.44 153.31,206.05 144.55,206.05 143.29,207.31 142.5,207.31 142.18,207.63 142.18,208.03 141.59,208.62 140.58,208.62 139.19,210.01 139.19,210.7 138.43,211.46 138.43,212.48 136.23,214.68 129.44,214.68 129.05,215.07 126.97,215.07 125.22,216.82 124.09,216.82 123.83,217.09 123.23,217.09 122.75,217.57 119.82,217.57 118.64,216.39 117.84,216.39 117.15,215.71 114.58,215.71 114.42,215.54 109.32,215.54 105.69,219.17 v3(105.69,223.53)
NGFF_CLKREQ0_N: length 5.9
  TOP w0.102: NGFF1.53 116.47,233.8 116.2,233.53 116.13,233.53 115.88,233.28 115.43,233.28 115.43,233.28 115.26,233.28 114.94,232.96 114.94,232.85 v3(114.86,232.77)
  BOTTOM w0.102: v3(114.86,232.77) 114.62,232.53 R676.1 114.62,231.64 v2(113.92,230.95)
NGFF_CLKREQ1_N: length 5.2
  TOP w0.102: R17.2 106.57,228.71 v1(106.8,228.94) 106.97,229.12 107.1,229.12 108.02,230.03 110.18,230.03 NGFF1.68
NGFF_DETECT_PCIE: length 278.5
  TOP w0.102: U29.AT27 144.17,78.06 144.47,77.76 144.79,77.76 144.86,77.83 145.17,77.83 145.3,77.71 145.62,77.71 145.77,77.86 146.94,77.86 147.35,77.45 147.7,77.45 148.97,76.18 v1(149.35,76.18) 149.73,76.18 150.07,76.52 152.06,76.52 152.15,76.44 152.48,76.44 v3(152.91,76.01) 153.34,75.57 154.9,75.57 R374.2
  L4 w0.127: v3(161.98,79.85) 163.34,79.85 164.3,80.82 164.3,81.81 163.49,82.62 163.49,93.76 170.92,101.18 176.87,101.18 177.83,102.13 177.83,108.85 176.87,109.8 176.87,120.82 179.6,123.55 179.6,135.47 188.11,143.98 188.11,150.12 190.26,152.27 190.26,167.97 183.98,174.25 182.35,174.25 180.2,176.4 180.2,179.7 182.12,181.62 182.63,181.62 184.47,183.45 184.47,184.56 184.42,184.61 184.42,187.06 185.39,188.04 185.39,217.87 180.38,222.88 172.67,222.88 169.79,220 158.44,220 155.14,216.7 151.67,216.7 150.49,215.52 138.71,215.52 137.52,216.71 130.28,216.71 129.76,217.24 129.23,217.24 127.66,218.8 127.21,218.8 126.99,219.02 124.77,219.02 124.67,219.12 124.07,219.12 122.99,220.2 117.47,220.2 111.45,226.23 111.45,230.82 111.63,231 111.71,231 v3(111.99,231.28)
  BOTTOM w0.102: v3(161.98,79.85) 161.94,79.82 159.85,79.82 157.29,77.25 157.01,77.25 155.56,75.8 153.42,75.8 153.21,76.01 v3(152.91,76.01) ; R1155.2 113.86,233.22 112.01,231.38 112.01,231.3 v3(111.99,231.28)
NGFF_DETECT_PCIE_C: length 4.8
  TOP w0.102: v3(115.78,233.83) 116.25,234.3 NGFF1.51
  BOTTOM w0.102: R1155.1 115.62,233.66 v3(115.78,233.83) 116.44,234.49 R1208.1
NGFF_DETECT_USB: length 284.6
  TOP w0.102: v3(154.96,81.41) 154.98,81.41 155,81.38 R346.2 154.52,79.97 153.91,79.97 153.62,79.69 152.28,79.69 152.19,79.6 151.74,79.6 v1(151.38,79.24) 151.32,79.18 147.63,79.18 147.38,79.44 145.88,79.44 145.58,79.74 143.88,79.74 U29.AR30
  L4 w0.127: v3(163.83,81.01) 163.24,81.6 163.24,93.86 170.81,101.43 176.77,101.43 177.57,102.24 177.57,108.74 176.62,109.7 176.62,120.92 179.35,123.65 179.35,135.57 187.86,144.08 187.86,166.33 188.02,166.5 188.02,169.85 183.87,174 182.24,174 179.95,176.29 179.95,179.81 182.01,181.87 182.53,181.87 184.21,183.56 184.21,184.45 184.16,184.51 184.16,187.17 185.14,188.15 185.14,217.76 180.27,222.63 172.78,222.63 169.9,219.74 158.55,219.74 155.24,216.44 151.77,216.44 150.59,215.26 138.6,215.26 137.41,216.46 130.18,216.46 129.79,216.85 129.26,216.85 127.56,218.55 127.1,218.55 126.88,218.77 124.67,218.77 124.56,218.87 123.97,218.87 122.92,219.91 118.25,219.91 118.21,219.95 117.58,219.95 117.37,219.95 111.2,226.12 111.2,242.09 v3(111.91,242.81)
  BOTTOM w0.102: v3(154.96,81.41) 156.47,81.41 156.57,81.31 163.53,81.31 v3(163.83,81.01) ; R1154.2 113.35,242.81 v3(111.91,242.81)
NGFF_DETECT_USB_C: length 5.2
  TOP w0.102: v3(116.18,246.72) 116.26,246.8 NGFF1.1
  BOTTOM w0.102: R1154.1 R1209.1 115.82,245.6 115.39,246.03 v2(115.39,246.31) 115.8,246.72 v3(116.18,246.72)
NGFF_PCIE0_RXN: length 8.9
  TOP w0.102: v3(112.73,235.9) 112.43,236.2 112.43,236.34 112.53,236.44 116.83,236.44 116.97,236.3 NGFF1.43
  BOTTOM w0.102: R664.1 112.43,234.71 112.43,235.6 v3(112.73,235.9) 112.73,236.69 v2(112.75,236.71)
NGFF_PCIE0_RXP: length 9.4
  TOP w0.102: v3(111.92,235.9) 112.22,236.2 112.22,236.43 112.45,236.66 116.83,236.66 116.97,236.8 NGFF1.41
  BOTTOM w0.102: R659.1 112.22,234.82 112.22,235.6 v3(111.92,235.9) 111.33,235.31 v2(111.28,235.31)
NGFF_PCIE0_TXN: length 8.1
  TOP w0.102: NGFF1.37 116.97,237.8 116.82,237.94 116.12,237.94 v3(115.82,237.64)
  BOTTOM w0.102: 114.96,237.94 114.57,237.94 113.47,236.85 113.47,235.43 113.61,235.3 113.84,235.3 R672.1 ; 114.96,237.94 v2(114.96,237.6) ; 114.96,237.94 115.52,237.94 v3(115.82,237.64)
NGFF_PCIE0_TXP: length 8.8
  TOP w0.102: v3(115.82,238.46) 116.12,238.16 116.83,238.16 116.97,238.3 NGFF1.35
  BOTTOM w0.102: 113.86,237.54 113.26,236.94 113.26,235.34 113.52,235.08 113.84,235.08 R669.1 ; 113.86,237.54 v2(113.61,237.78) ; 113.86,237.54 114.48,238.16 115.53,238.16 v3(115.82,238.46)
NGFF_PCIE1_RXN: length 16.1
  TOP w0.102: NGFF1.67 116.97,230.3 116.83,230.44 115.89,230.44 v3(115.61,230.17)
  BOTTOM w0.102: v2(110.95,224.88) 110.73,225.09 ; 110.73,225.09 108.82,223.18 108.82,222.66 108.92,222.56 109.12,222.56 109.22,222.46 R685.1 ; 110.73,225.09 111.3,225.66 113.54,225.66 114.55,226.68 114.55,229.86 115.13,230.44 115.34,230.44 v3(115.61,230.17)
NGFF_PCIE1_RXP: length 16.5
  TOP w0.102: v3(115.61,230.98) 115.94,230.66 116.83,230.66 116.97,230.8 NGFF1.65
  BOTTOM w0.102: R680.1 108.2,222.46 108.31,222.56 108.5,222.56 108.6,222.66 108.6,223.27 111.21,225.88 113.45,225.88 114.34,226.77 114.34,228.89 ; v3(115.61,230.98) 115.29,230.66 115.04,230.66 114.34,229.95 114.34,228.89 ; 114.34,228.89 v2(114,228.89)
NGFF_PCIE1_TXN: length 14.1
  TOP w0.102: R27.1 111.34,223.95 111.05,224.24 111.05,225.08 111.44,225.47 ; NGFF1.61 116.97,231.8 116.83,231.94 115.68,231.94 114.95,231.21 114.95,230.42 114.13,229.61 114.13,226.46 113.72,226.04 112.01,226.04 111.44,225.47 ; 111.44,225.47 v1(111.71,225.21)
NGFF_PCIE1_TXP: length 14.2
  TOP w0.102: 110.83,224.95 110.83,225.17 111.92,226.26 112.1,226.26 113.63,226.26 113.92,226.55 113.92,229.7 114.73,230.51 114.73,231.3 115.59,232.16 116.83,232.16 116.97,232.3 NGFF1.59 ; 110.83,224.95 v1(110.44,224.95) ; 110.83,224.95 110.83,224.16 R24.1
NGFF_PEWAKE0_N: length 16
  TOP w0.102: R19.2 R20.1 108.22,229.55 NGFF1.70 111.58,229.55 112.04,230.01 v3(112.04,230.26) ; v3(115.62,232.83) 115.75,232.83 116.22,233.3 NGFF1.55
  BOTTOM w0.102: v3(112.04,230.26) 112.34,229.96 v2(112.88,229.96) 113.77,229.96 115.62,231.81 v3(115.62,232.83)
NGFF_POWER_CTRL: length 259
  TOP w0.102: v3(170.15,195.94) 162.28,195.94 v3(162.18,196.05) ; U29.AN22 142.54,75.63 142.21,75.96 142.21,75.97 v4(142.21,75.97) ; R15.1 96.12,231.11 v3(95.89,230.88) ; R385.1 159.12,72.3 156.79,72.3 156.21,72.88 154.56,72.88 153.97,73.47 153.67,73.47 153.46,73.67 v3(152.19,73.67)
  L3 w0.127: v3(94.49,224.9) 94.96,225.37 95.87,225.37 101.42,219.83 104.68,219.83 111.6,212.91 112.3,212.91 115.47,209.74 115.47,206.84 125.43,196.87 161.28,196.87 161.94,196.21 162.01,196.21 v3(162.18,196.05) ; v3(152.19,73.67) 154.88,76.35 154.88,80.83 154.49,81.21 154.49,81.6 154.88,81.99 154.88,82.35 159.54,87.01 159.54,88.63 156.58,91.59 156.58,95.03 159.72,98.17 159.72,103.91 160.74,104.93 160.74,111.88 166.4,117.54 169.8,117.54 170.15,117.54 170.15,117.53 171.21,117.53 176.42,122.74 176.42,145.24 176.31,145.34 176.31,151.22 176.21,151.33 176.21,151.72 176.31,151.82 176.31,152.04 176.21,152.14 176.21,152.53 176.31,152.63 176.31,156.03 175.92,156.42 175.92,158.45 176.71,159.23 176.71,164.3 176.72,164.31 176.72,188.74 176.71,188.75 176.71,190.3 175.14,191.87 175.07,191.87 171,195.94 v3(170.15,195.94)
  BOTTOM w0.102: v3(94.49,224.9) 94.74,225.15 94.74,229.73 v2(94.97,229.96) v3(95.89,230.88) ; v4(142.21,75.97) 142.5,75.68 144.74,75.68 144.91,75.51 148.27,75.51 149.63,74.15 151.71,74.15 v3(152.19,73.67)
NGFF_POWER_CTRL_1: length 4
  TOP w0.102: Q3.G 95.22,232 R15.2 96.87,232.04 R11.2 97.46,233.27 v1(97.78,232.95)
NGFF_POWER_CTRL_V2: length 3.5
  BOTTOM w0.102: Q128.B 94.64,238.98 C864.1 93.66,240.02 R1228.1 92.78,240.03 v2(92.68,239.94)
NGFF_REFCLKN0: length 17.9
  TOP w0.102: v1(109.27,223.88) 109.21,223.95 R23.1 108.08,224.08 108.08,224.65 110.55,227.12 110.58,227.12 111.11,227.66 111.11,227.68 114.17,230.74 114.17,233.74 115.36,234.92 116.84,234.92 116.97,234.8 NGFF1.49
NGFF_REFCLKN1: length 8.4
  TOP w0.102: 114.19,225.17 115.19,226.17 115.19,227.97 116.14,228.92 116.84,228.92 116.97,228.8 NGFF1.73 ; 114.19,225.17 113.79,224.77 113.79,224.33 R26.1 ; 114.19,225.17 v1(114.43,224.93)
NGFF_REFCLKP0: length 17.8
  TOP w0.102: 108.23,225.16 107.82,224.75 107.82,224.58 R22.1 ; 108.23,225.16 110.45,227.38 110.47,227.38 110.86,227.76 110.86,227.79 113.92,230.85 113.92,233.85 115.25,235.18 116.84,235.18 116.97,235.3 NGFF1.47 ; 108.23,225.16 v1(107.98,225.41)
NGFF_REFCLKP1: length 9.6
  TOP w0.102: v1(112.98,224.95) 112.98,224.13 R25.1 113.54,224.33 113.54,224.88 114.94,226.28 114.94,228.08 116.04,229.18 116.84,229.18 116.97,229.3 NGFF1.71
NGFF_W_DISABLE1_N: length 5.2
  TOP w0.102: R9.2 105.71,232.9 105.73,232.91 107.51,232.91 107.54,232.88 v1(107.62,232.88) 107.65,232.88 107.67,232.9 108.44,232.9 108.6,233.05 NGFF1.56
NGFF_W_DISABLE2_N: length 5.3
  TOP w0.102: R8.2 105.64,233.92 106.04,233.52 v1(106.42,233.52) 107.35,233.52 107.4,233.47 107.8,233.47 107.88,233.55 NGFF1.54
OCP_6: length 7.6
  TOP w0.102: Q120.G 33.85,153.5 R1149.1 R1146.2 32.25,153.13 31.56,152.45 Q119.D 30.54,152.45 30.12,152.87 29.51,152.87 v1(28.88,153.5)
OCP_7: length 26
  TOP w0.102: U46.4 20.84,144.25 21.13,144.55 22.77,144.55 23.67,143.65 23.67,143 R1144.2 v1(24.45,143.6) 24.42,143.62 R1143.1 25.15,144.59 25.48,144.26 29.95,144.26 v1(32.42,146.73) 34.75,149.06 34.75,150.62 Q120.D 37.13,153 Q118.G
OCP_7_1: length 3.9
  TOP w0.102: Q118.D 39.64,152.68 40.44,153.48 41.2,153.48 v1(41.25,153.43) 41.27,153.4 R1147.1
ODTA0: length 46.7
  TOP w0.102: MEM1.K1 49.17,98.42 49.15,98.41 49.04,98.41 v4(48.83,98.2) 48.48,97.84 v1(46.56,97.84) ; v4(75.34,88.96) 75.72,89.34 U13.L18
  L3 w0.127: v4(48.83,98.2) 49.19,98.2 49.81,98.81 51.01,98.81 51.68,99.48 51.68,99.51 52.01,99.84 52.4,99.84 52.52,99.95 v4(52.77,99.95) 52.86,99.95 53.8,99.02 53.8,98.44 54.64,97.6 58.58,97.6 59.36,96.82 65.89,96.82 66.33,96.37 70.67,96.37 71.83,95.21 73.22,95.21 73.57,95.56 73.6,95.56 74.13,96.08 74.13,96.09 74.38,96.34 74.72,96.34 75,96.07 75,94.9 75.06,94.83 75.06,92.51 74.69,92.14 74.63,92.14 74.16,91.67 74.16,91.16 74.78,90.53 74.78,90.26 75.34,89.69 v4(75.34,88.96)
  L4 w0.127: v4(52.77,99.95) 53.03,99.95 54.6,98.39 55.12,98.39 55.26,98.52 v4(56.53,98.52)
  BOTTOM w0.102: MEM3.K1 56.42,98.42 v4(56.53,98.52)
ODTA1: length 46.8
  TOP w0.102: v4(75.31,86.88) 74.95,87.24 U13.K16 ; MEM2.K1 55.96,80.8 v4(56.59,81.43)
  L3 w0.127: v3(48.84,81.47) 51.15,81.47 51.41,81.21 52.21,81.21 52.36,81.06 v4(53.3,81.06) 53.3,81.42 53.17,81.54 53.16,81.54 52.96,81.75 52.96,82.03 53.06,82.13 53.62,82.13 53.81,81.93 54.18,81.93 54.31,82.06 54.31,82.33 54.43,82.46 54.69,82.46 54.81,82.33 54.81,82.06 54.94,81.93 55.19,81.93 55.32,82.06 55.32,82.33 55.45,82.46 55.7,82.46 55.83,82.33 55.83,82.06 55.96,81.93 56.73,81.93 57.12,82.32 57.12,82.79 57.25,82.91 58.05,82.91 58.4,82.57 63.71,82.57 63.88,82.41 66.72,82.41 66.9,82.58 67.94,82.58 68.06,82.71 68.24,82.71 68.48,82.46 69.09,82.46 69.47,82.08 69.8,82.08 69.93,81.96 69.93,81.72 70.05,81.59 71.55,81.59 71.93,81.98 73.57,81.98 73.58,81.97 74.2,81.97 74.27,81.9 74.7,81.9 74.97,82.17 74.97,82.52 74.94,82.55 74.94,83.37 74.42,83.89 74.42,84.1 74.65,84.33 74.65,84.62 74.52,84.74 74.34,84.74 74.14,84.94 74.14,85.15 74.27,85.28 74.71,85.28 74.93,85.06 75.39,85.06 75.93,85.6 75.93,86.26 v4(75.31,86.88)
  L4 w0.127: v4(53.3,81.06) 53.3,81.38 53.5,81.58 56.44,81.58 v4(56.59,81.43)
  BOTTOM w0.102: v2(47.09,81.14) 47.33,81.14 47.63,81.44 48.09,81.44 48.11,81.47 v3(48.84,81.47) 48.87,81.47 49.56,80.77 MEM4.K1
OSD_BIST_N: length 418.9
  TOP w0.102: R94.1 137.54,196.35 139.04,197.85 139.04,202.16 139.05,202.17 139.05,203.96 139.78,204.69 145.67,204.69 150.55,209.57 150.55,214.66 151.54,215.66 151.65,215.66 v3(151.66,215.66)
  L3 w0.127: v3(153.59,110.6) 153.59,108.54 151.73,106.68 141.92,106.68 140.18,104.94 137.26,104.94 135.66,103.33 133.53,101.2 133.53,101.15 131.61,99.23 126.55,99.23 125.82,98.51 125.82,98.5 124.72,97.4 124.72,95.18 125.21,94.69 125.21,92.77 125.55,92.43 125.55,91.1 125.43,90.97 125.43,89.94 126.25,89.12 126.25,88.75 125.62,88.12 123.86,88.12 122.77,87.03 122.77,84.22 123.7,83.3 v3(123.7,83.07)
  L4 w0.127: v3(123.7,83.07) 119.87,83.07 115.74,78.94 115.74,77.03 108.74,70.02 95.11,70.02 94.94,70.19 87.15,70.19 84.79,67.84 76.57,67.84 76.01,67.28 72.85,67.28 67.36,61.78 56.21,61.78 54.8,63.19 42.58,63.19 33.06,53.67 33.06,49.51 34.27,48.29 v3(34.97,48.29) ; v3(151.66,215.66) 152.18,216.19 155.35,216.19 158.65,219.49 170.02,219.49 172.91,222.37 180.17,222.37 182.92,219.62 182.92,216.76 184.38,215.3 184.38,196.93 184.53,196.78 184.53,188.48 183.54,187.49 183.54,184.27 183.6,184.2 183.6,183.81 183.24,183.45 182.73,183.45 179.34,180.06 179.34,176.04 182.34,173.03 183.98,173.03 187.41,169.6 187.41,167 187.15,166.73 187.15,144.59 178.74,136.18 178.74,123.9 170.06,115.22 166.05,115.22 164.62,113.8 156.79,113.8 v3(153.59,110.6)
  BOTTOM w0.102: v3(34.97,48.29) 34.87,48.19 32.69,48.19 32.18,48.7 9.44,48.7 8.6,47.86 6.05,47.86 4.05,45.86 4.05,39.48 5.66,37.86 7.96,37.86 10.33,35.49 11.58,35.49 12.12,34.96 v2(12.65,34.96) 12.81,34.96 R1063.2
OSD_BIST_N_1: length 9
  TOP w0.254: R94.2 136.08,197.09 137.47,197.09 138.32,197.94 138.32,198.47 137.69,199.09 v1(137.49,199.09) 135.2,199.09 Q20.B
OSD_DN: length 215.5
  TOP w0.102: R569.1 17.51,32.42 v1(18.31,32.42) 18.31,31.97 17.59,31.25 17.36,31.25 R571.1 C312.1 17.21,29.86 v3(16.52,29.17) ; v4(142,79.43) 141.83,79.26 U29.AM28
  L4 w0.127: v3(16.52,29.17) 17.12,29.17 17.98,28.3 19.76,28.3 21.44,26.63 27.05,26.63 30.73,22.95 30.78,22.95 33.34,20.38 35.12,20.38 37.64,17.86 37.64,17.55 39.03,16.16 39.63,16.16 40.75,15.07 41.46,14.36 45.89,14.36 46.09,14.55 57.03,14.55 57.23,14.35 59.84,14.35 60.77,15.27 64.78,15.27 66.07,13.99 72.45,13.99 75.17,11.27 77.43,11.27 79.35,13.19 88.23,13.19 90.18,15.14 105.94,15.14 106.42,15.62 115.56,15.62 115.95,15.22 118.47,15.22 119.21,14.49 128.61,14.49 129.27,15.15 135.13,15.15 138.64,18.65 139.84,18.65 141.6,20.42 141.6,21.62 145.54,25.56 145.54,27.11 148.08,29.65 148.08,34.81 151.16,37.88 151.16,42.39 148.63,44.92 148.63,46.98 148.49,47.12 148.49,53.4 149.35,54.26 149.35,61.2 150.05,61.9 150.05,63.42 150.75,64.12 150.75,66.43 151.61,67.29 151.61,70.37 148.49,73.49 148.49,75.35 143.93,79.91 142.47,79.91 142,79.44 v4(142,79.43)
OSD_DN_R: length 9.5
  TOP w0.102: PWRCN1.9 8.15,32.52 8.15,32.48 9.07,31.56 D11.3 15.74,31.56 15.79,31.51 15.91,31.51 R571.2
OSD_MENU: length 205.5
  TOP w0.102: U29.AT31 143.63,80.32 143.47,80.32 143.29,80.14 143.29,79.99 142.79,79.5 v4(142.64,79.5)
  L4 w0.127: v3(26.42,29.37) 26.52,29.27 26.52,27.59 33.44,20.68 35.97,20.68 40.65,16 41.47,16 42.85,14.61 45.79,14.61 45.98,14.8 57.14,14.8 57.34,14.6 59.73,14.6 60.66,15.53 64.89,15.53 66.02,14.4 70.31,14.4 70.84,14.93 73.11,14.93 73.57,14.47 78.83,14.47 79.57,13.74 88.42,13.74 90.2,15.52 105.96,15.52 106.31,15.87 115.68,15.87 116.08,15.48 118.58,15.48 119.31,14.74 128.5,14.74 129.16,15.4 135.02,15.4 138.53,18.91 139.73,18.91 141.35,20.53 141.35,21.73 145.29,25.67 145.29,28.61 147.42,30.74 147.42,34.76 150.9,38.24 150.9,42.27 148.37,44.8 148.37,46.87 148.23,47.01 148.23,53.55 149.07,54.39 149.07,54.39 149.09,54.41 149.09,54.43 149.1,54.44 149.1,61.32 149.82,62.05 149.82,63.52 150.5,64.19 150.5,66.58 151.36,67.45 151.36,70.27 148.26,73.36 148.26,73.91 143.55,78.62 143.52,78.62 v4(142.64,79.5)
  BOTTOM w0.102: C703.1 v2(24.66,33.87) 24.66,33.56 24.02,32.92 R1078.1 R1083.1 24.02,31.52 25.2,30.34 25.88,30.34 25.98,30.23 25.98,29.68 26.29,29.37 v3(26.42,29.37)
OSD_MENU_R: length 20.2
  BOTTOM w0.102: R1083.2 22.78,32 22.78,32.02 22.52,32.29 22.49,32.29 22.42,32.37 21.07,32.37 20.59,32.85 17.63,32.85 16.58,31.81 15.7,31.81 14.22,30.34 D21.3 10.6,31.86 6.81,31.86 PWRCN1.10
OSD_UP: length 237.4
  TOP w0.102: U29.AV29 145.61,79.23 147.29,79.23 147.55,78.98 150.56,78.98 150.86,78.68 151.62,78.68 152.32,79.39 154,79.39 v3(154.13,79.51)
  L4 w0.127: v3(11.18,37.3) 13.34,35.14 13.34,29.55 16.48,26.4 20.24,26.4 20.52,26.12 25.92,26.12 27.01,25.03 27.01,24.8 29.37,22.44 30.57,22.44 32.61,20.39 32.61,20.34 33.5,19.45 33.96,19.45 34.38,19.03 34.38,17.34 37.58,14.14 40.24,14.14 42.42,11.96 47.34,11.96 47.42,12.04 48.59,12.04 48.67,11.96 49.41,11.96 49.49,12.04 50.61,12.04 50.69,11.96 51.7,11.96 51.78,12.04 53,12.04 53.08,11.96 54.1,11.96 54.18,12.04 55.46,12.04 55.54,11.96 56.28,11.96 56.54,12.21 62.59,12.21 63.27,12.89 64.92,12.89 65.51,12.3 71.06,12.3 73.62,9.75 78.06,9.75 79.77,11.45 85.96,11.45 86.78,10.64 119.52,10.64 120.19,11.3 127.37,11.3 128.03,10.64 132.77,10.64 138.63,16.49 140.44,16.49 143.13,19.19 143.13,20.99 147.07,24.93 147.07,25.5 150.21,28.65 150.47,28.65 152.13,30.31 152.13,30.39 152.88,31.14 152.98,31.14 153.25,31.41 153.25,39.1 153.23,39.13 153.23,39.73 153.25,39.76 153.25,45.02 151.88,46.39 151.88,51.35 153.52,52.99 153.52,57.18 153.84,57.5 153.84,60.37 155.04,61.58 155.35,61.58 155.88,62.11 155.88,64.99 156.79,65.9 156.79,69.74 154.49,72.04 154.49,78.7 154.13,79.06 v3(154.13,79.51)
  BOTTOM w0.102: R1061.2 R1062.1 R1063.1 C694.1 12.33,37.53 v2(11.95,37.53) 11.41,37.53 v3(11.18,37.3)
OSD_UP_R: length 14.8
  BOTTOM w0.102: PWRCN1.8 6.65,34.02 13.04,34.02 R1062.2 15.14,35.77 16.13,34.78 D20.3
P25_GND: length 4.8
  TOP w0.127: U22.25 U23.25 142.71,44.59 v1(142.81,44.69) 142.84,44.71 142.84,45.82 143.07,46.05 R475.1
P_GNT_N1: length 4.8
  TOP w0.102: R335.1 148.94,81.04 v1(148.07,81.04) 145.75,81.04 145.62,80.91 144.92,80.91 U29.AU31
P_GNT_N2: length 6.4
  TOP w0.102: R342.1 150.6,80.22 v1(150.52,80.3) 150.32,80.5 149.53,80.5 149.5,80.48 147.81,80.48 147.49,80.8 145.79,80.8 145.59,80.59 U29.AV31
P_GNT_N3: length 14.6
  TOP w0.102: v4(133.57,79.9) 133.36,79.69 U29.R30
  BOTTOM w0.102: v4(133.57,79.9) 132.9,80.57 132.9,83.73 132.69,83.94 v2(132.69,87.08) 132.69,88.75 131.76,89.68 130.73,89.68 129.67,90.74 R916.1
P_INTA_N: length 12.2
  TOP w0.102: v1(154.99,79.48) 154.96,79.45 RN2.1 154.51,78.52 153.92,79.11 152.52,79.11 151.89,78.48 150.77,78.48 150.48,78.77 147.47,78.77 147.21,79.03 145.2,79.03 144.8,79.43 U29.AU29
P_INTB_N: length 11.2
  TOP w0.102: U29.AU27 145.05,78.06 145.3,78.32 145.64,78.32 145.69,78.27 147.11,78.27 147.26,78.11 149.58,78.11 v1(150.21,77.48) 150.61,77.08 152.29,77.08 152.38,77 154.2,77 154.57,77.37 RN2.3
P_INTC_N: length 10.3
  TOP w0.102: U29.AW28 146.01,78.68 147.28,78.68 147.38,78.57 150.39,78.57 151.05,77.92 v1(151.72,77.92) 151.72,77.92 152.63,78.83 153.81,78.83 154.43,78.2 154.43,78.02 154.45,78 154.58,77.87 RN2.2
P_INTD_N: length 10.1
  TOP w0.102: RN2.4 152.59,76.72 152.59,76.72 152.26,76.72 152.18,76.8 149.68,76.8 v1(148.95,77.53) 148.64,77.83 147.25,77.83 147.02,78.07 145.69,78.07 145.63,78.01 U29.AV27
P_PME#: length 12.1
  TOP w0.102: v4(136.61,79.9) 136.16,80.34 U29.AA31
  BOTTOM w0.102: R927.2 137.92,90.38 137.92,89.37 v2(137.87,89.32) 137.56,89 137.56,85.18 137.41,85.03 137.41,82.5 137.05,82.14 137.05,80.36 136.61,79.92 v4(136.61,79.9)
PANEL_ON_1: length 7.4
  TOP w0.102: R41.2 R40.1 R36.1 118.75,220.9 118.75,221.51 118.42,221.84 116.92,221.84 R33.2 v1(116.27,223.61)
PANEL_ON_2: length 3.5
  TOP w0.102: Q7.B 118.01,218.71 R40.2 118.24,218.09 v1(117.17,217.02)
PANEL_ON_3: length 7.3
  BOTTOM w0.102: R708.1 R707.2 113.35,221.45 v2(113.59,221.69) ; R708.1 C401.1 113.69,218.42 114.66,217.46 U36.3 ; R708.1 113.79,219.44 114.05,219.69 Q91.D
PANEL_ON_4: length 10.3
  TOP w0.102: v3(115.57,220.58) 114.87,219.88 Q7.C
  BOTTOM w0.102: R702.2 110.67,221.6 110.52,221.75 v2(110.52,222.11) 111.09,222.68 R700.1 111.86,222.9 Q90.G 113.89,222.23 113.89,222.2 115.52,220.58 v3(115.57,220.58) 115.57,220.63 115.62,220.68 Q91.G
PANEL_ON_5: length 3
  BOTTOM w0.102: Q90.D 116.46,223.88 R706.1 116.71,224.46 v2(117.44,225.18)
PANEL_SEL1_CABLE: length 11.4
  TOP w0.102: CONVT1.8 6.77,118.96 8.76,118.96 11.96,122.15 11.96,122.69 12.31,123.05 R164.2 R166.2
PANEL_SEL1_CABLE_PCH: length 360.9
  TOP w0.102: U29.AK28 140.41,79.56 v4(140.36,79.56) ; R164.1 14.99,123.05 15.37,123.43 17.27,123.43 18.16,122.54 v3(18.16,122.28)
  L3 w0.127: v3(166.8,58.53) 166.8,55.37 152.91,41.47 152.91,36.05 149.52,32.66 149.52,29.15 149.69,28.97 150.01,28.65 150.01,28.28 154.01,24.28 154.01,19.39 152.26,17.64 141.46,17.64 132.34,8.52 106.04,8.52 105.66,8.14 103.96,8.14 103.73,8.37 93.53,8.37 92.91,7.75 90.37,7.75 89.92,8.2 85.48,8.2 82.14,4.86 73.19,4.86 70.94,7.11 43.77,7.11 42.76,8.12 37.27,8.12 31.75,13.64 31.75,20.82 30.22,22.35 29.44,22.35 26.89,24.9 26.89,30.53 26.07,31.34 26.07,33.71 26.09,33.72 26.09,36.71 24.98,37.82 24.98,39.19 23.41,40.76 23.41,51.87 25.36,53.83 25.36,68.68 19.82,74.22 19.82,83.52 17.82,85.53 17.82,94.86 19.32,96.36 19.32,121.13 v3(18.16,122.28)
  L4 w0.127: v3(166.8,58.53) 166.8,59.04 166.67,59.16 166.67,59.26 165.44,60.49 165.44,61.92 164.85,62.52 164.85,64.14 v3(163.91,65.08)
  BOTTOM w0.102: v4(140.36,79.56) 141.04,80.24 141.04,80.92 141.28,81.16 141.5,81.16 141.72,81.38 142.59,81.38 142.83,81.62 142.83,82 143.17,82.34 144.85,82.34 145.08,82.1 145.17,82.01 145.63,82.01 145.94,82.32 145.94,82.42 146.83,83.31 148.6,83.31 149.44,84.14 153.61,84.14 153.93,84.46 161.13,84.46 161.21,84.54 164.48,84.54 166.65,82.37 166.65,80.18 166.9,79.93 166.9,76.03 166.35,75.47 165.02,75.47 v2(164.47,74.91) 163.93,74.38 163.93,65.11 v3(163.91,65.08)
PANEL_SEL2_CABLE: length 9.7
  TOP w0.102: CONVT1.11 8.61,113.3 8.61,113.3 11.69,110.22 13.24,110.22 13.36,110.35 14.03,110.35 R185.2 R186.2
PANEL_SEL2_CABLE_PCH: length 343.4
  TOP w0.102: R185.1 14.16,109.33 16.82,109.33 17.15,109.66 17.75,109.66 18.92,108.49 18.92,107.65 19.28,107.3 19.28,105.5 v3(17.65,103.87) ; U29.AW33 147.26,81.43 148.13,82.31 149.07,82.31 149.61,81.77 153.95,81.77 v3(154.19,82.01)
  L3 w0.127: v3(17.65,103.87) 16.89,103.11 16.89,95.49 16.24,94.83 16.24,85.45 16.89,84.79 16.89,76.26 24.85,68.3 24.85,54.32 22.35,51.81 22.35,43.09 20.72,41.46 19.03,41.46 17.34,39.77 17.34,33.19 21.57,28.95 25.72,28.95 26.28,28.4 26.28,24.36 31.24,19.39 31.24,13.43 37.06,7.61 42.55,7.61 43.56,6.6 70.73,6.6 72.97,4.35 82.58,4.35 85.92,7.69 89.71,7.69 90.16,7.25 93.12,7.25 93.74,7.86 103.52,7.86 103.75,7.63 105.87,7.63 106.25,8.01 132.57,8.01 141.69,17.13 152.47,17.13 154.52,19.18 154.52,24.91 153.48,25.96 153.48,41.69 167.31,55.52 167.31,56.91 167.41,57.01 v3(167.41,59.04)
  L4 w0.127: v3(167.41,59.04) 167.16,59.04 166.93,59.27 166.93,62.73 163.89,65.77 v3(163.42,65.77)
  BOTTOM w0.102: v3(163.42,65.77) 163.42,65.9 163.48,65.96 163.48,66.35 162.81,67.02 v2(162.81,72.88) 162.81,76.01 164.9,78.09 164.9,79.45 164.59,79.76 164.59,81.19 164.24,81.54 156.9,81.54 156.43,82.01 v3(154.19,82.01)
PANEL_SEL3_CABLE: length 12.1
  TOP w0.102: R189.2 R188.2 13.6,109.38 13.31,109.38 12.85,109.84 10.07,109.84 6.56,113.35 6.56,113.35 CONVT1.12
PANEL_SEL3_CABLE_PCH: length 316.9
  TOP w0.102: v4(143.38,79.42) 143.26,79.3 U29.AP28 ; R188.1 13.46,108.44 v3(12.7,109.2)
  L4 w0.127: v3(12.7,109.2) 13.84,108.06 13.84,103.79 17.13,100.5 17.13,50.26 11.68,44.82 11.68,42.4 10.98,41.69 10.93,41.64 10.71,41.41 10.71,36.31 13.08,33.93 13.08,29.44 16.37,26.15 18.81,26.15 19.08,25.87 25.81,25.87 26.76,24.92 26.76,24.69 29.27,22.18 30.46,22.18 32.36,20.29 32.36,20.23 33.39,19.2 33.85,19.2 34.12,18.92 34.12,17.24 37.48,13.88 40.14,13.88 42.31,11.7 47.44,11.7 47.52,11.78 48.48,11.78 48.56,11.7 49.62,11.7 49.7,11.78 50.5,11.78 50.58,11.7 51.81,11.7 51.89,11.78 52.89,11.78 52.97,11.7 54.24,11.7 54.32,11.78 55.35,11.78 55.43,11.7 56.39,11.7 56.53,11.85 62.23,11.85 62.24,11.84 62.1,11.71 62.1,10.05 63.27,8.89 64.92,8.89 67.35,11.31 71.69,11.31 73.51,9.5 78.17,9.5 79.87,11.2 85.85,11.2 86.67,10.38 119.63,10.38 120.29,11.05 127.26,11.05 127.93,10.38 132.88,10.38 138.48,15.99 140.6,15.99 146.3,21.69 146.3,23.81 147.32,24.82 147.32,25.39 150.32,28.39 151.47,28.39 153.5,30.43 153.5,39.21 153.48,39.24 153.48,39.63 153.5,39.65 153.5,45.13 152.13,46.5 152.13,51.24 153.77,52.88 153.77,57.08 154.26,57.56 154.26,60.27 155.15,61.16 155.48,61.16 156.13,61.81 156.13,64.88 157.05,65.8 157.05,69.84 154.74,72.15 154.74,79.56 154.19,80.12 v3(153.29,80.12)
  BOTTOM w0.102: v3(153.29,80.12) 151.89,80.12 v2(151.64,79.87) 151.1,79.33 146.69,79.33 146.59,79.44 143.39,79.44 v4(143.38,79.42)
PB_IN_SW1: length 9.4
  TOP w0.254: PWRCN1.5 9.1,35.57 D10.3 12.2,35.67 15.24,35.67 15.52,35.95 R549.1
PC_SPKR_DET: length 8.6
  TOP w0.203: 48.26,53.65 48.87,54.26 v1(49.68,54.26) 50.39,54.26 51.45,53.21 51.45,52.93 51.27,52.75 U24.54
  TOP w0.508: R455.1 46.62,55.37 46.48,55.23 46.48,54.09 46.97,53.6 48.21,53.6 48.26,53.65
PCH_1D05V_PG: length 324.4
  TOP w0.102: R211.2 v3(154.15,99.93) 156.95,102.73 157.23,102.73 157.26,102.75 157.76,102.75 158.06,103.06 158.8,103.06 158.92,102.94 U15.1 ; v3(9.27,247.51) 11.25,245.53 12.9,245.53 16.17,242.26 20.86,242.26 22.5,243.9 34.85,243.9 v1(38.99,239.76) 43.69,235.06 v3(45.64,235.06)
  L4 w0.127: v3(45.64,235.06) 45.64,234.59 51.77,228.46 89.15,228.46 90.3,227.31 93.5,227.31 94.9,225.92 103.41,225.92 103.57,225.75 105.83,225.75 107.75,223.84 107.75,223.48 110.29,220.94 110.43,220.94 114.22,217.15 116.03,217.15 116.37,216.81 117.18,216.81 117.52,217.15 118.32,217.15 119.5,218.34 123.06,218.34 123.54,217.85 124.14,217.85 124.25,217.75 126.46,217.75 127.38,216.83 127.38,216.52 128.07,215.83 129.36,215.83 129.76,215.44 136.72,215.44 139.39,212.77 140.2,212.77 146.13,206.84 153.6,206.84 154.07,206.38 157.27,206.38 164.37,199.27 168.75,199.27 177.67,190.35 177.67,174.21 178.61,173.27 178.61,155.98 179.41,155.18 179.41,142.61 177.34,140.54 177.34,124.48 169.48,116.62 165.47,116.62 164.04,115.2 154.68,115.2 150.46,110.98 150.46,108.52 148.59,106.65 148.59,105.52 149.99,104.12 153.86,104.12 154.62,103.36 154.62,100.4 v3(154.15,99.93)
  BOTTOM w0.102: Q86.3 9.52,244.7 R634.1 9.74,245.08 9.27,245.55 v3(9.27,247.51)
PCH_1D05V_PG_R: length 10.7
  BOTTOM w0.203: U35.1 16.25,241.52 15.85,241.92
  BOTTOM w0.254: 15.85,241.92 15.6,242.17 13.55,242.17 12.75,242.97 12.75,244.4 C366.1 R633.2 10.85,245.28 10.8,245.28 10.44,245.65 10.44,245.66 10.29,245.81 10.25,245.81 10.09,245.97 R634.2 9.93,246 9.93,246.77 v2(10.16,247)
PCH_AUD_MUTE: length 17.1
  TOP w0.102: R224.1 141.74,96.68 143.49,96.68 v1(143.92,96.25) 144.3,95.88 144.3,95.68 145.14,94.83 145.14,93.51 144.35,92.72 143.37,92.72 142.29,91.64 142.29,91.16 141.71,90.58 141.71,90.57 140.21,89.07 140.21,88.7 140.2,88.69 U29.AJ40
PCH_AUD_RST_N: length 61.9
  TOP w0.102: R469.1 143.51,54.72 142.34,53.55 142.34,49.62 140.21,47.49 v3(140.21,47.3) ; U29.AC32 137.29,81.05 v4(137.68,80.66)
  L4 w0.127: v4(137.68,80.66) 138.26,80.08 138.26,79.65 138.77,79.15 138.77,75.63 139.57,74.82 139.57,69.8 139.88,69.49 140.23,69.49 140.36,69.62 140.76,69.62 141.01,69.37 141.01,67.29 140.73,67.01 140.73,66.4 138.99,64.66 138.8,64.66 137.72,63.58 137.72,60.74 140.11,58.35 140.11,56.32 140.28,56.14 140.28,55.61 140.3,55.6 140.3,55.06 139.88,54.64 139.88,52.31 139.47,51.9 139.47,48.68 140.16,47.99 140.16,47.35 v3(140.21,47.3)
  BOTTOM w0.102: v4(137.68,80.66) 138.29,81.27 138.29,82.93 138.05,83.18 138.05,84.18 v2(138.42,84.56) 138.83,84.97 138.83,87.34 138.35,87.83 138.35,88.35 139.54,89.54 140.08,89.54 140.44,89.9 140.44,90.41 140.34,90.51 R925.2
PCH_AUD_RST_N_1: length 2.8
  TOP w0.102: Q62.5 145.8,54.53 R469.2 145.61,55.29 v1(145.16,55.74)
PCH_DPWROK: length 204.5
  TOP w0.102: U29.AV38 145.37,83.89 145.59,83.67 146.18,83.67 148.7,86.19 149.18,86.19 149.73,86.75 150.24,86.75 150.82,86.17 151.18,86.17 151.26,86.24 152.89,86.24 v4(153.13,86.48) ; v3(66.29,51.04) 66.45,51.19 v1(66.45,52.03) 66.29,52.18 R480.2 64.78,51.5 64.3,51.5 64.14,51.33 64.14,50.8 62.12,48.78 U24.28
  L3 w0.127: v3(66.29,51.04) 66.75,50.58 66.75,49.74 64.28,47.27 62.49,47.27 62.12,46.89 62.12,39.6 63.84,37.87 63.84,33.67 64.96,32.56 64.96,30.37 64.95,30.36 64.95,23.98 68.77,20.16 70.69,20.16 74.79,16.06 78.68,16.06 79.78,17.16 79.78,17.43 80.63,18.28 88.69,18.28 89.8,19.39 92.58,19.39 94.19,21 96.37,21 96.85,20.52 103.8,20.52 105.04,21.76 108.94,21.76 110.25,20.45 116.76,20.45 118.07,21.76 122.33,21.76 123.25,20.85 129.29,20.85 131.62,23.17 133.81,23.17 135.29,24.66 136.12,24.66 139.88,28.41 139.88,30.11 146.13,36.36 146.51,36.36 149.86,39.71 149.86,43.64 149.64,43.86 149.64,47.94 150.61,48.9 v3(153.01,48.9)
  L4 w0.127: v4(153.13,86.48) 153.46,86.48 155.76,84.19 155.76,72.57 158.17,70.16 158.17,64.23 157.15,63.22 157.15,60.76 155.98,59.59 155.98,58.91 155.55,58.48 155.55,53.04 153.73,51.23 153.73,50.51 153.01,49.79 v3(153.01,48.9)
