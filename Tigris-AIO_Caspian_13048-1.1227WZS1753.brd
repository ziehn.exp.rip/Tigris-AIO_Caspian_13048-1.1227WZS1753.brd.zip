# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V_1P05_PECI_VCOM: length 8.5
  TOP w0.102: v3(74.21,181.87) CPU1.N35
  BOTTOM w0.102: v3(74.21,181.87) 74.21,181.95 74.69,182.44 74.69,182.96 75.11,183.38 75.11,186.92 74.93,187.1 74.93,188.32 TP41.1
V_1P5_RTC_INT: length 4
  TOP w0.203: 146.73,82.7 U29.AW35
  TOP w0.508: 146.73,82.7 147.93,83.91 v1(148.26,83.91) 148.83,84.47 C198.1
V_1P5_STBY_INT: length 12.5
  TOP w0.102: v4(140.05,78.31) 139.87,78.49 139.87,78.51 139.86,78.56 139.83,78.61 139.8,78.66 139.76,78.7 U29.AH28
  BOTTOM w0.102: v4(140.05,78.31) 140.54,78.8 141.15,78.8 141.59,79.24 141.59,79.6 142.02,80.03 143.78,80.03 143.94,79.87 147.14,79.87 v2(147.45,80.17) 148.03,80.76 149.65,80.76 C606.1
V_1P05_XCK_DCB_FB_R: length 15.6
  TOP w0.203: 136.8,61.44 U29.AB1
  TOP w0.508: 136.8,61.44 137.1,61.14 137.1,60.63 136.44,59.97 C250.1 136.19,59.85 135.78,59.44 135.78,59.43 135.76,59.41 135.76,58.48 135.78,58.46 135.78,56.85 134.46,55.52 v3(134.09,55.52)
  BOTTOM w0.508: C665.1 R999.2 135.38,53.92 134.28,53.92 v2(133.9,54.3) 133.9,55.3 134.09,55.48 v3(134.09,55.52)
V_3_CARD: length 13.1
  L4 w0.762: v3(184.86,160.45) 185.6,159.71 185.6,157.56 183.79,155.76 183.79,155.25
  L4 w1.016: v3(184.65,152.51) 184.65,153.47 183.79,154.32 183.79,155.25
  BOTTOM w0.203: U39.17 183.54,159.14
  BOTTOM w0.508: C438.1 185.17,160.77 184.86,160.46 v3(184.86,160.45) 184.85,160.45 184.84,160.46 184.28,159.9 183.95,159.9 183.59,159.55 183.59,159.19 183.54,159.14
  vias: v1(183.21,153.37)
V_3P0_BAT_VREG: length 477.2
  TOP w0.356: v4(143.24,80.66) 143.26,80.68 U29.AP33
  TOP w0.406: v3(65.47,43.16) 65.66,43.35 65.66,43.99 R518.2
  TOP w0.508: v5(67.9,220.23) 67.79,220.34 67.79,226.98 69.76,228.95 D2.3 ; R281.1 145.67,92.29 147.07,93.69 147.07,94.24 147.37,94.55 148.04,94.55 148.17,94.68 149.31,94.68 R305.1 150.18,94.8 151.21,94.8 ; 151.21,94.8 151.54,95.13 R306.1 ; 151.21,94.8 151.21,93.84 149.77,92.4 R273.1 148.84,92.4 148.16,91.72 148.16,90.74 v3(147.96,90.53) ; v3(153.47,85.28) 153,85.74 R298.1
  TOP w0.635: v5(174.9,77.56) 174.6,77.25 v3(171.73,77.25) 165.25,77.25 v3(165.18,77.33)
  TOP w0.889: R386.2 197.61,72.75 v3(197.5,72.87)
  L3 w0.508: v3(117.47,46.97) 118.03,47.53 120.42,47.53 121.03,48.15 122.56,48.15 123.85,46.86 127.92,46.86 128.03,46.97 128.69,46.97 129.12,46.54 129.67,46.54 129.87,46.75 137.46,46.75 v3(137.62,46.59) ; v3(153.22,82.79) 153.19,82.79 152.69,82.29 150.19,82.29 149,83.48 149,85.47 149.63,86.1 149.63,87.92 148.18,89.37 148.18,90.31 v3(147.96,90.53) ; v3(94.31,55.81) 92.08,53.58 73.05,53.58 72.47,52.99 72.47,51.88 67.82,47.23 67.82,45.39 65.59,43.16 v3(65.47,43.16)
  L4 w0.508: v5(67.9,220.23) 67.42,220.23 57.9,210.71 57.9,207.53 52.83,202.46 52.83,171.53 51.79,170.49 51.79,146.69 83.95,114.54 98.84,114.54 110.64,102.73 110.64,80.06 105.12,74.53 v3(103.25,74.53) ; v3(117.47,46.97) 117.03,47.42 110.86,47.42 102.46,55.81 v3(94.31,55.81) ; v3(197.5,72.87) 195.76,74.6 190.06,74.6 189.23,73.77 189.23,72.65 186.22,69.64 181.57,69.64 177.93,73.29 177.93,74.53 v5(174.9,77.56) ; v3(153.47,85.28) 153.47,84.62 154.18,83.91 154.18,83.29 153.68,82.79 v3(153.22,82.79)
  BOTTOM w0.508: v3(171.73,77.25) 171.58,77.1 171.58,73.86 171.5,73.79 171.5,67.26 160.47,56.22 159.27,56.22 157.24,58.25 156.46,58.25 155.19,56.98 151.15,56.98 145.34,51.16 143.82,51.16 141.99,49.33 141.99,48.93 141.48,48.42 141.23,48.42 140.78,47.96 140.48,47.96 140.43,48.02 139.88,48.02 139.5,47.63 139.5,47.58 138.51,46.59 v3(137.62,46.59) ; v4(143.24,80.66) 144.18,80.66 144.25,80.59 144.75,80.59 145.33,81.16 150.36,81.16 150.41,81.11 C600.1 151.32,82.18 151.84,82.7 153.1,82.7 153.19,82.79 v3(153.22,82.79) 153.33,82.89 154.65,82.89 154.93,83.17 156.39,83.17 157.02,82.53 v2(161.32,82.53) 164.21,82.53 165.46,81.29 165.46,77.61 v3(165.18,77.33) ; v3(103.25,74.53) 103.37,74.53 103.86,74.04 103.86,72.84 103.8,72.77 103.8,69.54 104.55,68.79 104.55,65.51 116.97,53.09 116.97,47.48 v3(117.47,46.97)
V_3P3_A: length 547.5
  TOP w0.203: U24.22 62.27,46.38 v3(62.59,46.69) ; U24.45 v3(54.87,53.4) ; v3(49.33,53.22) 48.87,52.76 U24.60 ; U24.104 50.07,35.41 v3(50.34,35.14) ; U24.120 56.47,35.65 56.89,35.22 v3(57.08,35.22) ; U24.77 44.93,45.58 44.42,46.09 v3(44.42,46.12) ; v3(44.69,51.19) 45.57,51.19 45.72,51.04 U24.65 ; v3(50.67,53.25) 50.83,53.1 50.83,52.89 50.87,52.85 U24.55 ; v3(61.62,51.37) 61.62,51.19 61.21,50.78 U24.32
  TOP w0.33: v4(146.54,84.78) 146.5,84.74 U29.AW39 ; U29.AW39 145.48,84.74 U29.AV39 ; U29.AW39 U29.AW38
  TOP w0.356: R487.1 151.3,50.4 151.18,50.28 151.17,50.28 151.14,50.25 149.61,50.25 149.19,50.66 149.19,51.83 147.96,53.07 147.96,54.28 R466.1
  TOP w0.508: v3(175.64,73.26) 175.11,73.26 171.98,76.39 v3(166.44,76.39) ; v5(68.88,224.66) 69.66,225.44 D2.1 ; R225.2 R224.2 140.73,98.09 140.46,97.82 140.46,97.82 v3(140.42,97.78) ; v3(151,86.6) 150.34,87.26 148.73,87.26 147.97,86.5 147.97,86.21 v4(146.54,84.78) ; R487.1 151.79,50.19 151.79,49.97 152.06,49.69 153.98,49.69 154.43,50.14 155.13,50.14 v3(155.93,50.94) ; R480.1 64.26,52.18 64.13,52.05 64.01,52.05 63.76,51.8 63.58,51.62 63.45,51.44 63.42,51.41 v3(63.42,51.29) ; v3(190.02,73.49) 190.7,72.81 R380.1 ; v3(153.54,83.55) R313.2 ; v3(150.93,90.08) 151.37,90.52 R283.2 ; C290.2 15.49,37.07 14.98,36.55 D10.2 12.57,37.99 v3(12.57,38.34)
  L3 w0.508: v3(151,86.6) 150.49,87.11 150.49,89.64 v3(150.93,90.08) ; v3(57.08,35.22) 57.08,35.39 55.35,37.12 55.35,39.22 53.85,40.72 53.85,44.03 v3(54.86,45.04) ; v3(44.69,51.19) 44.69,51.18 45.26,50.6 45.26,46.96 v3(44.42,46.12) 44.42,45.86 45.08,45.2 45.08,36.51 44.68,36.11 44.68,35.47 45.11,35.04 v3(45.77,35.04) ; v3(71.25,52.05) 71.25,51.73 67.06,47.54 67.06,46.47 66.57,45.98 63.3,45.98 v3(62.59,46.69) ; v3(140.97,38.21) 140.67,37.91 140.28,37.91 139.6,37.22 139.49,37.22 138.86,36.59 136.48,36.59 133.86,33.96 133.86,31.2 131.45,28.8 126.86,28.8 126.29,29.37 126.29,30.72 125.93,31.07
  L4 w0.508: v3(175.64,73.26) 175.72,73.19 176.95,73.19 181.26,68.88 186.53,68.88 190.02,72.36 v3(190.02,73.49) ; v5(68.88,224.66) 63.03,224.66 51,212.63 51,173.57 44.07,166.63 44.07,163.5 30.63,150.07 30.63,144.95 30.48,144.79 30.48,136.76 29.73,136.02 29.73,133.8 22.61,126.67 22.61,72.01 23.62,70.99 26.17,68.44 31.47,68.44 31.49,68.46 33.16,68.46 36.2,65.42 v5(36.2,65.39) 26.92,65.39 20.32,58.79 20.32,52.31 12.57,44.57 v3(12.57,38.34) ; v3(153.54,83.55) 151,86.09 v3(151,86.6) ; v3(150.93,90.08) 150.93,90.44 148.2,93.17 142.51,93.17 140.23,95.45 140.23,96 140.43,96.19 140.43,97.77 v3(140.42,97.78) ; v3(54.86,45.04) 54.86,45.97 55.74,46.85 56.9,46.85 58.5,48.45 60.83,48.45 v3(62.59,46.69) ; v3(45.77,35.04) 50.24,35.04 v3(50.34,35.14) 51.16,35.95 55.53,35.95 56.26,35.22 v3(57.08,35.22)
  BOTTOM w0.203: v4(146.54,84.78) 146.54,84.67 145.7,83.84 145.15,83.84 144.83,83.52 144.27,83.52 R947.2
  BOTTOM w0.508: C679.1 54.18,45.63 54.76,45.04 v3(54.86,45.04) 55.14,44.76 R1026.1 ; C670.2 46.37,52.17 45.63,51.43 C671.2 44.74,51.24 v3(44.69,51.19) ; C670.2 48.92,52.82 v3(49.33,53.22) ; C670.2 C669.2 ; C680.1 45.38,45.23 C678.2 44.3,46 v3(44.42,46.12) ; C677.2 62.31,46.97 v3(62.59,46.69) ; v3(153.54,83.55) 153.63,83.55 154.11,84.03 v2(161.42,84.03) 164.37,84.03 166.22,82.19 166.22,80 166.44,79.77 v3(166.44,76.39) ; C668.2 57.32,52.32 57.66,52.66 59.66,52.66 60.96,51.37 v3(61.62,51.37) 61.62,51.19 61.53,51.1 C672.2 62.23,50.53 62.43,50.73 R1001.1 62.52,51.51 62.69,51.67 63.04,51.67 v3(63.42,51.29) ; C668.2 54.94,52.17 v2(53.16,52.17) C669.2 ; C668.2 55.09,53.17 v3(54.87,53.4) ; C669.2 50.95,52.77 50.83,52.89 50.83,53.1 v3(50.67,53.25) ; v3(57.08,35.22) 56.86,35.44 56.79,35.44 C691.2 ; R1068.1 45.52,34.78 v3(45.77,35.04) ; v3(50.34,35.14) 49.78,35.7 R1060.1 49.4,35.99 49.38,35.96 C695.2 ; v3(140.97,38.21) 142.21,38.21 143.13,37.3 147.72,37.3 150.17,39.74 150.17,42.43 155.93,48.19 v3(155.93,50.94) 155.93,51.41 158.25,53.73 161.5,53.73 164.29,56.52 166.26,56.52 173.99,64.25 173.99,71.61 v3(175.64,73.26) ; C581.1 146.67,84.91 v4(146.54,84.78)
  BOTTOM w1.016: v5(36.2,65.39) 36.68,64.91 42.19,64.91 42.67,65.39
  vias: v2(47.07,67.78) v2(94.46,58.35) v2(101.65,52.46) v2(103.63,46.87) v5(43.51,67.17) v5(43.52,66.2) v5(100.25,49.23) v5(101.02,48.32) v5(101.03,47.06) v5(101.07,50.4) v5(101.8,51.01) v5(101.8,49.64) v5(101.93,48.35) v5(101.93,47.2) v5(125.09,33.77) v5(125.09,32.75) v5(126.11,33.77) v5(126.11,32.75)
V_3P3_BG: length 45.9
  TOP w0.254: U29.AW21 145.96,75.06 146.39,74.63 v4(146.39,74.36) ; U29.B6 125.71,66.74 125.05,66.74 123.7,65.39 123.19,65.39 122.43,64.63 C247.1 ; U29.AE1 138.16,62.79 v3(138.3,62.65)
  TOP w0.508: v3(121.21,62.95) 121.09,63.06 C247.1
  L4 w0.305: 141.76,68.11 141.33,68.54 141.33,69.71 v3(142.21,70.6)
  L4 w0.508: 141.76,68.11 141.76,66.58 139.41,64.24 138.97,64.24 138.23,63.5 138.23,62.72 v3(138.3,62.65) ; v3(136.27,61.07) 136.12,61.07 134.24,62.95 133.63,62.95 133.3,62.62 132.34,62.62 132.01,62.95 v3(121.21,62.95)
  BOTTOM w0.508: v3(142.21,70.6) 142.76,71.14 143.04,71.14 144.15,72.25 v2(144.15,72.37) 144.93,72.37 145.95,73.39 145.95,73.39 146.39,73.84 v4(146.39,74.36) ; v3(136.27,61.07) 136.91,61.07 137.07,61.23 137.22,61.23 C659.1 137.41,61.52 137.41,62.57 R992.1 137.41,62.62 138.19,62.62 138.22,62.65 v3(138.3,62.65)
V_3P3_EPW: length 46
  TOP w0.254: U29.R41 133.08,86.44 133.07,86.46 133.07,87.48 130.37,90.17
  TOP w0.508: v3(128.7,91.62) 128.71,91.61 C172.1 129.68,91.61 129.68,91.09 v1(130.07,90.69) 130.37,90.39 130.37,90.17 ; R184.1 145.03,112 144.15,111.11 144.15,110.03 C127.1 ; v3(139.06,108.95) 138.56,109.46 138.56,110.22 140.21,111.87 140.21,113.33 R180.1
  L3 w0.508: v3(143.13,109.23) 142.85,108.95 v3(139.06,108.95) 137.48,108.95 v3(131.95,103.43)
  L4 w0.508: v3(128.7,91.62) 128.45,91.62 127.1,92.96 127.1,94.24 127.63,94.76 127.73,94.76 128.68,95.71 128.68,98.61 130.71,100.64 130.71,101.51 131.94,102.74 131.95,103.05 v3(131.95,103.43)
V_3P3_LAN: length 45.8
  TOP w0.203: U26.32 26.69,33.66 v3(26.54,33.51) ; U26.11 32.12,35.68 32.74,35.06 v3(32.74,34.86)
  TOP w0.254: RJ1.12 16.83,8.55 22.18,13.89 29.39,13.89 30.23,14.73 30.23,17.92 29.69,18.46 v3(29.69,19.16)
  TOP w0.508: v3(26.54,33.51) 25.81,33.51 25.4,33.11 C309.1 ; U28.5 23.83,27.29 v3(24,27.11) ; C317.1 31.7,28.99 Q80.D v3(30.61,27.8) ; U30.5 v3(27.89,27.16) ; v3(34.32,36.26) 34.42,36.15 R548.1 ; v3(32.74,34.86) 32.98,34.62 C305.1
  L3 w0.254: v3(24,27.11) 24.45,27.11 24.98,26.58 24.98,23.58 25.68,22.88 26.94,22.88 29.35,20.47 29.35,19.74 29.62,19.47 29.62,19.24 v3(29.69,19.16)
V_3P3_LAN_VDDSREG: length 3.3
  TOP w0.203: U26.23 27.78,39.05 27.56,39.27 27.56,39.73 v3(28.83,41)
  vias: v2(34.72,40.52)
V_3P3_PCIVAUX: length 14.6
  TOP w0.305: 110.2,228.04 NGFF1.74 108.68,228.55 ; 108.7,246.55 NGFF1.2 110.2,247.37 ; NGFF1.4 108.68,246.05 ; NGFF1.72 108.67,229.05
  TOP w0.508: Q2.G 95.54,238.05 R4.1 98.62,238.05 ; R1.1 98.51,241.2
  TOP w0.559: R1.1 95.5,241.2 Q1.G
  vias: v1(98.93,237.09) v2(107.95,228.33) v5(96.39,226.81) v5(97.03,227.82) v5(97.41,226.81) v5(107.44,227.44) v5(108.46,227.44)
V_5_CODEC: length 24.1
  TOP w0.203: 183.77,86.6 183.68,86.69 183.68,87.07 183.14,87.61 U16.39
  TOP w0.508: v3(189.18,84.18) 188.91,84.45 187.39,84.45 C193.1 185.86,85.14 184.61,85.14 C194.2 184.24,85.19 183.77,85.66 183.77,86.6
  BOTTOM w0.635: v3(189.18,84.18) 188.21,83.22 C525.1
  BOTTOM w0.889: C525.1 186.69,82.97 v2(185.04,82.97) 182.55,82.97 182.36,82.78 180.52,82.78 177.13,79.38 L31.1
V_5_LCD1: length 1
  BOTTOM w0.254: L27.1 v2(118.49,215.88)
V_5_LCD2:
  vias: v2(119.13,224.42)
V_5HDD: length 8.8
  TOP w0.508: 18.7,86.01 TC18.1 ; TC18.1 18.7,88.12 ; TC18.1 19.76,87.06 ; TC18.1 17.65,87.06 ; 5.46,100.05 SATAP1.3 ; SATAP1.3 6.62,98.89 ; SATAP1.3 7.78,100.05 ; SATAP1.3 6.62,101.21
V_5P0_A: length 226.7
  TOP w0.508: v3(47.24,54.26) 47.24,54.41 47.69,54.86 R463.2 ; v3(56.29,44.81) 56.64,44.81 56.77,44.94 58.66,44.94 58.67,44.93 59.55,44.93 v3(59.56,44.94) ; R545.2 40.39,37.78 v3(40.34,37.83) 40.36,37.86 40.36,39.07 40.87,39.58 R535.2
  L3 w0.508: v3(48.39,38.64) 48.39,41.83 47.53,42.69 47.53,44.26 48.03,44.76 48.03,45.86 48.79,46.62 48.79,47.84 48.41,48.22 48.41,53.05 47.42,54.04 47.42,54.09 v3(47.24,54.26) ; v5(102.49,29.96) 98.4,25.87 91.82,25.87 91.49,25.54 83.47,25.54 81.18,23.25 74.9,23.25 71.75,26.4 71.75,35.92 64.8,42.88 64.8,43.56 63.67,44.69 v3(63.25,44.69)
  L4 w0.508: v3(56.29,44.81) 56.39,44.71 56.39,39.7 56.16,39.48 55.66,39.48 55.65,39.47 55.1,39.47 55.09,39.48 52.45,39.48 51.28,38.31 49.56,38.31 49.23,38.64 v3(48.39,38.64) 44.75,38.64 43.61,37.5 40.78,37.5 40.45,37.83 v3(40.34,37.83)
  L4 w0.762: v5(175.39,75.45) 175.39,74.94 174.85,74.41 174.85,72.09 176.66,70.29 176.66,67.8 175.77,66.91 175.77,62.32 174.88,59.92 174.05,59.1 174.05,57.96 172.97,56.88 172.97,54.59 171.07,52.69 171.07,50.15 168.53,47.61 168.53,44.05 164.72,40.24 164.72,29.57 164.47,29.32 164.47,21.83 161.8,19.16 156.46,19.16 153.67,16.37 147.04,16.37 144.43,13.76 144.08,13.76 143.64,13.32 v5(139.42,13.32)
  BOTTOM w0.508: R1039.1 47.88,40.79 47.88,40.32 C683.2 48.39,39.81 v3(48.39,38.64) 48.82,38.64 49.03,38.86 R1053.1 ; v3(63.25,44.69) 62.17,45.77 R1022.1 60.63,45.77 59.81,44.94 v3(59.56,44.94)
  BOTTOM w0.762: v5(175.39,75.45) 175.39,75.93 D17.K 176.4,76.95 L31.2
  BOTTOM w1.016: v5(139.42,13.32) 139.45,13.32 138.35,14.41 136.45,14.41 133.4,17.46 132.82,17.46 128.07,22.21 124.08,22.21 123.06,23.22 123.06,25.38
  vias: v2(104.65,31.45) v2(120.62,29.14) v5(101.85,33.38) v5(101.85,32.37) v5(101.85,31.35) v5(102.87,34.02) v5(102.87,33) v5(102.87,31.99) v5(102.87,30.97) v5(120.98,26.78) v5(120.98,25.79) v5(122,26.78) v5(122,25.79)
V_5P0_HDMI_CONN: length 2.2
  TOP w0.305: HDMI1.18 47.33,20.2 v5(47.12,19.98)
  vias: v2(49.53,20.96)
V_5P0_HDMI_CONN_L:
  vias: v2(55.73,25.49)
V_12_INV: length 13.4
  TOP w0.508: 4.87,124.05 CONVT1.2 5.86,125.04 ; CONVT1.1 7.86,125.04 ; CONVT1.1 7.73,124.05 6.99,123.3 ; CONVT1.1 8.85,124.05 ; 4.87,122.05 CONVT1.4 ; CONVT1.4 5.99,122.05 6.73,122.79 ; CONVT1.4 5.86,122.01 6.6,121.27
  BOTTOM w0.508: 4.87,124.05 CONVT1.2 5.86,125.04 ; 8.85,124.05 CONVT1.1 7.86,125.04 ; 4.87,122.05 CONVT1.4
  vias: v2(13.27,121.89) v5(12.06,126.35) v5(12.06,125.21) v5(12.06,124.19)
V_12P0_A: length 326.1
  TOP w0.508: v3(70.48,51.93) 69.98,51.42 69.98,46.88 69.55,46.44 69.55,36.2 68.85,35.51 68.83,35.51 v3(68.58,35.26) ; R576.1 132.18,29.07 132.52,28.72 R584.1 v3(133.35,28.15) ; R553.1 137.06,34.45 136.88,34.63 136.88,34.76 v3(137.79,35.67) ; R422.1 51.37,67.36 50.67,66.66 v3(50.67,66.53) 50.67,66.4 51.49,65.59 R428.1 52.14,65.24 53.48,63.91 55.83,63.91 v3(56.38,63.35) ; C113.1 30,154.39 v3(30,153.53) ; C113.1 29.62,155.17 29.62,157.24 29.85,157.46 31.4,157.46 Q115.2 32.85,156.51 33.49,157.15 R1133.1 33.78,157.18 33.91,157.31 R1138.1 33.11,158.16 32.83,158.44 R1136.1 32.85,159.85 33.17,159.85 33.78,160.46 v1(33.78,160.51) 33.27,161.02 32.64,161.02 ; C113.1 30.84,153.96 R1146.1 ; R530.1 111.34,40.73 R531.1 112.38,41.25 112.81,41.67 v3(113.06,41.67) ; 6.36,134.36 ATX2.1
  TOP w0.762: 18.49,134.81 R844.2
  TOP w0.838: 18.49,134.81 v1(20.57,136.89) 21.78,138.1 v1(23.09,138.1) v1(25.2,138.1) 26.84,138.1 v5(26.95,137.98)
  L3 w0.508: v3(50.67,66.53) 50.55,66.53 49.17,67.9 41.39,67.9 40.68,67.19 32.92,67.19 32.45,66.73 30.07,66.73 28.94,67.86 28.94,72 29.51,72.58 29.51,73.65 29.52,73.65 29.52,74.91 29.51,74.91 22.34,82.09 22.34,97.69 22.3,97.72 22.3,118.93 23.48,120.11 23.48,134.74 26.72,137.98 v5(26.95,137.98) ; v3(137.79,35.67) 137.16,35.67 135.2,33.72 135.2,32.53 135.08,32.41 135.08,31.4 133.42,29.75 133.42,28.23 v3(133.35,28.15) 132.33,27.14 129.75,27.14 129.37,27.52 116.64,27.52 116.15,27.04 116.15,27.01 115.12,25.98 113.1,25.98 112.06,27.01 101.9,27.01 100.05,25.16 92.01,25.16 90.25,23.4 88.69,23.4 87.47,22.18 84.56,22.18 84.16,22.59 74.67,22.59 71.12,26.14 71.12,32.72 v3(68.58,35.26)
  L4 w0.508: v3(30,153.53) 27.18,150.71 27.18,142.48 27.89,141.77 27.89,138.92 v5(26.95,137.98)
  BOTTOM w0.508: v3(113.06,41.67) 113.46,42.07 123.52,42.07 124.15,41.44 134.73,41.44 136.88,39.29 136.88,36.59 v3(137.79,35.67) ; v3(68.58,35.26) 68.46,35.26 67.74,34.55 66.24,34.55 64.03,36.76 64.03,37.99 63.07,38.95 62.92,38.95 62.42,39.45 R1046.1 R1047.1 ; v3(56.38,63.35) 57.02,63.99 62.51,63.99 70.76,55.74 70.76,52.71 70.48,52.43 v3(70.48,51.93)
V_CPU_CORE: length 168.9
  TOP w0.508: 43.71,209.21 TC4.1 ; TC4.1 44.76,210.27 ; TC4.1 44.76,208.16 ; TC4.1 45.82,209.21 ; L1.2 38.65,212 ; L1.2 37.05,213.6 ; L1.2 35.45,212 ; L1.2 37.05,210.39 ; 45.85,192.22 TC8.1 ; TC8.1 44.79,193.28 ; TC8.1 45.85,194.33 ; TC8.1 46.9,193.28 ; TC10.1 46.9,185.4 ; TC10.1 44.79,185.4 ; TC10.1 45.85,186.46 ; TC10.1 45.85,184.35 ; v3(57.23,217.56) 55.07,217.56 52.93,219.69 52.93,226.07 52.98,226.13 52.98,226.67 52.6,227.06 50.82,228.84 47.77,228.84 33.52,243.09 22.48,243.09 21.09,241.7 15.94,241.7 13.69,243.95 v3(8.08,243.95) ; TC11.1 46.77,177.53 ; TC11.1 45.72,176.48 ; TC11.1 45.72,178.58 ; TC11.1 44.67,177.53 ; L5.2 38.65,189.01 ; L5.2 37.05,187.41 ; L5.2 35.45,189.01 ; L5.2 37.05,190.61 ; TC6.1 45.85,202.33 ; TC6.1 45.85,200.22 ; TC6.1 46.9,201.28 ; TC6.1 44.79,201.28 ; 37.73,178.49 L6.2 ; L6.2 39.33,180.09 ; L6.2 37.73,181.69 ; L6.2 36.13,180.09
  TOP w0.559: R47.1 v3(60.83,217.58)
  L3 w1.27: v5(49.09,213.99) 49.1,213.99 49.1,214.03 52.63,217.56 v3(57.23,217.56) 57.25,217.58 v3(60.83,217.58)
  BOTTOM w0.508: TC6.1 46.9,201.28 ; TC6.1 45.85,202.33 ; TC6.1 45.85,200.22 ; TC6.1 44.79,201.28 ; L5.2 38.65,189.01 ; L5.2 37.05,190.61 ; L5.2 37.05,187.41 ; L5.2 35.45,189.01 ; R652.2 9.11,243.95 v3(8.08,243.95) ; 36.07,178.67 35.43,178.67 35.02,179.08 35.02,180.09 G5.1 ; TC4.1 45.82,209.21 ; TC4.1 44.76,208.16 ; TC4.1 43.71,209.21 ; TC4.1 44.76,210.27 ; L1.2 38.65,212 ; L1.2 35.45,212 ; L1.2 37.05,210.39 ; L1.2 37.05,213.6 ; 45.85,192.22 TC8.1 ; TC8.1 46.9,193.28 ; TC8.1 44.79,193.28 ; TC8.1 45.85,194.33 ; 36.13,180.09 L6.2 ; L6.2 39.33,180.09 ; L6.2 37.73,178.49 ; L6.2 37.73,181.69 ; 36.32,191.12 36.32,191.75 36.58,192.01 37.24,192.01 G4.1 ; TC10.1 46.9,185.4 ; TC10.1 45.85,186.46 ; TC10.1 45.85,184.35 ; TC10.1 44.79,185.4 ; TC11.1 45.72,178.58 ; TC11.1 46.77,177.53 ; TC11.1 44.67,177.53 ; TC11.1 45.72,176.48 ; 36.2,213.72 36.2,214.36 G2.1
  vias: v2(41.53,188.6) v2(42.24,198.41) v2(45.64,172.17) v2(53.54,199.68) v2(54.71,180.35) v2(54.66,167.52) v2(79.07,165.13) v3(58.8,185.47) v3(59.58,182.78) v3(59.58,180.95) v3(59.58,179.12) v3(59.58,177.56) v3(59.58,176.01) v3(59.58,174.18) v3(59.58,172.35) v3(59.58,170.52) v3(61.4,182.78) v3(61.4,180.95) v3(61.4,179.12) v3(61.4,177.56) v3(61.4,176.01) v3(61.4,174.18) v3(61.4,172.35) v3(61.4,170.52) v3(63.23,180.95) v3(63.23,179.12) v3(63.23,177.29) v3(63.23,176.01) v3(63.23,174.18) v3(63.23,172.35) v3(63.23,170.52) v3(65.06,180.95) v3(65.06,179.12) v3(65.06,177.29) v3(65.06,176.01) v3(65.06,174.18) v3(65.06,172.35) v3(65.06,170.52) v3(66.89,180.95) v3(66.89,179.12) v3(66.89,177.29) v3(66.89,176.01) v3(66.89,174.18) v3(66.89,172.35) v3(66.89,170.52) v3(66.89,168.69) v3(68.72,180.95) v3(68.72,179.12) v3(68.72,177.29) v3(68.72,176.01) v3(68.72,174.18) v3(68.72,172.35) v3(68.72,170.52) v3(68.72,168.69) v3(70.55,180.95) v3(70.55,179.12) v3(70.55,177.29) v3(70.55,176.01) v3(70.55,174.18) v3(70.55,172.35) v3(70.55,170.52) v3(70.55,168.69) v3(71.46,180.95) v3(71.46,166.86) v3(71.46,165.04) v3(71.46,163.21) v3(71.46,161.38) v3(72.38,179.12) v3(72.38,177.29) v3(72.38,176.01) v3(72.38,174.18) v3(72.38,172.35) v3(72.38,170.52) v3(72.38,168.69) v3(73.29,176.01) v3(73.29,174.18) v3(73.29,172.36) v3(73.29,170.53) v3(73.29,168.7) v3(73.29,166.87) v3(73.29,165.04) v3(73.29,163.21) v3(73.29,161.38) v3(73.29,159.55) v3(74.47,177.88) v3(74.52,172.68) v3(74.52,171.28) v3(74.52,170.52) v3(74.52,169.38) v3(74.52,168.62) v3(74.52,165.32) v3(74.52,164.55) v3(74.52,163.16) v3(74.52,162.39) v3(74.52,161.25) v3(74.52,160.49) v3(74.52,159.35) v3(75.39,176.71) v3(75.82,177.85) v3(76.71,176.74) v3(77.09,177.9) v3(78.39,177.9) v4(74.09,176.58) v4(74.09,174.55) v4(74.63,175.57) v4(78.06,176.62) v4(78.36,174.3) v4(78.37,172.29) v4(78.36,170.26) v4(78.41,168.2) v4(78.36,166.18) v4(78.41,164.13) v4(78.41,162.1) v4(78.4,160.08) v5(35.31,213.22) v5(35.31,187.69) v5(35.43,190.74) v5(35.56,185.78) v5(35.69,209.91) v5(36.83,186.93) v5(36.83,185.78) v5(36.96,178.04) v5(37.21,209.41) v5(38.35,186.93) v5(38.61,213.6) v5(38.73,210.55) v5(38.86,209.41) v5(38.86,188.45) v5(38.86,182.36) v5(39.12,191.25) v5(39.24,212.2) v5(39.24,189.85) v5(39.37,178.42) v5(39.37,176.26) v5(39.88,214.74) v5(39.88,183.88) v5(40.01,192.52) v5(40.13,213.47) v5(40.13,211.44) v5(40.13,209.66) v5(40.13,188.83) v5(40.26,181.72) v5(40.51,190.23) v5(40.89,179.43) v5(41.4,193.28) v5(41.4,191.5) v5(41.4,183.63) v5(41.4,175.24) v5(41.53,185.66) v5(41.91,177.4) v5(42.16,180.7) v5(42.55,182.23) v5(42.8,185.02) v5(42.93,179.31) v5(43.18,187.18) v5(43.48,177.4) v5(43.81,182.99) v5(44.42,175.14) v5(44.75,190.71) v5(44.83,181.85) v5(44.88,205.39) v5(44.91,197.75) v5(45.16,207.48) v5(45.24,199.35) v5(46.35,175.24) v5(46.53,182.28) v5(46.94,187.03) v5(47.09,214.13) v5(47.17,212.05) v5(47.24,180.04) v5(47.27,189.42) v5(47.35,183.8) v5(47.42,209.86) v5(47.4,207.6) v5(47.4,200.11) v5(47.42,193.74) v5(47.42,191.25) v5(47.47,205.27) v5(47.5,202.45) v5(47.5,198.23) v5(47.5,195.89) v5(48.31,182.81) v5(48.31,181.01) v5(48.26,178.6) v5(48.31,176.13) v5(48.41,206.49) v5(48.41,192.34) v5(48.41,190.13) v5(48.36,188.02) v5(48.44,185.45) v5(48.46,211.06) v5(48.46,208.62) v5(48.46,203.95) v5(48.46,201.33) v5(48.49,199.25) v5(48.49,196.99) v5(48.46,194.67)
V_CPU_VCCIO2PCH: length 105.5
  TOP w0.254: v4(126.93,83.94) 126.93,84.22 U29.C39
  TOP w0.508: v3(90.07,125.64) 90.07,133.23 v3(91.06,134.22)
  L3 w0.508: v3(84.61,157.05) 83.17,155.61 82.17,155.61 81.33,154.77 81.33,152.09 79.35,150.11 79.35,143.65 88.77,134.22 v3(91.06,134.22)
  L4 w0.508: v3(90.07,125.64) 92.94,125.64 115.51,103.07 115.51,96.82 121.16,91.17 121.16,89.13 123.44,86.84 v3(123.44,86.75)
  BOTTOM w0.508: R824.1 83.71,157.34 R826.2 v3(84.61,157.05) ; v3(123.44,86.75) 123.44,86.34 v2(124.08,85.71) 124.65,85.14 C579.1 125.48,83.74 C598.1 126.13,83.09 C599.1 127.07,83.79 v4(126.93,83.94)
V_CPU_VCCIO_OUT: length 28
  TOP w0.508: CPU1.L40 71.92,187.77 73.96,189.82 73.96,195.53 76.63,198.2 76.63,199.88 76.35,200.16 75.97,200.54 74.75,201.76 73.89,201.76 73.51,202.15 73.51,202.55 72.97,203.08 71.46,203.08 71.05,202.68 v3(68.58,202.68)
  BOTTOM w0.508: R773.2 67.79,201.99 68.48,202.68 v3(68.58,202.68) 68.58,203.69 v2(68.71,203.82)
V_CPU_VCCIO_RIGHT: length 123.4
  TOP w0.508: v3(52.86,231.91) v3(52.86,241.69) 53.72,242.55 53.72,245.4 52.63,246.5 v3(52.58,246.5) 51.43,245.35 48.61,245.35 47.5,246.46 v3(47.5,246.52) v3(46.23,246.52) 27.3,246.52 26.04,247.79 22,247.79 21.41,247.2 v3(21.36,247.2) ; v3(65.66,200.01) 65.53,200.14 v3(63.37,200.14) 63.37,200.65 v3(61.09,202.93) 61.09,208.36 62.87,210.14 63.03,210.14 R62.1 64.07,211.18 64.19,211.18 v3(64.19,211.96)
  BOTTOM w0.279: 52.5,235.95 52.86,235.59 XDPC1.43 v3(52.86,231.91) ; XDPC1.44 v3(52.86,241.69)
  BOTTOM w0.508: R645.1 v3(46.23,246.52) ; 52.5,235.95 48.74,235.95 48.2,235.41 48.2,226.98 53.09,222.08 54.4,222.08 54.42,222.09 55.31,222.09 56.44,220.97 56.44,220.93 v2(62.76,214.61) 64.19,213.19 v3(64.19,211.96) ; R767.1 v3(63.37,200.14) ; R629.1 C365.1 ; C365.1 20.54,245.51 21.03,246.01 21.03,246.04 21.34,246.35 21.34,247.18 v3(21.36,247.2) ; C365.1 20.32,244.52 R648.1 R649.1 ; R769.1 v3(61.09,202.93) 60.71,202.93 60.13,203.5 R749.1 ; R639.1 53.49,245.67 52.66,246.5 v3(52.58,246.5) ; R644.1 v3(47.5,246.52) ; R772.2 R773.1 R774.1 66.71,201.02 C411.1 v3(65.66,200.01)
V_SM: length 171.3
  TOP w0.203: DIMM2.87 150.29,159.5 v4(151.34,160.55) ; DIMM2.112 154.44,152 153.96,152.48 v4(153.96,152.51) ; v4(151.59,153.45) 151.59,153.65 151.21,154.03 149.26,154.03 DIMM2.105 ; DIMM1.93 165.44,157.7 v4(166.19,158.45)
  TOP w0.254: v4(151.74,150.89) 151.74,150.71 151.33,150.3 150.29,150.3 150.06,150.53 149.23,150.53 DIMM2.117 ; DIMM1.100 171.08,155.6 v4(170.92,155.43) ; v4(170.89,153.8) DIMM1.106 ; DIMM1.99 165.42,155.9 v4(165.79,156.27) ; DIMM2.88 158.84,159.2 159.51,159.88 159.51,160.25 v4(159.52,160.26) ; DIMM1.105 v4(162.56,154.1) ; v4(155.42,155.81) 155.52,155.71 157.29,155.71 DIMM2.100 ; v4(155.83,157.92) 156.35,157.4 DIMM2.94 ; v4(153.06,153.43) 151.93,152.3 DIMM2.111 ; DIMM2.81 150.05,161.3 152.13,163.38 v4(152.13,163.97) ; v4(155.91,154) 156.18,153.73 157.33,153.73 DIMM2.106
  TOP w0.305: DIMM2.76 156.44,162.8 154.74,164.5 v4(154.74,165.13) ; Q57.5 68.2,60.56 61.59,53.96 v3(61.59,53.32) ; v4(166.55,149.26) 165.99,148.7 DIMM1.123 ; 147.47,159.5 DIMM2.87 ; v4(99.27,160.81) 99.15,160.81 98.72,160.38 CPU1.AY12 ; DIMM1.111 166.94,152.3 167.92,151.32 v4(167.92,151.16) ; v4(94.37,164.5) 94.37,164.53 94.78,164.94 CPU1.AT17 ; v4(97.92,161.76) 97.92,161.77 98.36,162.21 CPU1.AY14 ; DIMM2.82 158.6,161 159,161.4 v4(159,162.54) ; DIMM1.88 171.18,159.2 171.18,159.2 v4(170.93,159.2) ; 147.3,155.9 147.39,155.99 147.48,155.9 DIMM2.99 v4(150.88,155.9) ; DIMM1.76 173.97,162.8 v4(174.04,162.87) ; DIMM1.75 162.67,163.1 162.05,162.48 v4(162.05,162.42) ; CPU1.AV11 97.02,159.06 97.02,159.06 v4(97.08,158.99) ; v4(170.89,161) DIMM1.82 ; DIMM1.112 v4(170.87,152) ; DIMM1.81 162.94,161.3 161.93,160.28 v4(161.93,160.13) ; 153.55,149.94 v4(153.55,149.96) ; 153.55,149.94 152.45,148.84 150.58,148.84 150.44,148.7 DIMM2.123 147.47,148.7 ; 153.55,149.94 153.55,149.71 154.38,148.88 155.75,148.88 156.18,148.45 157.35,148.45 DIMM2.124 ; CPU1.AJ13 88.34,161.29 v4(87.88,160.83) 88.34,160.38 CPU1.AJ12 ; 147.52,163.1 DIMM2.75 150.2,163.1 150.89,163.78 150.89,164.4 151.37,164.89 151.37,164.9 v4(151.55,165.07) ; CPU1.AU24 95.69,171.31 v4(96.12,170.89) 96.57,170.44 CPU1.AV23 ; v4(155.07,149.99) 155.29,150.2 DIMM2.118 159.88,150.2 v4(160.07,150.01) ; DIMM1.118 v4(170.71,150.2) ; 147.45,150.5 DIMM2.117 ; CPU1.AV8 96.17,154.05 v4(96.17,154.02) ; v4(95.23,162.7) 95.25,162.7 95.67,163.12 CPU1.AU15 ; DIMM1.117 166.9,150.5 168.07,149.33 v4(168.07,149.31) ; v4(96.19,165.39) 96.19,165.44 96.61,165.86 CPU1.AV18 ; v4(98.2,169.52) 98.2,169.43 97.48,168.71 97.4,168.71 97.12,168.43 97.12,168.42 96.85,168.15 96.15,168.15 CPU1.AU20 ; 147.45,161.3 DIMM2.81 ; 147.3,152.3 DIMM2.111 ; v4(170.92,148.73) 171.24,148.4 DIMM1.124 ; DIMM1.94 170.93,157.4 v4(170.92,157.41) ; CPU1.AW16 97.52,164 v4(97.09,163.56) ; v4(162.79,158.99) 163.3,159.5 DIMM1.87 ; v4(98.46,154.85) 98.36,154.94 98,154.94 97.52,155.42 CPU1.AY9 ; v4(146.59,157.46) 146.83,157.7 DIMM2.93 ; v4(94.32,169.94) 94.36,169.94 CPU1.AT22
  TOP w0.381: CPU1.AV13 96.62,161.29 v4(97.09,161.76) ; v4(95.19,156.78) 95.21,156.76 95.28,156.76 CPU1.AV10
  TOP w0.406: CPU1.AJ29 88.31,175.92 v3(87.86,175.48)
  TOP w0.508: R138.1 175.3,150.66 175.3,151.71 174.37,152.64 v4(174.14,152.64)
  BOTTOM w0.305: v3(61.59,53.32) 61.59,53.4 61.04,53.96 53.59,53.96 53.13,53.5 52.15,53.5 51.84,53.81 48.87,53.81 47.88,52.82 45.06,52.82 44.13,51.89 44.13,50.96 46.48,48.6 46.48,47.45 46.94,47 47.23,47 47.9,46.33 47.9,44.99 46.87,43.96 46.87,42.27 46.02,41.43 Q106.4
  vias: v1(128.65,116.32) v2(71.35,62.49) v2(87.96,189.54) v2(91.06,143.67) v2(132.33,121.98) v2(144.3,189.72) v3(85.83,175.43) v3(85.83,174.67) v3(85.83,173.4) v3(85.83,172.51) v3(85.83,171.37) v3(85.83,169.34) v3(85.83,168.57) v3(85.83,167.3) v3(85.83,165.85) v3(85.9,165.03) v3(85.9,164.14) v3(85.88,163.17) v3(85.88,162.41) v3(85.88,161.26) v3(85.88,160.5) v3(85.88,159.36) v3(85.88,158.47) v3(87.01,176.38) v3(87.01,175.46) v3(87.07,171.98) v3(87.26,170.89) v4(87.84,171.75) v4(87.89,169.07) v4(87.89,168.18) v4(87.87,165.42) v4(87.92,163.61) v4(87.92,154.94) v4(88.81,174.56) v4(88.86,171.81) v4(153.06,165.08) v4(156.21,165.13) v4(167.13,165.64) v4(170.36,165.06) v4(171.81,165.06) v5(72.21,63.9) v5(72.69,63.08) v5(73.12,63.89) v5(99.68,65.02) v5(100.59,65.02) v5(101.51,65.02) v5(125.68,107.71) v5(126.19,106.84) v5(126.72,107.71) v5(130.56,120.13) v5(131.24,118.81) v5(131.72,119.8) v5(131.93,117.97) v5(132.74,119.8) v5(132.84,117.97)
V_SM_1P5_EN: length 5.7
  TOP w0.102: R97.1 176.21,194.83 C48.1 R95.1 R90.2 175.45,197.72 v1(174.24,197.72)
V_SM_VTT: length 8.4
  TOP w0.305: DIMM2.204 156,124.4 155.5,123.9 v3(155.5,122.97) ; DIMM1.204 171.63,124.4 v4(171.04,123.81) ; DIMM1.203 164.2,123.69 164.34,123.55 v4(165.23,123.55) ; v3(147.68,124.98) 147.95,124.7 DIMM2.203
  vias: v2(146.56,120.51) v2(162.79,121.37)
V_VCC3P3_EN: length 7.4
  TOP w0.102: R577.2 133.58,30.43 C307.1 133.58,32.22 C306.1 v1(130.91,33.49) 128.75,33.49 Q78.4
V_VCC3P3_EN_R: length 8.3
  TOP w0.102: R576.2 133.07,29.44 R577.1 134.38,29.44 v1(134.65,29.7) 135.55,30.6 Q76.D 135.55,32.92 135.17,33.29 R552.1
V_VCC5_EN: length 7.2
  TOP w0.102: v1(134.19,26.25) 133.48,26.25 C341.1 131.75,25.74 C340.1 131.72,26.95 R593.2 131.38,27.29 129.72,27.29 129.39,27.62 Q82.4
V_VCC5_EN_R: length 39.7
  TOP w0.102: Q83.D 159,18.91 158.85,18.75 150.11,18.75 149.25,17.89 144.27,17.89 144.2,17.82 140.29,17.82 138.2,19.91 137.55,19.91 137.23,20.22 137.23,21.12 136.65,21.7 136.65,23.03 134.81,24.88 134.29,24.88 R601.1 134.77,25.79 134.77,27.52 134.62,27.67 v1(134.16,27.67) 133.66,27.67 133.02,27.03 R593.1 132.18,27.38 132.18,27.61 R584.2
V_VCCIOA_LOAD: length 10
  TOP w0.305: v3(74.21,151.32) CPU1.P4
  BOTTOM w0.305: v2(78.84,157.46) 78.46,157.08 77.39,157.08 R830.1 R831.1 75.62,156.35 75.62,155.89 75.41,155.68 75.36,155.68 74.3,154.61 74.3,151.41 v3(74.21,151.32)
VCTRL_VCC_EN: length 51.2
  TOP w0.102: Q79.D 164.57,22.49 165.48,21.57 165.48,19.26 Q83.G 163.83,18.24 163.83,18.52 162.68,19.67 161.54,19.67 161.16,20.05 v1(159.77,20.05) 158.5,20.05 157.56,19.11 149.89,19.11 149.02,18.25 143.92,18.25 142.85,19.31 142.85,19.57 142.16,20.27 137.69,20.27 137.59,20.37 137.59,21.27 137.32,21.54 137.32,29.35 137.45,29.49 Q76.G 137.83,31.13 138.43,31.73 138.43,32.31 R597.1 139.19,33.64 138.38,34.45 R553.2
VGA_BLUE: length 143.9
  TOP w0.102: R609.2 C345.1 36.73,21.74 L17.1 36.65,23.42 36.65,23.89 36.25,24.29 v3(36.25,24.62) ; R442.1 137.99,59.26 137.99,58.07 v1(137.58,57.66) 137.31,57.38 v3(137.31,56.83)
  TOP w0.178: U29.AC3 137.47,65.3 137.13,64.95 137.13,61.74 137.67,61.2 137.67,60.11 R442.1
  L4 w0.127: v3(36.25,24.62) 37.49,25.87 42.64,25.87 43.34,25.17 47.36,25.17 48.17,25.98 64.28,25.98 68.17,22.09 72.83,22.09 73.51,22.77 80.81,22.77 81.48,22.09 86.03,22.09 88.87,24.94 98.83,24.94 101.59,27.7 108.88,27.7 113.12,31.94 118.4,31.94 122.68,36.22 134.58,36.22 135.67,37.3 136.04,37.67 136.04,41.64 136.04,41.65 136.04,42.17 136.04,44.4 136.51,44.88 136.51,47.05 136.83,47.37 136.83,47.67 136.83,48.94 137.17,49.28 137.17,56.13 137.31,56.27 v3(137.31,56.83)
VGA_BLUE_C_L: length 4.8
  TOP w0.102: C346.1 34.42,21.49 v1(34.44,21.51) 34.47,21.54 34.47,22.12 L17.2 35.15,22.42 35.15,20.95 L20.1
VGA_CORE: length 0.7
  TOP w0.305: U13.AA12 83.55,84.51 v4(84.01,84.06)
  vias: v1(53.85,112.02) v2(52.96,112.12) v2(77.83,96.63) v4(77.22,90.64) v4(77.3,85.18) v4(77.25,83.88) v4(78.66,96.83) v4(79.22,88.77) v4(79.22,87.92) v4(79.32,96.78) v4(79.26,90.62) v4(79.27,87.06) v4(79.27,85.02) v4(80.28,84.05) v4(81.08,89.77) v4(81.08,88.81) v4(81.07,87.06) v4(81.23,90.8) v4(81.88,89.82) v4(82.03,86.08) v4(82.99,85.98) v4(83.09,88.7) v4(83.06,87.13) v5(52.07,118.65) v5(52.07,117.71) v5(52.07,116.49) v5(52.07,115.55) v5(52.07,114.21) v5(52.07,113.27) v5(53.09,118.65) v5(53.09,117.71) v5(53.09,116.49) v5(53.09,115.55) v5(53.09,114.21) v5(53.09,113.27) v5(54.23,118.27) v5(54.23,117.33) v5(54.74,116.37) v5(54.74,115.43) v5(54.74,114.08) v5(54.74,113.14) v5(55.75,116.37) v5(55.75,115.43) v5(55.75,114.08) v5(55.75,113.14) v5(77.24,89.85) v5(77.24,88.88) v5(77.22,86.98) v5(82.04,90.79)
VGA_CORE_PWR: length 74.9
  TOP w0.508: 42.77,110.64 PT4.1 ; PT4.1 42.77,112.75 ; PT4.1 41.72,111.69 ; PT4.1 43.83,111.69 ; 34.22,117.78 PL1.2 ; PL1.2 35.82,116.18 ; PL1.2 37.42,117.78 ; PL1.2 35.82,119.38 ; 41.74,119.52 PT3.1 ; PT3.1 43.85,119.52 ; PT3.1 42.8,118.46 ; PT3.1 42.8,120.57 ; PT1.1 43.85,127.39 ; PT1.1 42.8,126.34 ; PT1.1 41.74,127.39 ; PT1.1 42.8,128.45 ; PR27.1 v3(31.62,140.7)
  L3 w0.381: v3(31.62,140.7) 32.13,140.7 32.83,140 35.68,140 35.74,140.06 37.59,140.06 38.7,141.17 41.27,141.17 42.99,139.45 42.99,136.45 44.32,135.11 44.32,119.06 v3(43.33,118.07)
  BOTTOM w0.508: 42.8,126.34 PT1.1 ; PT1.1 41.74,127.39 ; PT1.1 42.8,128.45 ; PT1.1 43.85,127.39 ; 35.82,116.18 PL1.2 ; PL1.2 34.22,117.78 ; PL1.2 35.82,119.38 ; PL1.2 37.42,117.78 ; PT4.1 43.83,111.69 ; PT4.1 42.77,112.75 ; PT4.1 41.72,111.69 ; PT4.1 42.77,110.64 ; 41.74,119.52 PT3.1 ; PT3.1 43.85,119.52 ; PT3.1 42.8,120.57 ; PT3.1 42.8,118.46
  vias: v2(38.58,125.38) v2(39.45,116.01) v5(34.01,120.58) v5(33.99,118.98) v5(35.15,119.92) v5(35.46,115.53) v5(36.63,120.68) v5(36.78,119.54) v5(38.35,112.33) v5(39.55,110.91) v5(39.73,114.11) v5(39.93,112.53) v5(42.39,117.54) v5(42.37,115.88) v5(42.77,125.41) v5(42.77,124.01) v5(43.21,116.67)
VGA_DACREFSET: length 3.2
  TOP w0.102: v4(138.86,66.76) 138.64,66.53 U29.AF5
  BOTTOM w0.102: R990.1 139.72,66.13 138.88,66.13 138.74,65.98 v2(138.68,65.98) 138.66,66 138.66,66.56 v4(138.86,66.76)
VGA_DDC_PU: length 51.2
  L3 w0.406: v3(34.06,23.33) 34.06,19.49 34.52,19.03 34.52,18.35 34.88,17.99 35.45,17.99 36.22,17.23 v3(36.22,16.77)
  BOTTOM w0.406: U44.5 36.93,17.99 36.35,17.41 36.35,16.9 v3(36.22,16.77) 36.22,16.75 35.86,16.39 34.87,16.39 C726.1 33.89,16.41 R1116.1 33.88,17.28 33.6,17.56 32.48,17.56 31.52,18.52 31.52,19.43 R1115.1 ; v3(34.06,23.33) 34.06,24.3 36.03,26.27 41.63,26.27 43.79,24.11 49.15,24.11 v2(51.46,26.43) 55.37,30.34 56.77,30.34 56.87,30.44 59.25,30.44 59.35,30.34 60.48,30.34 60.56,30.26 61.67,30.26 D22.K
VGA_DET: length 200.5
  TOP w0.102: v3(152.77,78.32) 152.72,78.26 R361.2 152.62,77.36 151.12,77.36 150.11,78.37 147.3,78.37 147.19,78.47 145.77,78.47 145.49,78.76 U29.AV28
  L3 w0.127: v3(41.12,22.97) 41.78,22.31 41.78,19.92 43.27,18.43 43.27,17.07 44.33,16.01 46.7,16.01 49.04,13.67 VGA1.4
  L4 w0.127: v3(152.77,78.32) 153.73,77.37 153.73,71.73 155.78,69.68 155.78,66 155.14,65.36 153.51,65.36 153.07,64.92 153.07,59.45 151.73,58.1 151.73,54.2 151.73,54.2 151.73,53.93 151.73,53.5 150.67,52.45 150.67,50.76 151.5,49.94 151.5,46.25 152.93,44.81 152.93,31.76 v3(152.78,31.61) ; v3(137.46,32.14) 137.17,31.85 135.66,31.85 132.25,28.44 132.25,27.52 127.6,22.86 102.49,22.86 100.88,21.25 90.41,21.25 87.57,18.41 79.82,18.41 79.31,18.92 75.02,18.92 74.35,18.25 63.49,18.25 62.01,19.72 62.01,19.74 61.74,20.01 61.72,20.01 59.8,21.93 57.02,21.93 56.01,20.91 55.64,20.91 46.51,20.91 46.51,20.91 45.72,20.91 45.06,21.57 42.52,21.57 v3(41.12,22.97)
  BOTTOM w0.102: v3(137.46,32.14) 139.03,32.14 141.98,29.19 v2(147.27,29.19) 148.41,29.19 150.32,31.1 150.77,31.1 150.78,31.09 151.15,31.09 151.67,31.61 v3(152.78,31.61) ; U43.4 40.91,23.01 40.94,22.97 v3(41.12,22.97)
VGA_GREEN: length 152.9
  TOP w0.102: v3(138.35,57.03) 138.56,56.83 139.75,56.83 140.31,57.38 140.31,59.04 R444.1 ; L18.1 33.49,20.43 R605.2 C343.1 30.89,22.02 30.89,22.66 31.6,23.37 32.01,23.37 32.73,24.09 34.47,24.09 34.95,23.61 v3(36.14,23.61)
  TOP w0.178: R444.1 139.49,60.7 137.76,62.43 137.76,62.5 137.75,62.51 137.75,64.46 138.1,64.8 U29.AE2
  L4 w0.127: v3(36.14,23.61) 37,24.46 38.22,24.46 38.3,24.54 43.07,24.54 43.07,24.53 47.21,24.53 47.78,23.96 54.37,23.96 54.57,24.16 54.94,24.53 54.99,24.53 55.43,24.98 62.19,24.98 63.09,24.08 64.64,22.53 64.64,22.52 65.85,21.31 72.95,21.31 73.77,22.13 80.48,22.13 81.15,21.46 86.31,21.46 89.15,24.3 99.1,24.3 101.85,27.06 109.14,27.06 113.39,31.3 120.06,31.3 124.34,35.58 134.32,35.58 134.84,35.58 135.93,36.67 136.67,37.41 136.67,44.14 137.15,44.62 137.15,46.79 137.46,47.11 137.46,48.68 137.8,49.02 137.8,55.87 138.28,56.34 138.28,56.96 v3(138.35,57.03)
  BOTTOM w0.102: v2(35.28,23.33) 35.86,23.33 v3(36.14,23.61)
VGA_GREEN_C_L: length 4.4
  TOP w0.102: v3(29.88,19.96) 30.35,19.49 L21.1 31.56,20.38 C347.1 31.64,20.43 L18.2
  BOTTOM w0.102: v2(29.63,20.73) 29.63,20.22 v3(29.88,19.96)
VGA_HSYNC_3V: length 153.8
  TOP w0.102: L23.1 33.55,14.13 33.83,13.85 36.13,13.85 38.34,16.06 39.94,16.06 41.91,18.03 41.91,20.11 42.59,20.79 42.59,20.79 44,22.19 v3(46.02,22.19) ; U29.AH3 140,65.27 139.68,64.95 139.68,62.93 139.6,62.85 139.6,61.68 v1(139.7,61.58) 140.08,61.2 v4(140.55,61.2)
  L4 w0.127: v4(140.55,61.2) 140.8,60.94 140.8,59.09 141.31,58.58 141.31,54.64 140.89,54.22 140.89,51.89 140.6,51.59 140.6,48.98 141.23,48.35 141.23,46.88 140.11,45.75 140.11,41.65 140.45,41.31 140.45,40.08 139.98,39.61 139.98,39.03 139.56,38.62 139.56,36.69 139.42,36.56 139.42,35.57 136.46,32.61 135.35,32.61 131.49,28.76 131.49,27.84 127.28,23.63 102.18,23.63 100.57,22.02 90.1,22.02 87.26,19.17 80.21,19.17 79.53,19.85 74.78,19.85 73.95,19.02 64.9,19.02 64.79,19.13 62.35,21.57 62.35,21.59 61.25,22.69 56.71,22.69 56.55,22.54 56.23,22.54 55.88,22.19 55.41,21.73 55.37,21.73 55.32,21.68 46.83,21.68 46.31,22.19 v3(46.02,22.19)
VGA_PCH_DDCSCL: length 164.4
  TOP w0.102: v4(141.08,62.3) 141.2,62.42 U29.AL2 ; v3(42.98,19.85) 42.98,17.11 40.58,14.72 38,14.72 37.39,14.11 36.35,13.07 36.35,13.04 35.76,12.45 35.76,7.43 34.36,6.03 v3(33.15,6.03) 32.93,6.03 R626.2 32.37,7.14 U34.1
  L4 w0.127: v3(42.98,19.85) 42.98,20.14 44.02,21.18 44.95,21.18 45.46,20.66 46.4,20.66 46.41,20.66 55.74,20.66 56.43,20.66 57.45,21.68 59.7,21.68 60.27,21.1 60.27,20.11 62.39,17.99 73.94,17.99 75.17,16.76 78.88,16.76 80.24,18.12 88.19,18.12 91.07,21 100.99,21 102.6,22.61 127.7,22.61 132.51,27.42 132.51,28.33 135.77,31.59 137.58,31.59 140.77,34.78 140.77,37.36 140.5,37.64 140.5,38.48 140.74,38.72 140.74,39.29 141.21,39.76 141.21,41.93 140.87,42.27 140.87,45.44 141.99,46.56 141.99,49.63 141.99,49.63 141.99,50.06 141.99,50.06 141.99,53.25 142.08,53.34 142.08,59.89 141.64,60.32 141.64,61.7 141.08,62.26 v4(141.08,62.3)
VGA_PCH_DDCSDA: length 157.6
  TOP w0.102: U34.4 33.67,11.41 33.54,11.54 R623.2 33.54,11.95 34.23,12.63 34.61,12.63 34.86,12.38 35.37,12.38 35.92,12.93 35.92,12.96 36.15,13.2 36.15,13.2 37.16,14.2 37.16,14.2 37.9,14.94 40.22,14.94 42.52,17.24 42.52,20.04 42.79,20.3 42.81,20.3 43.89,21.38 v3(46.14,21.38) ; v1(141.22,60.66) 141.18,60.71 v4(141.18,61.53) 141.53,61.88 141.53,63.31 141.46,63.37 141.46,64.58 141.5,64.62 141.5,64.91 141.25,65.16 U29.AL3
  L4 w0.127: v3(46.14,21.38) 46.31,21.22 46.57,21.22 46.62,21.17 55.53,21.17 55.53,21.17 55.9,21.17 56.92,22.18 61.04,22.18 61.84,21.38 61.84,20.27 62.27,19.84 62.27,19.83 63.59,18.5 74.15,18.5 74.99,19.34 79.25,19.34 79.92,18.67 87.47,18.67 90.31,21.51 100.78,21.51 102.39,23.12 127.49,23.12 132,27.63 132,28.54 135.56,32.1 136.67,32.1 140.52,35.94 140.52,36.67 140.25,36.94 140.25,38.3 140.25,38.58 140.49,38.82 140.49,39.4 140.95,39.86 140.95,41.52 140.62,41.86 140.62,45.55 141.74,46.67 141.74,49.53 141.74,49.53 141.74,50.16 141.74,50.16 141.74,54.35 141.82,54.43 141.82,54.92 141.82,54.92 141.82,59.13 141.31,59.64 141.31,61.4 v4(141.18,61.53)
VGA_RED: length 141.1
  TOP w0.102: v3(139.04,57.51) 139.04,59.26 R443.1 ; L19.1 38.2,20.68 38.95,21.43 R606.2 C344.1 40.57,21.43 42.64,23.51 v3(42.64,24.07)
  TOP w0.178: R443.1 138.45,60.8 v1(138.3,60.94) 138.05,61.2 138.05,61.32 137.47,61.9 U29.AC2
  L4 w0.127: v3(42.64,24.07) 42.81,23.9 46.94,23.9 47.51,23.33 54.64,23.33 54.84,23.53 55.21,23.9 55.25,23.9 55.7,24.34 61.93,24.34 62.46,23.82 64,22.27 64,22.26 65.59,20.67 73.21,20.67 74.03,21.5 80.22,21.5 80.89,20.82 86.57,20.82 89.41,23.67 99.36,23.67 102.04,26.35 105.05,26.35 105.68,25.73 109.61,25.73 114.55,30.67 120.33,30.67 124.61,34.95 127.8,34.95 128.74,34.01 134.17,34.01 136.19,36.03 137.39,37.23 137.39,43.96 137.97,44.54 137.97,45.95 138.43,46.41 138.44,46.42 138.44,55.6 139.04,56.2 v3(139.04,57.51)
VGA_RED_C_L: length 3.5
  TOP w0.102: v1(35.89,21.5) 36.7,20.68 L19.2 36.92,20.66 L22.1 C348.1
VGA_VSYNC_3V: length 152.6
  TOP w0.102: L24.1 33.24,16.43 33.05,16.62 33.05,17.6 33.26,17.81 34.04,17.81 34.21,17.98 35.37,17.98 35.41,17.94 35.62,17.94 35.93,17.63 37.48,17.63 37.77,17.92 39.32,17.92 41,19.59 41,20.48 43.21,22.7 v3(44.68,22.7) ; v4(140.54,61.85) 140.38,61.85 139.8,62.43 139.8,62.76 139.88,62.84 139.88,64.72 U29.AH2
  L4 w0.127: v4(140.54,61.85) 140.13,61.44 140.13,59.05 140.8,58.37 140.8,54.85 140.39,54.43 140.39,52.1 140.09,51.81 140.09,48.77 140.68,48.18 140.68,47.05 139.57,45.94 139.57,42.22 139.04,41.68 139.04,39.03 139.05,39.02 139.05,36.9 138.92,36.77 138.92,35.78 136.25,33.12 134.97,33.12 130.59,28.74 117.61,28.74 113.02,24.15 101.46,24.15 99.83,22.52 89.89,22.52 87.05,19.68 80.42,19.68 79.74,20.35 74.51,20.35 73.68,19.53 65.11,19.53 64.82,19.82 62.86,21.78 62.86,21.8 61.46,23.2 56.5,23.2 56.34,23.05 56.02,23.05 55.67,22.7 55.63,22.7 55.11,22.18 47.04,22.18 46.52,22.7 v3(44.68,22.7)
  BOTTOM w0.102: v2(45.67,23.33) 45.67,22.94 45.37,22.64 44.74,22.64 v3(44.68,22.7)
VR_READY: length 496.2
  TOP w0.102: R55.1 60.71,214.36 59.99,215.07 59.99,217.59 60.58,218.17 61.18,218.17 R42.1 61.74,219.05 v3(60.3,220.48) ; v3(45.59,237.88) 37.85,245.63 26.87,245.63 25.43,247.08 v3(23.37,247.08)
  L3 w0.127: v3(99.47,72.68) 97.82,71.03 97.82,68.95 89.19,60.32 86.85,60.32 83.82,63.36 76.9,63.36 76.9,63.36 76.06,63.36 72.07,59.37 66.24,59.37 62.8,55.93 62.49,55.93 47.34,55.93 42.58,51.17 42.58,45.34 42.89,45.03 42.89,41.6 43.34,41.15 43.35,41.15 43.89,40.6 v3(43.89,38.86) ; v3(51.1,227.01) 48.03,230.08 48.03,235.44 v3(45.59,237.88)
  L4 w0.127: v3(60.3,220.48) 60.41,220.6 60.41,221.24 60.69,221.51 61.33,221.51 61.44,221.62 68.07,221.62 69.49,220.2 96.22,220.2 96.99,219.44 104.34,219.44 109,214.78 114.74,214.78 114.9,214.94 117.47,214.94 118.16,215.63 118.95,215.63 120.13,216.81 122.43,216.81 122.91,216.33 123.51,216.33 123.83,216.01 123.83,215.75 125.34,214.23 128.81,214.23 129.13,213.92 134.82,213.92 137.81,210.93 137.81,209.59 141.78,205.62 153.21,205.62 154.31,204.51 157.52,204.51 163.9,198.13 165.97,198.13 172.31,191.8 174.49,191.8 176.53,189.76 176.53,173.73 177.01,173.25 177.01,159.24 177.47,158.78 177.47,154.18 177.53,154.12 177.53,142.34 176.2,141.01 176.2,124.96 169.01,117.76 164.99,117.76 163.57,116.34 152.22,116.34 149.64,113.77 149.64,113.69 149.22,113.27 149.22,110.99 147.59,109.36 146.62,109.36 146.34,109.08 146.34,108.11 136.42,98.19 136.42,97.97 v3(135.65,97.21) 135.65,97.05 133.87,95.27 132.93,95.27 132.5,94.84 132.5,93.73 132.42,93.65 132.42,93.26 132.5,93.18 132.5,91.14 134.81,88.83 134.81,88.1 134.06,87.35 128.21,87.35 125.72,84.86 118.72,84.86 113.21,79.35 113.21,79.1 106.75,72.64 99.5,72.64 v3(99.47,72.68)
  BOTTOM w0.102: v3(135.65,97.21) 135.65,97.78 v2(135.41,98.03) 134.92,97.55 134.92,96.78 R887.1 ; Q89.C 3,238.27 3,245.25 6.35,248.6 22.15,248.6 23.37,247.38 v3(23.37,247.08) 23.37,246.87 22.96,246.47 22.96,244.62 R647.2 21.41,244.04 C370.2 21.07,243.69 21.07,243.51 20.64,243.09 20.64,242.92 19.39,241.66 18.92,241.66 18.65,241.39 U35.7 ; v3(60.3,220.48) 55.37,225.41 51.79,225.41 51.1,226.09 v3(51.1,227.01) R698.1 ; Q106.1 44.15,39.11 v3(43.89,38.86)
VR_TT#: length 2.1
  TOP w0.203: U9.4 41.6,143.71 TP8.1
VRAM1_VREFCA: length 7.6
  BOTTOM w0.178: R885.1 46.87,96.68 47.42,97.23 49.95,97.23 MEM3.M8
  BOTTOM w0.508: R885.1 R886.2 C529.1 v2(43.18,96.68)
VRAM1_VREFDQ: length 11.6
  BOTTOM w0.178: 57.07,98.91 55.96,100.01 MEM3.H1
  BOTTOM w0.508: 57.07,98.91 57.14,98.84 57.14,97.78 58.05,96.86 58.05,94.99 59.34,93.71 v2(59.56,93.71) 60.59,92.68 R928.1 61.78,92.68 R924.2 C559.1
VRAM2_VREFCA: length 18.9
  TOP w0.178: MEM1.M8 55.44,96.82 55.87,96.39 56.41,96.39 56.44,96.36 56.83,96.36 v4(57.26,96.79)
  TOP w0.508: v3(47.66,96.68) 47.25,96.68 47.24,96.68 R230.1 C163.1 R229.2 43.69,96.68 43.64,96.63 v1(43.18,96.63)
  L3 w0.178: v4(57.26,96.79) 57.24,96.79 56.81,96.36 56.81,96.36 56.57,96.12 55.38,96.12 52.96,98.54 52.42,98.54 52.13,98.82 51.38,98.82 51.11,98.56 50,98.56 49.02,97.58 48.56,97.58 v3(47.66,96.68)
VRAM2_VREFDQ: length 7.3
  TOP w0.178: 47.88,100.66 47.95,100.66 48.84,99.77 49.31,99.77 MEM1.H1
  TOP w0.508: 47.88,100.66 47.75,100.79 47.75,101.13 47.37,101.51 v1(47.32,101.51) R203.1 R202.2 C145.1 43.32,101.51 C835.1
VRAM3_VREFCA: length 14.9
  L3 w0.178: v3(47.84,82.02) 47.85,82.02 50.8,82.02 51.1,82.33 52.4,82.33 52.65,82.57 53.53,82.57 53.74,82.79 55.99,82.79 56.31,82.47 v4(56.56,82.47)
  BOTTOM w0.178: v4(56.56,82.47) 56.48,82.47 56.2,82.75 55.84,82.75 55.44,82.36 MEM4.M8
  BOTTOM w0.508: R957.1 45.91,81.63 C602.1 R951.2 46.82,82.7 v2(47.12,82.41) 47.5,82.02 v3(47.84,82.02)
VRAM3_VREFDQ: length 7.3
  BOTTOM w0.178: MEM4.H1 49.56,79.37 49.06,79.88 48.5,79.88 47.94,79.33 46.59,79.33 46.38,79.54 R959.1
  BOTTOM w0.508: v2(43.94,80.5) C608.1 R960.2 R959.1
VRAM4_VREFCA: length 7.1
  TOP w0.178: MEM2.M8 50.36,82.37 49.96,82.78 49.38,82.78 49.17,82.98 48.92,82.98 47.97,83.93 v1(46.99,83.93)
  TOP w0.508: v1(46.99,83.93) 46.75,83.69 R309.1 C199.1 R308.2
VRAM4_VREFDQ: length 19.4
  TOP w0.203: v4(56.73,83.09) 56.74,83.08 56.74,83.01 57.05,82.7 57.05,79.56 56.65,79.16 MEM2.H1
  L3 w0.178: v4(48.17,83.06) 48.17,83.53 48.95,84.31 49.04,84.31 49.17,84.44 52.66,84.44 52.69,84.47 53.68,84.47 54.85,83.3 56.52,83.3 v4(56.73,83.09)
  BOTTOM w0.508: R946.2 C588.1 R945.1 v2(46.99,83.73) 47.49,83.73 v4(48.17,83.06)
VRAM_ZQ1: length 5.5
  BOTTOM w0.102: R870.2 v2(46.16,97.65) 49,97.65 49.35,97.99 49.96,97.99 50.33,97.62 MEM3.L8
VRAM_ZQ2: length 16.7
  TOP w0.102: MEM1.L8 55.53,97.26 57.37,97.26 57.67,96.96 57.67,96.63 57.44,96.4 v4(57.44,94.71)
  L3 w0.127: v4(57.44,94.71) 57.35,94.8 52.47,94.8 52.43,94.76 49.58,94.76 49.45,94.89 49.45,94.9 49.21,95.15 49.13,95.15 49.11,95.17 48.35,95.17 v3(48,94.82)
  BOTTOM w0.102: R899.2 v2(47.19,94.72) 47.9,94.72 v3(48,94.82)
VRAM_ZQ3: length 17.8
  TOP w0.102: R299.2 v3(47.24,85.7)
  L3 w0.127: v3(47.24,85.7) 47.58,85.36 52.98,85.36 53.01,85.39 53.53,85.39 55.01,83.91 56.2,83.91 56.44,84.15 56.85,84.15 v3(57.56,83.44)
  BOTTOM w0.102: MEM4.L8 55.49,81.89 56.1,81.89 56.16,81.83 57.37,81.83 57.56,82.03 v3(57.56,83.44) 58.08,83.44 v2(58.46,83.06)
VRAM_ZQ4: length 4.7
  TOP w0.102: R320.2 47.04,82.52 v1(47.06,82.55) 48.11,82.55 48.66,81.99 49.93,81.99 MEM2.L8
VREF_1: length 4.5
  TOP w0.203: U16.41 184.52,88.41 v1(184.94,88.83)
  TOP w0.508: v1(184.94,88.83) 184.94,88.91 185.17,89.14 185.17,90.1 C179.1
VREG_PCIAUX_PCH: length 7.5
  TOP w0.254: v3(92.66,236.41) 91.77,235.52 v1(91.77,235.2) 91.45,234.88 R10.2 91.45,232.83 R13.1 93.14,232.81 Q3.D
  BOTTOM w0.254: Q128.C 92.66,237.28 v3(92.66,236.41)
VREG_PCIAUX_PCH_1: length 5.3
  TOP w0.254: Q4.G 92.83,230.79 PC1.2 91.44,230.79 C7.1 91.44,231.91 R13.2 v1(89.51,232.81)
VRP: length 31.3
  TOP w0.203: U16.38 183.03,87.21 183.26,86.98
  TOP w0.254: 183.26,86.98 183.26,84.87 v1(183.64,84.49) 183.87,84.26 184.93,84.26 185,84.32 186.6,84.32 187.43,83.5 C202.1 186.94,82.48 v3(186.94,80.57)
  L4 w0.254: TC17.1 171.32,88.17 173.99,85.51 180.9,85.51 183.62,82.79 184.78,82.79 186.94,80.63 v3(186.94,80.57)
VSUM_RC: length 2.6
  TOP w0.254: PR34.2 35.24,137.55 35.15,137.65 35.15,138.14 v1(34.89,138.4) 34.1,137.6 PC14.2
VSUM_RR: length 13.9
  TOP w0.254: PR42.2 35.48,134.34 35.48,133.24 36.8,131.92 36.8,130.69 36.32,130.2 36.32,129.12 36.75,128.69 v1(36.75,124.93) 36.75,122.04 PR51.1
VSYNC_3P3V: length 25.6
  TOP w0.102: L24.2 33.58,17.32 C353.1 34.96,15.94 36.27,15.94 37.39,17.05 38.04,17.05 v3(38.42,17.43)
  L3 w0.127: v3(38.42,17.43) 38.42,16.78 39.02,16.18 39.79,16.18 40.57,15.39 41.88,15.39 42.15,15.11 42.15,12.22 46.38,8 48.14,8 VGA1.14
  BOTTOM w0.102: v3(38.42,17.43) 39.17,18.19 39.17,18.56 39.56,18.95 U44.1
WAKE_N: length 464.6
  TOP w0.102: v4(141.24,82.45) 140.9,82.11 U29.AK34 ; U26.21 28.58,39.74 v3(28.83,39.99) ; v3(102.39,234.3) 102.08,233.99 102.08,229.33 104.74,226.68 R19.1 R20.2
  L3 w0.127: v3(36.07,18.61) 36.11,18.65 36.11,18.68 36.35,18.91 36.35,21.19 34.77,22.77 34.77,23.83 32.54,26.07 32.54,27.77 30.06,30.25 30.06,33.58 30.66,34.17 30.66,38.16 v3(28.83,39.99) ; v3(102.39,234.3) 102.46,234.22 105.2,234.22 106.43,232.99 108.14,232.99 111.51,229.63 113.42,229.63 115.06,227.98 115.06,224.97 118.18,221.85 118.39,221.85 118.45,221.79 153.67,221.79 155.13,220.33 155.13,217.51 154.48,216.86 154.48,206.6 168.26,192.82 171.04,192.82 173.1,190.76 173.1,190.07 173.81,189.37 174.29,189.37 175.06,188.6 175.06,164.99 173.6,163.53 173.6,145 174.25,144.34 174.25,128.57 174.3,128.53 174.3,128.14 174.25,128.09 174.25,126.36 173.77,125.88 173.77,122.98 170.37,119.57 168.95,119.57 165.55,119.57 159.98,113.99 156.91,113.99 155.83,112.91 155.83,108.51 156.14,108.2 156.14,98.72 153.47,96.05 v3(153.47,92.99)
  L4 w0.127: v3(36.07,18.61) 36.18,18.61 36.61,18.18 36.78,18.18 37.26,17.7 37.26,16.94 39.27,14.93 40.34,14.93 40.49,14.79 41.3,13.97 46.05,13.97 46.25,14.17 56.5,14.17 56.71,13.97 60,13.97 60.92,14.89 64.63,14.89 65.91,13.61 66.02,13.61 66.02,13.61 66.34,13.61 66.34,13.61 72.3,13.61 75.01,10.89 77.59,10.89 79.51,12.81 88.39,12.81 90.34,14.75 106.09,14.75 106.58,15.24 115.21,15.24 115.6,14.84 118.31,14.84 119.68,13.47 128.13,13.47 129.43,14.77 135.29,14.77 138.79,18.27 139.99,18.27 141.99,20.27 141.99,21.47 145.92,25.4 145.92,26.73 148.76,29.56 148.76,33.42 151.54,36.2 151.54,42.55 149.01,45.08 149.01,47.13 148.87,47.27 148.87,53.2 149.73,54.06 149.73,61.07 151.27,62.61 151.27,66.41 152.63,67.77 152.63,69.89 151.67,70.85 151.67,71.14 148.76,74.05 148.76,82.06 148.49,82.32 144.49,82.32 143.54,81.37 142.25,81.37 141.24,82.38 v4(141.24,82.45)
  BOTTOM w0.102: v3(153.47,92.99) 153.47,92.95 153.19,92.67 153.06,92.67 v2(152.81,92.41) 152.59,92.2 152.59,92.07 151.91,91.4 R920.1 151.89,91.17 151.46,90.74 150.66,90.74 148.84,88.91 147.15,88.91 146.76,88.52 142.97,88.52 141.63,87.17 141.63,83.58 141.64,83.57 141.64,82.85 v4(141.24,82.45)
WEA0#: length 38.9
  TOP w0.127: U13.G25 72.29,94.74 72.16,94.61 v4(72.16,94.37) ; v4(52.52,98.1) 52.33,97.91 51.28,97.91 51.16,97.79 MEM1.L3 ; v1(58.9,94.14) 58.9,94.95 v4(58.93,94.98)
  L3 w0.165: v4(58.93,94.98) 59.08,95.13 60.36,95.13 60.74,95.52 60.74,95.88 60.87,96.01 61.25,96.01 61.42,95.84 61.42,95.3 61.58,95.13 62.06,95.13 62.23,95.3 62.23,95.84 62.4,96.01 62.88,96.01 63.04,95.84 63.04,95.3 63.21,95.13 63.69,95.13 63.86,95.3 63.86,95.84 64.02,96.01 65.54,96.01 66.03,95.52 66.39,95.16 66.81,95.16 66.98,94.98 70.26,94.98 70.38,94.85 70.38,94.73 70.51,94.61 71.93,94.61 v4(72.16,94.37)
  L4 w0.165: v4(52.52,98.1) 52.82,98.1 52.92,98.19 53.39,98.19 54.01,97.58 54.25,97.58 54.46,97.37 54.46,97.13 54.65,96.94 54.79,96.94 55.15,97.3 55.33,97.3 55.5,97.14 55.5,96.96 55.09,96.56 55.09,96.38 55.27,96.2 55.45,96.2 55.93,96.68 56.11,96.68 56.29,96.5 56.29,96.32 56,96.03 56,95.25 56.13,95.12 56.77,95.12 56.91,95.26 56.91,96.2 57.02,96.31 57.24,96.31 57.36,96.19 57.36,95.3 57.49,95.17 57.93,95.17 58.06,95.31 58.06,96.63 58.19,96.76 58.52,96.76 59.39,95.89 59.39,95.11 59.26,94.98 v4(58.93,94.98)
  BOTTOM w0.127: v4(52.52,98.1) 52.6,98.18 53.81,98.18 MEM3.L3
