# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
L_AD0_R: length 18.6
  TOP w0.102: U29.AN24 142.25,76.87 v4(142.25,77.09) ; v3(157.1,75.68) 157.1,75.8 157.29,75.99 R372.2
  BOTTOM w0.102: v3(157.1,75.68) 156.72,75.68 v2(156.34,75.29) 156.08,75.04 149.99,75.04 148.09,76.93 143.51,76.93 143.26,76.68 142.66,76.68 v4(142.25,77.09)
L_AD1: length 170.6
  TOP w0.102: v3(139.83,40.37) 140.22,40.37 140.39,40.2 143.71,40.2 144.01,40.5 U22.23 U23.23 v3(144.01,43.62) ; R353.1 160.44,78.22 161.16,78.22 v3(161.29,78.09) 161.42,77.96 R355.1 ; v3(64.14,40.94) 64.14,41.07 64.02,41.18 U24.9
  L3 w0.127: v3(167.68,66.53) 167.68,66.07 167.55,65.94 167.55,61.49 159.83,53.77 153.49,53.77 153.16,54.1 150.31,54.1 145.15,48.94 145.15,48.35 145.11,48.32 145.11,44.54 144.2,43.62 v3(144.01,43.62) ; LPC1.7 129.09,38.4 129.95,37.55 131.35,37.55 131.69,37.21 131.69,37.09 132.17,36.61 134.58,36.61 136.37,38.4 139.08,38.4 139.44,38.76 139.7,38.76 139.98,39.03 139.98,40.22 v3(139.83,40.37)
  L4 w0.127: v3(64.14,40.94) 64.34,41.14 66.59,41.14 70.13,44.68 70.13,49.24 72.9,52.01 73.77,52.01 75.41,53.65 82.65,53.65 83.41,54.42 93.17,54.42 94.9,52.69 103.44,52.69 106.91,49.22 106.91,48.71 106.91,41.14 110.66,37.39 118.89,37.39 121.08,39.58 121.08,40.5 121.83,41.25 124.65,41.25 125.15,40.75 125.15,40.34 126.24,39.25 126.65,39.25 127.5,38.4 LPC1.7 ; v3(167.68,66.53) 167.69,66.53 167.69,67.53 167.51,67.7 166.09,67.7 165,68.79 165,74.38 v3(161.29,78.09)
L_AD1_R: length 17
  TOP w0.102: R353.2 157.49,79.11 v3(157.1,78.72) ; U29.AP26 143.26,78.11 v4(143.36,78.22)
  BOTTOM w0.102: v4(143.36,78.22) 143.36,78.22 143.69,77.89 151.94,77.89 152.5,77.33 155.7,77.33 156.24,77.86 ; v2(156.24,77.83) 156.24,77.86 ; 156.24,77.86 v3(157.1,78.72)
L_AD2: length 169
  TOP w0.102: v3(146.02,43.62) 145.96,43.56 U23.20 U22.20 145.96,40.59 146.15,40.4 146.15,39.46 145.47,38.77 144.03,38.77 143.5,38.24 142.34,38.24 141.6,38.97 139.76,38.97 v3(139.51,39.23) ; v3(64.14,41.77) 64.14,41.71 64.01,41.58 U24.10 ; R377.1 160.62,74.95 v3(161.04,74.53) 161.38,74.19 R378.1
  L3 w0.127: v3(139.51,39.23) 139.48,39.23 139.13,38.88 138.78,38.88 138.75,38.86 138.36,38.86 138.34,38.88 136.42,38.88 134.45,36.92 132.3,36.92 131.99,37.22 131.99,37.41 131.01,38.4 LPC1.9 ; v3(168.02,65.74) 168.02,61.53 159.96,53.46 153.21,53.46 152.88,53.79 150.44,53.79 145.71,49.06 145.71,44.27 146.02,43.95 v3(146.02,43.62)
  L4 w0.127: v3(64.14,41.77) 66.78,41.77 69.82,44.81 69.82,49.37 72.81,52.36 73.69,52.36 75.29,53.96 82.53,53.96 83.42,54.85 83.82,54.85 93.17,54.85 95.02,52.99 103.56,52.99 107.21,49.34 107.21,48.59 107.21,41.27 110.79,37.69 118.76,37.69 120.78,39.71 120.78,40.62 121.71,41.55 126.35,41.55 127.15,40.75 127.15,40.34 128.24,39.25 128.65,39.25 129.5,38.4 LPC1.9 ; v3(168.02,65.74) 167.22,65.74 167.09,65.87 166.88,65.87 166.82,65.81 166.43,65.81 166.15,66.08 166.15,66.34 164.01,68.48 164.01,71.56 v3(161.04,74.53)
L_AD2_R: length 20
  TOP w0.102: U29.AJ24 140.41,76.77 v4(140.73,77.09) ; R377.2 157.41,74.95 157.4,74.94 157.12,74.94 v3(157.1,74.91)
  BOTTOM w0.102: v3(157.1,74.91) 156.69,74.51 v2(154.05,74.51) 149.87,74.51 147.64,76.73 143.7,76.73 143.45,76.48 142.58,76.48 142.4,76.66 141.16,76.66 v4(140.73,77.09)
L_AD3: length 176.3
  TOP w0.102: R350.1 161.29,79.1 v3(161.16,78.98) 160.78,78.98 159.6,80.16 R347.1 ; v3(138.56,39.33) 139.22,38.67 141.27,38.67 141.99,37.96 143.61,37.96 144.15,38.49 146.86,38.49 147.91,39.54 U22.17 U23.17 147.91,44.25 147.88,44.28 147.88,44.46 146.84,45.5 v3(146.23,45.5) ; v3(64.11,42.53) 64.09,42.53 63.55,41.98 U24.11
  L3 w0.127: v3(168.4,66.79) 168.4,66.15 168.49,66.06 168.49,61.52 160.13,53.16 152.96,53.16 152.63,53.49 150.56,53.49 146.3,49.23 146.3,49.16 146.3,49.16 146.3,47.01 146.3,45.58 v3(146.23,45.5) ; LPC1.11 132.3,37.35 132.43,37.22 134.33,37.22 136.46,39.35 138.53,39.35 138.56,39.33 v3(138.56,39.33)
  L4 w0.127: v3(64.11,42.53) 67.11,42.53 69.52,44.94 69.52,49.5 72.69,52.66 72.94,52.66 73.56,52.66 75.16,54.26 82.4,54.26 83.29,55.15 83.7,55.15 83.7,55.15 83.95,55.15 93.29,55.15 95.15,53.3 103.69,53.3 107.52,49.47 107.52,48.46 107.52,41.39 110.92,38 117.72,38 121.58,41.86 128.04,41.86 129.45,40.45 129.45,40.04 129.95,39.55 130.39,39.55 131.54,38.4 LPC1.11 ; v3(168.4,66.79) 168.4,67.24 167.64,68.01 166.23,68.01 165.3,68.94 165.3,74.84 v3(161.16,78.98)
L_AD3_R: length 18.1
  TOP w0.102: R347.2 157.77,80.16 v3(157.1,79.49) ; U29.AN26 142.54,78.09 v4(142.71,78.26)
  BOTTOM w0.102: v4(142.71,78.26) 143.1,78.65 143.6,78.65 144.09,78.17 152.07,78.17 152.37,77.86 v2(154.81,77.86) 155.09,77.86 156.72,79.49 v3(157.1,79.49)
L_BKLTEN: length 4.3
  TOP w0.102: U29.AT2 143.63,64.56 143.63,63.39 143.94,63.08 144.04,63.08 v4(144.09,63.03)
  BOTTOM w0.102: TP146.1 143.23,63.84 143.97,63.1 144.02,63.1 v4(144.09,63.03)
L_FRAME_N: length 169.7
  TOP w0.102: v3(138.49,40.09) 138.67,39.91 143.81,39.91 144.66,40.76 U22.22 U23.22 144.66,44.56 144.02,45.2 v3(143.87,45.2) ; R367.1 161.33,76.27 v3(161.16,76.44) 160.15,76.44 159.55,77.03 R366.1 ; v3(64.14,43.29) 63.22,42.38 U24.12
  L3 w0.127: v3(143.87,45.2) 143.87,45.22 142.98,46.11 142.98,48.73 143.74,49.49 145.27,49.49 150.18,54.4 153.34,54.4 153.67,54.07 159.7,54.07 167.09,61.46 167.09,67.08 v3(167,67.17) ; LPC1.13 135.03,38.4 136.73,40.09 v3(138.49,40.09)
  L4 w0.127: LPC1.13 133.59,38.4 132.73,37.55 120.57,37.55 119.8,36.78 110.41,36.78 106.3,40.89 106.3,48.97 103.19,52.08 94.64,52.08 92.92,53.81 83.67,53.81 82.91,53.04 75.67,53.04 74.02,51.39 73.76,51.39 73.14,51.39 70.74,48.99 70.74,44.43 65.95,39.65 63.94,39.65 63.64,39.95 63.64,42.8 v3(64.14,43.29) ; v3(167,67.17) 166.19,67.17 164.69,68.66 164.69,72.91 v3(161.16,76.44)
L_FRAME_N_R: length 17.7
  TOP w0.102: v3(157.1,76.69) 157.44,77.03 R366.2 ; U29.AP24 143.02,76.87 v4(143.02,77.09)
  BOTTOM w0.102: v4(143.02,77.09) 143.08,77.15 148.63,77.15 v2(149.48,76.3) 150.36,75.42 155.64,75.42 156.91,76.69 v3(157.1,76.69)
L_PWRDWN_N: length 4.1
  TOP w0.102: U22.28 U23.28 140.76,43.23 140.27,43.72 R476.2 140.27,44.88 v1(140.59,45.2)
L_VDD_EN: length 3.6
  TOP w0.102: U29.AP1 143.28,62.82 143.89,62.21 TP28.1
LAN_1P05_OUT: length 0.3
  TOP w0.203: U26.24 27.08,38.37
  vias: v1(27.74,41.13)
LAN_DISABLE_N: length 265
  TOP w0.102: v3(140.77,98.84) 142.36,98.84 142.88,98.32 142.88,97.71 R225.1 R226.1 v1(145.86,97.2) 146.79,96.28 146.79,95.65 146.3,95.17 146.3,93.81 144.6,92.11 144.44,92.11 143.62,92.11 142.95,91.44 142.95,89.4 141.96,88.42 141.96,86.56 141.63,86.23 141.63,85.52 U29.AL40
  L4 w0.127: v3(140.77,98.84) 139.95,98.02 139.95,97.65 139.97,97.62 139.97,96.81 139.79,96.63 139.79,95.27 142.47,92.58 143.81,92.58 145.14,91.26 146.86,91.26 147,91.4 149.06,91.4 149.44,91.02 149.44,90.62 150.65,89.4 152.79,89.4 152.81,89.43 154.51,89.43 154.72,89.65 156.57,89.65 158.67,87.54 158.67,73.46 161.66,70.48 161.66,67.19 161.14,66.66 161.14,63.01 160.57,62.43 160.57,61.81 160.79,61.58 160.79,60.92 160.57,60.69 160.57,55.38 159.59,54.4 159.59,53.93 157.16,51.5 157.16,50.42 154.91,48.18 154.91,38.29 154.01,37.39 154.01,29.36 146.81,22.16 146.81,21.48 140.81,15.48 138.76,15.48 131.54,8.26 123.81,8.26 122.97,9.1 119.65,9.1 118.81,8.26 110.02,8.26 109.07,9.2 106.83,9.2 105.88,8.26 97.01,8.26 96.37,8.9 93.87,8.9 93.23,8.26 91.32,8.26 90.74,8.85 87.48,8.85 85.64,10.69 80.08,10.69 78.38,8.99 73.3,8.99 71.56,10.73 67.48,10.73 65.13,8.38 63.06,8.38 61.48,9.96 57.81,9.96 57.57,9.72 56.62,9.72 56.54,9.8 55.58,9.8 55.51,9.72 54.2,9.72 54.13,9.8 53.29,9.8 53.22,9.72 51.91,9.72 51.84,9.8 51,9.8 50.93,9.72 49.62,9.72 49.55,9.8 48.71,9.8 48.64,9.72 47.41,9.72 46.83,10.3 43,10.3 39.93,13.37 36.08,13.37 31.85,17.6 31.85,20.08 31,20.93 29.81,20.93 26.83,23.91 v3(25.77,23.91)
  BOTTOM w0.102: v3(25.77,23.91) 25.74,23.94 25.07,23.94 24.56,24.44 24.56,24.48 24.51,24.53 R1104.1
LAN_DISABLE_N_1: length 9.1
  BOTTOM w0.254: Q126.B 19.91,29.13 R1226.1 20.76,29.13 21.59,29.96 22.73,29.96 22.99,29.7 22.99,27.19 v2(22.78,26.98) 23.5,26.27 C716.1 R1104.2
LAN_DISABLE_N_2: length 8.8
  BOTTOM w0.254: R1090.2 24.48,29.89 Q114.B 23.83,30.54 21.41,30.54 20.89,30.02 R1226.2 v2(20.7,31.02) 20.27,31.02 19.94,30.69 18.58,30.69 Q126.C
LAN_DISABLE_N_3: length 11.4
  TOP w0.102: v3(21.74,28.38) 21.69,28.43 21.69,32.41 Q127.C
  BOTTOM w0.102: R1107.1 20.05,26.03 19.48,26.6 19.38,26.6 v2(18.92,27.06) 18.97,27.11 R1096.2 19.82,27.35 21.79,29.32 Q114.C 22.16,28.8 v3(21.74,28.38)
LAN_DISABLE_N_4: length 17
  TOP w0.102: Q80.G 30.68,25.16 v3(31.8,24.04)
  BOTTOM w0.102: v3(31.8,24.04) 31.45,24.04 v2(30.78,23.38) 29.9,22.49 23.05,22.49 21.29,24.25 21.29,24.99 PC72.2 21.03,25.14 R1107.2 C718.1
LAN_DISABLE_V3: length 5.3
  TOP w0.102: v1(20.17,34.05) 19.51,33.38 19.34,33.38 R1227.1 19.15,33.13 19.71,32.57 19.71,31.71 C863.1 19.99,31.2 20.46,30.73 Q127.B
LAN_LEDACT_R#: length 54.6
  TOP w0.254: v3(29.79,23.2) 29.79,21.92 29.13,21.26 29.13,18.25 29.82,17.56 29.82,14.89 29.22,14.3 22.01,14.3 16.44,8.73 16.43,8.73 15.86,8.16 15.86,8.14 15.46,7.75 RJ1.11 ; R524.2 23.9,44.84 v3(24.64,45.58)
  L3 w0.254: v3(29.79,23.2) 29.77,23.22 29.77,24.09 28.42,25.43 28.42,30.16 28.47,30.21 28.47,33.22 27,34.7 27,40.37 24.23,43.14 24.23,45.17 v3(24.64,45.58)
LAN_MDI0_DN: length 24.2
  TOP w0.089: U26.2 27.78,33.5 27.41,33.13 27.41,33 25.12,30.72 24.3,30.72 23.22,29.63 23.22,29.16 23.36,29.02 23.36,27.82 23.22,27.68 23.22,26.93 22.69,26.41 22.69,25.87 U28.1 22.69,25.51 22.69,23.29 22.18,22.78 17.94,22.78 16.45,21.28 16.45,20.05 15.88,19.48 15.88,18.8 RJ1.2
LAN_MDI0_DP: length 24.3
  TOP w0.089: RJ1.1 14.9,19.65 15.04,19.52 15.43,19.52 16.1,20.19 16.1,21.42 17.8,23.12 22.04,23.12 22.35,23.43 22.35,26.55 22.87,27.07 U28.6 22.87,29.78 24.16,31.06 24.98,31.06 27.06,33.15 27.06,33.27 27.38,33.59 U26.1
LAN_MDI1_DN: length 23.4
  TOP w0.089: U26.5 28.98,33.72 28.92,33.66 28.92,32.82 25.58,29.47 25.02,29.47 24.78,29.23 U28.4 24.78,27.76 25.27,27.26 25.27,23.94 22.92,21.58 19.45,21.58 18.91,21.04 18.91,19.98 18.37,19.43 18.31,19.4 18.3,19.4 18.24,19.37 18.2,19.25 RJ1.4
LAN_MDI1_DP: length 23.2
  TOP w0.089: U26.4 28.58,32.96 25.44,29.82 24.88,29.82 24.43,29.37 24.43,29.08 24.31,28.96 24.31,27.74 24.93,27.12 24.93,25.84 U28.3 24.93,25.54 24.93,24.08 22.78,21.92 19.31,21.92 18.57,21.18 18.57,20.12 18.16,19.71 18.08,19.67 17.96,19.71 RJ1.3
LAN_MDI2_DN: length 18.9
  TOP w0.089: U26.7 29.78,33.76 29.92,33.61 29.92,31.96 27.43,29.47 27.43,27.38 26.94,26.89 U30.1 26.94,23.84 24.02,20.92 24.02,20 23.45,19.43 23.32,19.37 23.32,19.37 23.28,19.25 RJ1.8
LAN_MDI2_DP: length 18.8
  TOP w0.089: U26.6 29.38,33.67 29.58,33.47 29.58,32.1 27.08,29.61 27.08,28.53 U30.6 27.08,28.24 27.08,27.52 26.59,27.03 26.59,26.39 26.42,26.21 26.42,25.1 26.59,24.92 26.59,23.99 23.67,21.07 23.67,20.14 23.24,19.71 23.16,19.67 23.04,19.71 RJ1.7
LAN_MDI3_DN: length 21.1
  TOP w0.089: RJ1.10 26.01,18.86 26.01,19.46 28.86,22.31 28.86,23.79 29.34,24.26 29.34,26.94 28.84,27.44 U30.4 28.84,29.19 31.62,31.98 31.62,32.57 32.09,33.04 32.09,34.92 31.76,35.25 31.53,35.25 31.5,35.28 U26.10
LAN_MDI3_DP: length 21
  TOP w0.089: U26.9 31.5,34.88 31.53,34.91 31.62,34.91 31.75,34.78 31.75,33.18 31.28,32.71 31.28,32.12 28.5,29.34 28.5,29.08 28.38,28.96 28.38,27.69 28.5,27.57 28.5,27.3 28.99,26.8 28.99,25.84 U30.3 28.99,25.54 28.99,24.41 28.52,23.93 28.52,22.45 25.9,19.83 25.79,19.72 25.74,19.67 25.56,19.49 25.32,19.49 25.06,19.75 RJ1.9
LAN_P5_CN: length 8.3
  L3 w0.254: RJ1.6 21.25,19.48 RJ1.5 17.98,22.75 v3(17.98,24.19)
  BOTTOM w0.254: C719.2 18.16,24.37 v3(17.98,24.19)
LAN_RSET: length 2.8
  TOP w0.102: U26.31 25.91,35.28 25.35,34.72 v1(25.2,34.72) R555.2
LAN_XTALI: length 10.3
  TOP w0.102: U26.28 25.35,36.48 24.89,36.94 v3(24.49,36.94) 23.5,36.94 23.11,37.32 R546.2 C288.1 22.23,37.82 22.23,37.07 21.97,36.81 21.29,36.81 X4.1
LAN_XTALO: length 7
  TOP w0.102: X4.3 21.9,35.82 22.69,35.02 C299.1 R546.1 23.29,36.1 23.72,35.67 v3(24.43,35.67) 24.64,35.67 25.1,36.13 25.58,36.13 25.63,36.08 U26.29
LANCLK_REQ_N: length 158.2
  TOP w0.102: R559.2 v1(37.74,33.08) 39.24,33.08 39.42,33.26 v3(39.5,33.26) ; R256.1 R255.1 135.61,92.74 135.61,91.85 134.98,91.21 134.98,89.67 136.06,88.58 v4(136.06,88.12) 136.55,87.64 136.55,86.4 136.49,86.34 136.49,85.58 136.6,85.46 136.6,85.02 136.3,84.72 U29.AA39
  L4 w0.127: v4(136.06,88.12) 133.73,85.79 127.62,85.79 125.93,84.1 119.57,84.1 114.35,78.88 114.35,76.97 108.35,70.96 102.88,70.96 102.42,71.42 87.41,71.42 86.98,70.99 86.97,70.99 84.51,68.52 76.29,68.52 75.73,67.97 70.77,67.97 70.77,67.97 66.69,63.89 60.68,63.89 60.34,64.23 42.65,64.23 32.37,53.96 32.37,45.31 33.35,44.33 33.35,41.34 34.72,39.97 34.72,37.66 39.13,33.26 v3(39.5,33.26)
LANCLK_REQ_U_N: length 7.1
  TOP w0.102: v1(35.36,31.99) 35.32,32.03 R559.1 34.75,33.65 34.12,33.65 33.53,34.23 33.53,34.78 32.23,36.08 U26.12
LDO_3D3V: length 1.1
  TOP w0.508: PG1.2 TP33.1
LDO_5V: length 21.5
  TOP w0.508: PC45.1 90.54,40.76 PR83.2 v3(89.66,40.19) ; v3(101.35,34.53) 101.57,34.53 101.67,34.63 101.78,34.63 102.06,34.91 R550.1
  L3 w0.508: v3(89.66,40.19) 90.25,39.61 v3(90.25,36.53) 92.18,34.6 101.04,34.6 101.12,34.53 v3(101.35,34.53)
  BOTTOM w0.508: PG6.2 91.16,37.4 v2(91.16,36.46) 90.32,36.46 v3(90.25,36.53)
LED_5VSB: length 3.2
  TOP w0.254: v3(117.83,41.36) 117.83,41.46 118.85,42.48 R1074.2 118.11,43.32 LED1.A
LED_V_5P0_A: length 3.1
  BOTTOM w0.254: R1087.2 123.85,29.3 124.21,28.94 v2(124.46,28.94) 124.71,28.94 125.27,29.5 LED2.A
LINE2-VREFO: length 5.5
  TOP w0.203: U16.29 178.72,85.55 178.66,85.48 178.66,83.95 178.37,83.65 177.93,83.65 v1(177.7,83.42) 177.48,83.2 R323.1 R336.1
LINEOUT-JD: length 178.1
  TOP w0.203: LOUT1.Q 81.22,3.73 82.04,2.9 168.15,2.9 169.29,4.05 169.29,51.37 172.11,54.19 172.11,54.97 172.11,54.97 172.11,57.03 174.14,59.06 174.14,62.69 174.14,62.69 174.14,63.44 174.14,65.16 175.77,66.79 176.2,66.79 v3(177.9,68.49) ; v1(182.93,80.43) 182.04,80.43 v3(182.02,80.45) 181.61,80.86 R331.1
  L3 w0.203: v3(182.02,80.45) 182.02,79.26 178.92,76.16 178.92,69.5 v3(177.9,68.49)
LINEOUT-L: length 198.2
  TOP w0.203: v3(177.19,66.86) 177.19,66.02 v1(175.43,64.26) 175.06,63.89 175.06,58.68 173.03,56.65 173.03,53.81 170.21,50.99 170.21,3.67 168.53,1.99 75.76,1.99 R624.1 ; U16.19 175.21,88.81 175.01,89.01 v3(174.24,89.01)
  L3 w0.203: v3(177.19,66.86) 177.11,66.94 177.11,69.07 176.68,69.5 176.68,71.59 177.09,71.99 177.09,78.62 179.55,81.09 180.05,81.59 180.05,83.98 178.1,85.94 176.78,85.94 176.23,86.5 176.23,87.51 175.29,88.45 174.8,88.45 v3(174.24,89.01)
LINEOUT-R: length 197.5
  TOP w0.203: v3(173.41,88.99) 173.94,89.52 174.5,89.52 174.55,89.47 174.56,89.47 174.69,89.34 175.14,89.34 175.27,89.21 U16.18 ; R625.1 71.52,7.21 76.28,2.45 168.34,2.45 169.75,3.86 169.75,51.18 172.57,54 172.57,56.84 174.6,58.87 174.6,64.47 v1(175.77,65.64) 176.35,66.23 v3(176.63,66.23)
  L3 w0.203: v3(173.41,88.99) 174.41,87.99 174.94,87.99 175.77,87.16 175.77,86.31 176.62,85.45 177.93,85.45 179.53,83.86 179.53,81.71 179.1,81.28 176.89,79.07 176.63,78.81 176.63,72.18 176.23,71.78 176.23,69.31 176.63,68.91 v3(176.63,66.23)
LINEOUT_C-L: length 4
  TOP w0.203: L25.1 70.38,10.54 70.1,10.27 v3(70.1,10.26) 70.1,8.54 R624.2
  BOTTOM w0.203: v3(70.1,10.26) v2(70.1,11.16)
LINEOUT_C-R: length 3.9
  TOP w0.203: L26.1 71.37,11.04 v3(71.37,9.34) 71.37,8.41 R625.2
  BOTTOM w0.203: v3(71.37,9.34) v2(71.37,10.16)
LINEOUT_CON-L: length 12.7
  TOP w0.203: LOUT1.4 76.52,17.85 74.15,15.48 72.14,15.48 v3(71.12,14.46) 70.65,13.99 Q85.1 69.34,13.24 C355.1 69.89,12.11 69.93,12.07 L25.2
  BOTTOM w0.203: v3(71.12,14.46) v2(71.12,13.57)
LINEOUT_CON-R: length 18
  TOP w0.203: LOUT1.1 77.02,10.2 78.61,11.79 v3(78.61,13.83) 77.47,14.97 73.04,14.97 Q85.2 72.06,13.24 72.52,12.79 C356.1 72.48,12.07 L26.2
  BOTTOM w0.203: v3(78.61,13.83) v2(79.5,13.83)
LINK_ACTIVITY_N: length 10.3
  TOP w0.254: D8.K 23.39,42.53 R524.1 ; R524.1 C282.1 ; R524.1 23.67,41.79 23.67,40.52 v1(23.88,40.32) 23.88,37.93 24.18,37.63 25.02,37.63 25.77,36.88 U26.27
LMV393IN+: length 4.5
  TOP w0.152: U46.1 22.14,145.95 22.73,146.54 23.44,146.54 v1(23.59,146.69) 23.59,145.78 R1142.2 R1143.2
LMV393IN-: length 4.8
  TOP w0.152: R1157.1 20.84,146.85 U46.3 20.81,145.36 20.43,145.36 19.61,146.19 v1(19.41,146.19) 19,145.78 R1141.2
LPC_DRQ1_N: length 9.4
  TOP w0.102: v4(141.38,78.3) 141.12,78.05 U29.AK26
  BOTTOM w0.102: R962.1 145.77,78.6 TP127.1 145.14,79.23 144.02,79.23 143.71,78.93 142,78.93 v4(141.38,78.3)
LPC_PME_N: length 143.5
  TOP w0.102: R277.2 139.83,90.45 v4(139.83,90.15) 138.94,89.26 138.94,88.55 139.24,88.25 139.24,86.08 139.22,86.06 139.22,85.7 139.44,85.48 U29.AG40 ; U24.75 45,46.38 43.7,47.68 43.02,47.68 42.92,47.58 41.41,47.58 39.64,49.35 v1(39.64,51.49) 39.95,51.8 39.95,54.49 38.17,56.27 36.8,56.27 v3(36.7,56.37)
  L4 w0.127: v3(36.7,56.37) 36.7,56.91 42.73,62.94 54.69,62.94 56.1,61.53 67.46,61.53 72.96,67.03 76.12,67.03 76.68,67.58 84.9,67.58 87.25,69.94 94.83,69.94 95,69.77 108.84,69.77 116,76.93 116,78.83 119.67,82.51 123.77,82.51 124.42,83.16 127.25,83.16 128.13,84.04 129.2,84.04 129.27,83.97 129.79,83.97 131.15,85.33 135.13,85.33 136.75,86.95 136.75,87.23 139.68,90.15 v4(139.83,90.15)
LVDS_BL_ADJ: length 6.2
  TOP w0.165: R171.2 16.57,118.73 R170.2 R168.1 v1(15.62,120.63) R167.1 R169.1
LVDS_DET_A*: length 171.9
  TOP w0.102: v3(119,214.23) 118.68,213.92 R32.2 118.24,210.61 118.24,209.28 119.1,208.42 121.36,208.42 123.04,206.74 124.28,206.74 126.62,204.4 126.62,203.39 127.41,202.6 127.41,192.82 125.63,191.04 125.63,124.9 125.9,124.63 125.96,124.57 v3(125.96,123.89) ; LVDS1.14 v3(140.12,220.1) ; v4(127.34,89.35) 127.34,89.08 129.3,87.13 130.62,87.13 130.9,86.86 130.9,86.46 130.84,86.41 130.84,85.63 130.7,85.49 130.61,85.4 U29.L40
  L4 w0.127: v4(127.34,89.35) 129.82,91.83 129.82,93.74 130.59,94.51 130.59,98.33 130.59,98.33 130.59,98.65 132.7,100.76 132.7,101.42 133.39,102.11 133.39,107.81 133.64,108.07 133.64,112.02 124.73,120.94 124.73,122.96 125.65,123.89 v3(125.96,123.89)
  BOTTOM w0.102: v3(140.12,220.1) 139.33,220.89 v2(138.77,220.89) 138.75,220.87 129.95,220.87 127.25,218.17 125.14,218.17 123.51,216.54 120.37,216.54 119,215.18 v3(119,214.23)
LVDS_DET_B*: length 166.4
  TOP w0.102: U29.H41 129.23,85.96 126.79,88.41 126.33,88.41 v3(125.81,88.93) ; R44.2 131.97,217.56 Q129.D 130.77,217.97 130.77,218.72 130.12,219.36 130.12,219.67 v3(129.9,219.9) ; v3(115.82,213.22) 115.98,213.22 116.08,213.11 116.08,209.03 116.53,208.58 116.53,208.57 117.11,208 117.12,208 120.5,204.61 123.31,204.61 124.48,203.43 124.48,202.5 125.27,201.72 125.27,193.7 123.34,191.77 123.34,122.84 v3(123.52,122.67)
  L4 w0.127: v3(125.81,88.93) 125.81,89.82 125.16,90.47 125.16,91.1 124.33,91.93 124.33,97.9 128.09,101.66 128.09,105.86 130.51,108.28 131.2,108.28 132.12,109.19 132.12,112.26 131.85,112.52 131.85,112.74 123.95,120.64 123.95,122.23 v3(123.52,122.67)
  BOTTOM w0.102: v3(115.82,213.22) 115.87,213.27 116.24,213.27 116.47,213.5 116.95,213.5 117.18,213.27 119.02,213.27 119.51,213.75 119.51,213.94 119.68,214.11 119.68,215.06 119.94,215.31 119.94,215.79 120.46,216.32 124,216.32 v2(125.35,217.66) 127.21,217.66 129.45,219.9 v3(129.9,219.9)
LVDS_DET_B_R: length 15
  TOP w0.102: Q129.G 129.81,216.04 C869.1 129.26,217.13 130.1,217.97 v1(130.1,218.53) 130.1,218.7 129.64,219.16 129.64,219.5 129.44,219.71 129.44,220.09 129.45,220.1 129.45,222.22 128.95,222.72 124.53,222.72 124.12,222.31 LVDS1.30
LVDS_PU_4: length 3.7
  TOP w0.102: LVDS1.27 127.12,220.71 127.31,220.52 v3(127.31,220.11) 127.09,219.89 R43.2
  BOTTOM w0.102: v2(127.51,219.19) 127.51,219.92 v3(127.31,220.11)
LVDS_PU_5: length 4.9
  TOP w0.102: LVDS1.26 128.12,220.27 127.56,219.71 127.56,218.99 128.12,218.42 v1(128.12,218.14) 127.97,217.99 R46.2
LVDS_PU_6: length 3.7
  TOP w0.102: R1120.2 128.66,218.87 v1(128.12,219.41) 128.12,219.77 129.12,220.77 LVDS1.25
LVDS_PU_24: length 7.3
  TOP w0.102: v1(152.22,217.51) 151,218.73 R45.2 150.15,219.59 148.13,219.59 147.64,220.08 147.64,220.4 147.12,220.91 LVDS1.7
M1_SMB_CLK: length 5.6
  TOP w0.102: R14.2 106.12,230.87 106.76,231.5 v1(107.44,231.5) 108.45,231.5 109,232.05 NGFF1.60
M1_SMB_DATA: length 5.4
  TOP w0.102: R12.2 106.12,231.89 v1(106.25,232.01) 106.43,232.19 108.64,232.19 108.99,232.55 NGFF1.58
M_CAS_A_N: length 82.2
  TOP w0.216: CPU1.AU9 94.85,155.43 v4(95.24,155.82) ; v4(165.71,151.14) 165.67,151.1 DIMM1.115
  L3 w0.292: v4(165.71,151.14) 164.18,151.14 162.05,149.02 159.32,149.02 158.09,147.79 158.09,146.16 157.64,145.71 144.09,145.71 132.86,156.94 96.36,156.94 v4(95.24,155.82)
  BOTTOM w0.216: v2(164.64,151.52) 165.33,151.52 v4(165.71,151.14)
M_CAS_B_N: length 81.3
  TOP w0.216: v4(93.44,163.53) 92.95,164.02 CPU1.AP16 ; v4(151.02,150.89) 150.81,151.1 DIMM2.115
  L4 w0.102: v4(93.44,163.53) 93.83,163.14 93.83,162.5 94.16,162.17 96.34,162.17 96.39,162.21 98.41,162.21 98.63,162.44
  L4 w0.292: v4(151.02,150.89) 150.99,150.86 148.74,150.86 148.03,150.15 148.03,150.14 147.15,149.25 146.37,149.25 146.14,149.48 146.14,149.92 145.84,150.22 138.9,150.22 138.61,149.93 138.61,149.45 138.32,149.16 137.73,149.16 137.44,149.45 137.44,149.93 137.15,150.22 136.56,150.22 136.27,149.93 136.27,149.45 135.98,149.16 135.4,149.16 135.1,149.45 135.1,149.93 134.81,150.22 134.24,150.22 133.94,149.93 133.94,149.5 133.65,149.21 133.07,149.21 132.78,149.5 132.78,149.93 132.48,150.22 131.9,150.22 131.61,149.93 131.61,149.5 131.31,149.21 130.73,149.21 130.44,149.5 130.44,149.93 130.15,150.22 129.56,150.22 129.27,149.93 129.27,149.5 128.98,149.21 128.39,149.21 128.1,149.5 128.1,149.93 127.81,150.22 127.23,150.22 126.93,149.93 126.93,149.5 126.64,149.21 126.06,149.21 125.77,149.5 125.77,149.93 125.47,150.22 124.89,150.22 124.6,149.93 124.6,149.5 124.3,149.21 123.72,149.21 123.43,149.5 123.43,149.93 123.14,150.22 122.55,150.22 122.26,149.93 122.26,149.5 121.97,149.21 121.38,149.21 121.09,149.5 121.09,149.93 120.8,150.22 120.22,150.22 119.92,149.93 119.92,149.5 119.63,149.21 119.05,149.21 118.75,149.5 118.75,149.93 109.08,159.6 107.54,159.6 104.74,162.4 98.68,162.4 98.63,162.44
  BOTTOM w0.216: v4(151.02,150.89) 150.24,150.12 150.24,149.88 v2(150.21,149.85)
M_DATA_A0: length 114.1
  TOP w0.14: v4(166.5,186.95) 166.04,186.5 DIMM1.5 ; CPU1.AD38 83.37,184.59 v4(83.37,184.61)
  L3 w0.102: 83.51,187.98 83.69,187.79 83.69,186.45 83.37,186.13 v4(83.37,184.61)
  L3 w0.191: 83.51,187.98 83.37,188.12 83.37,192.48 83.37,193.19 92.95,202.78 93.46,203.29 110.31,203.29 111.82,201.78 112.09,201.78 112.5,202.19 112.77,202.19 113.04,201.92 113.04,201.65 112.62,201.24 112.62,200.97 112.89,200.7 113.16,200.7 113.57,201.11 113.84,201.11 114.11,200.84 114.11,200.57 113.7,200.16 113.7,199.89 113.97,199.62 114.24,199.62 114.65,200.03 114.92,200.03 115.19,199.76 115.19,199.49 114.78,199.08 114.78,198.81 115.05,198.54 115.32,198.54 115.73,198.96 116,198.96 116.27,198.69 116.27,198.42 115.86,198.01 115.86,197.74 116.23,197.37 116.84,197.37 117.3,196.91 117.3,196.3 119.04,194.55 158.91,194.55 166.5,186.97 v4(166.5,186.95)
  BOTTOM w0.14: v2(166.37,185.23) 166.37,186.55 166.5,186.67 v4(166.5,186.95)
M_DATA_A1: length 112.7
  TOP w0.14: v4(167.93,186.9) 167.93,186.76 167.07,185.9 DIMM1.7 ; v4(83.26,187.39) 83.87,187.39 84.19,187.06 84.19,185.45 CPU1.AD39
  L3 w0.191: v4(167.93,186.9) 167.42,187.41 167.07,187.41 159.52,194.96 120.57,194.96 120.07,195.46 119.8,195.46 119.59,195.24 119.32,195.24 119.05,195.51 119.05,195.78 119.27,195.99 119.27,196.26 119,196.53 118.73,196.53 118.51,196.32 118.24,196.32 117.97,196.59 117.97,196.86 118.19,197.07 118.19,197.34 112.37,203.16 111.84,203.69 93.29,203.69 92.78,203.18 82.96,193.36 82.96,192.31 82.96,192.31 82.96,187.69 v4(83.26,187.39)
  BOTTOM w0.14: v2(167.77,187.94) 167.93,187.78 v4(167.93,186.9)
M_DATA_A2: length 114.2
  TOP w0.14: DIMM1.15 165.17,183.5 165.22,183.45 165.87,183.45 166.45,184.03 v4(166.45,184.11) ; CPU1.AF38 86.04,184.56 86.11,184.56 v4(86.14,184.59)
  L3 w0.102: 85.91,188.01 85.91,187.79 85.68,187.56 85.68,185.2 86.14,184.74 v4(86.14,184.59)
  L3 w0.191: 85.91,188.01 85.91,192.2 94.5,200.78 105.55,200.78 106.77,199.56 107.04,199.56 107.8,200.32 108.07,200.32 108.34,200.05 108.34,199.78 107.58,199.02 107.58,198.76 107.85,198.49 108.12,198.49 108.88,199.25 109.15,199.25 109.42,198.98 109.42,198.71 108.66,197.95 108.66,197.68 108.93,197.41 109.19,197.41 109.95,198.17 110.22,198.17 110.49,197.9 110.49,197.63 109.73,196.87 109.73,196.6 110,196.33 110.27,196.33 111.03,197.09 111.3,197.09 111.57,196.82 111.57,196.55 110.81,195.79 110.81,195.52 114.35,191.99 156.96,191.99 157.6,191.34 164.56,184.39 166.17,184.39 v4(166.45,184.11)
  BOTTOM w0.14: v2(164.72,183.81) 165.07,183.45 165.87,183.45 166.45,184.03 v4(166.45,184.11)
M_DATA_A3: length 112.1
  TOP w0.14: CPU1.AF39 85.64,185.1 v4(85.21,185.53) ; v4(167.87,183.83) 167.36,183.32 166.32,183.32 165.9,182.9 DIMM1.17
  L3 w0.102: 85.47,187.84 85.47,185.8 v4(85.21,185.53)
  L3 w0.191: 85.47,187.84 85.47,192.33 94.33,201.19 107.99,201.19 112.49,196.68 112.49,196.41 111.63,195.55 111.63,195.28 111.9,195.01 112.17,195.01 112.81,195.65 113.12,195.65 113.35,195.43 113.35,195.11 112.71,194.47 112.71,194.2 112.98,193.93 113.25,193.93 113.9,194.58 114.21,194.58 114.44,194.36 114.44,194.04 113.79,193.39 113.79,193.12 114.51,192.4 157.12,192.4 157.76,191.76 164.72,184.79 166.92,184.79 167.87,183.84 v4(167.87,183.83)
  BOTTOM w0.14: v4(167.87,183.83) 167.87,184.21 v2(168.22,184.57)
M_DATA_A4: length 114.6
  TOP w0.14: DIMM1.4 170.97,186.8 170.89,186.88 v4(170.87,186.88) ; CPU1.AD37 83.38,183.67 v4(83.38,183.7)
  L3 w0.102: 82.94,184.85 82.94,184.13 v4(83.38,183.7)
  L3 w0.191: v4(170.87,186.88) 170.81,186.93 170.81,186.99 169.58,188.22 167.5,188.22 160.18,195.54 159.95,195.78 120.9,195.78 113.18,203.5 112.17,204.5 92.95,204.5 92.71,204.27 92.71,204.27 82.04,193.59 82.04,186.47 82.51,186 82.65,186 82.95,185.7 82.95,184.85 82.94,184.85
  BOTTOM w0.14: v4(170.87,186.88) 171.3,187.31 v2(171.83,187.31)
M_DATA_A5: length 112.2
  TOP w0.14: DIMM1.6 170.22,186.2 169.42,187 v4(169.42,187.05) ; v3(83.23,186.63) 83.81,186.06 CPU1.AD40
  L3 w0.191: v3(83.23,186.63) 83.05,186.81 83.05,186.88 82.55,187.38 82.55,192.14 82.55,193.53 93.12,204.1 112.01,204.1 112.77,203.33 120.73,195.38 159.78,195.38 167.33,187.82 169.21,187.82 169.42,187.61 v4(169.42,187.05)
  BOTTOM w0.14: v2(169.93,189.03) 169.42,188.51 v4(169.42,187.05)
M_DATA_A6: length 115.4
  TOP w0.14: v4(170.19,183.75) 170.32,183.75 170.87,183.2 DIMM1.16 ; CPU1.AF37 85.64,183.45 85.8,183.61 86.05,183.61 v4(86.08,183.63)
  L3 w0.102: v4(86.08,183.63) 85.71,184 85.71,184.67 85.39,185 84.55,185 84.36,185.19
  L3 w0.191: v4(170.19,183.75) 170.19,183.76 168.92,185.02 168,185.02 167.4,185.62 165.05,185.62 164.26,186.41 164.26,187.34 158.36,193.24 118.53,193.24 114.92,196.85 114.65,196.85 114.21,196.4 113.94,196.4 113.67,196.67 113.67,196.94 114.11,197.38 114.11,197.65 113.85,197.92 113.58,197.92 113.13,197.48 112.86,197.48 108.34,202 93.99,202 84.65,192.66 84.65,187.75 84.36,187.46 84.36,185.19
  BOTTOM w0.14: v2(172.21,183.71) 171.68,184.25 170.68,184.25 v4(170.19,183.75)
M_DATA_A7: length 112
  TOP w0.14: v4(168.66,183.85) 169.91,182.6 DIMM1.18 ; CPU1.AF40 85.64,187.06 85.43,187.26 v4(84.83,187.26)
  L3 w0.191: v4(84.83,187.26) 85.06,187.49 85.06,192.49 94.16,201.6 108.16,201.6 114.36,195.39 114.75,195.39 115.13,195.76 115.39,195.76 115.66,195.49 115.66,195.23 115.17,194.73 115.17,194.46 115.44,194.19 115.71,194.19 116.2,194.69 116.47,194.69 116.74,194.42 116.74,194.15 116.25,193.65 116.25,193.39 116.52,193.12 116.79,193.12 117.28,193.61 117.55,193.61 118.33,192.83 119.73,192.83 158.14,192.83 163.86,187.12 163.86,186.24 164.89,185.2 167.24,185.2 167.83,184.62 167.89,184.62 v4(168.66,183.85)
  BOTTOM w0.14: v2(169.44,182.76) 169.41,182.79 169.41,183.22 168.78,183.85 v4(168.66,183.85)
M_DATA_A8: length 105.9
  TOP w0.14: v4(87.05,186.52) 87.47,186.1 CPU1.AH40 ; v4(166.55,182.1) 166.07,181.63 165.38,181.63 165.31,181.7 DIMM1.21
  L3 w0.102: 87.13,187.34 87.05,187.26 v4(87.05,186.52)
  L3 w0.191: v4(166.55,182.1) 166.09,182.56 164.53,182.56 156.41,190.69 142.2,190.69 142.01,190.5 142.01,189.61 141.82,189.42 141.44,189.42 141.25,189.61 141.25,190.5 141.06,190.69 140.68,190.69 140.49,190.5 140.49,189.61 140.3,189.42 139.92,189.42 139.73,189.61 139.73,190.5 139.54,190.69 136.88,190.69 135.41,189.21 115.05,189.21 104.89,199.37 95.11,199.37 87.13,191.39 87.13,191.05 87.13,187.34
  BOTTOM w0.14: v4(166.55,182.1) 166.19,181.75 166.19,181.75 166.07,181.63 164.79,181.63 v2(164.49,181.93)
M_DATA_A9: length 106.3
  TOP w0.14: v4(87.05,185.53) 87.47,185.11 CPU1.AH39 ; DIMM1.23 166.89,181.1 v4(167.97,182.18)
  L3 w0.191: v4(87.05,185.53) 87.05,185.84 86.57,186.31 86.57,187.79 86.72,187.94 86.72,191.56 94.95,199.78 105.06,199.78 115.22,189.62 134.8,189.62 136.32,191.14 156.52,191.14 156.81,190.86 164.7,182.97 167.18,182.97 v4(167.97,182.18)
  BOTTOM w0.14: v2(166.37,183) 167.15,183 v4(167.97,182.18)
M_DATA_A10: length 105.1
  TOP w0.14: v4(88.81,183.71) 88.86,183.71 CPU1.AK38 ; DIMM1.33 165.62,178.1 165.79,178.27 v4(165.79,178.3)
  L3 w0.102: 89.99,188.78 89.77,188.56 89.77,186.2 89.36,185.79 89.36,184.28 88.81,183.73 v4(88.81,183.71)
  L3 w0.191: 89.99,188.78 90.17,188.96 90.17,189.72 96.73,196.28 99.87,196.28 104.72,191.42 104.99,191.42 105.44,191.86 105.71,191.86 105.98,191.6 105.98,191.33 105.53,190.88 105.53,190.61 105.8,190.35 106.07,190.35 106.51,190.79 106.78,190.79 107.05,190.52 107.05,190.25 106.61,189.81 106.61,189.54 106.88,189.27 107.15,189.27 107.59,189.71 107.86,189.71 108.13,189.44 108.13,189.17 107.69,188.73 107.69,188.46 107.96,188.19 108.23,188.19 108.67,188.63 108.94,188.63 109.21,188.36 109.21,188.09 108.77,187.65 108.77,187.38 109.04,187.11 109.31,187.11 109.75,187.55 110.02,187.55 110.29,187.28 110.29,187.01 109.85,186.57 109.85,186.3 110.11,186.03 110.38,186.03 110.83,186.48 111.1,186.48 111.37,186.21 111.37,185.94 110.92,185.49 110.92,185.22 111.59,184.56 150.69,184.56 150.87,184.39 157.32,184.39 158.85,182.86 159.9,182.86 164.04,178.72 164.08,178.72 164.23,178.57 165.61,178.57 165.77,178.41 165.77,178.32 v4(165.79,178.3)
  BOTTOM w0.14: v2(165.1,178.93) 165.72,178.3 v4(165.79,178.3)
M_DATA_A11: length 104.2
  TOP w0.14: v4(88.81,184.57) 88.81,184.6 89.28,185.07 CPU1.AK39 ; v4(167.25,178.37) 166.38,177.5 DIMM1.35
  L3 w0.102: 89.53,188.79 89.53,186.3 89.09,185.86 89.09,184.85 v4(88.81,184.57)
  L3 w0.191: 89.53,188.79 89.53,189.65 96.56,196.69 101.82,196.69 113.54,184.97 116.37,184.97 116.81,185.41 117.57,185.41 118.02,184.97 118.78,184.97 119.22,185.41 119.99,185.41 120.43,184.97 121.19,184.97 121.64,185.41 122.4,185.41 122.84,184.97 123.6,184.97 124.05,185.41 124.81,185.41 125.26,184.97 126.02,184.97 126.46,185.41 127.22,185.41 127.67,184.97 128.43,184.97 128.88,185.41 129.64,185.41 130.08,184.97 130.84,184.97 131.29,185.41 132.05,185.41 132.49,184.97 133.26,184.97 133.7,185.41 134.46,185.41 134.91,184.97 135.67,184.97 136.11,185.41 136.88,185.41 137.32,184.97 138.08,184.97 138.53,185.41 139.29,185.41 139.73,184.97 140.5,184.97 140.94,185.41 141.7,185.41 142.15,184.97 142.91,184.97 143.35,185.41 144.12,185.41 144.56,184.97 145.32,184.97 145.77,185.41 146.53,185.41 146.97,184.97 147.73,184.97 148.18,185.41 148.94,185.41 149.39,184.97 150.19,184.97 150.53,185.3 151.69,185.3 152.2,184.79 157.49,184.79 159.01,183.27 160.07,183.27 164.21,179.13 164.25,179.13 164.32,179.05 164.4,178.98 166.64,178.98 v4(167.25,178.37)
  BOTTOM w0.14: v4(167.25,178.37) 167.25,178.81 v2(166.81,179.25)
M_DATA_A12: length 108.6
  TOP w0.14: CPU1.AH37 87.47,183.26 v4(87.03,183.7) ; DIMM1.22 170.73,181.4 v4(170.13,182)
  L3 w0.102: v4(87.03,183.7) 87.03,183.92 86.58,184.38 86.58,185.8
  L3 w0.191: 86.58,185.8 86.28,186.1 86.28,187.96 86.32,188 86.32,191.72 94.78,200.19 105.23,200.19 113.87,191.55 156.69,191.55 164.87,183.37 167.65,183.37 168.19,182.84 169.29,182.84 v4(170.13,182)
  BOTTOM w0.14: v4(170.13,182) 170.61,182.48 171.21,182.48 v2(171.87,181.83)
M_DATA_A13: length 106.4
  TOP w0.14: v4(87.9,183.7) 87.47,184.13 CPU1.AH38 ; DIMM1.24 170.81,180.8 v4(170.18,180.17)
  L3 w0.102: 87.54,187.24 87.49,187.2 87.49,184.11 v4(87.9,183.7)
  L3 w0.191: 87.54,187.24 87.54,191.22 95.28,198.97 104.07,198.97 114.82,188.22 142.63,188.22 142.82,188.41 142.82,188.79 143.02,188.99 143.4,188.99 143.59,188.79 143.59,188.41 143.78,188.22 158.27,188.22 164.9,181.59 168.77,181.59 169.95,180.42 169.95,180.41 v4(170.18,180.17)
  BOTTOM w0.14: v2(170.22,180.96) 170.22,180.21 v4(170.18,180.17)
M_DATA_A14: length 106.3
  TOP w0.14: v4(170.18,178.39) 170.81,177.76 172.36,177.76 DIMM1.34 ; v4(88.83,182.81) 88.87,182.81 CPU1.AK37
  L3 w0.102: v4(88.83,182.81) 88.38,183.26 88.38,184.75 88.65,185.01 88.65,186.09 88.43,186.31 88.43,186.67 88.62,186.86 88.62,187.36
  L3 w0.191: v4(170.18,178.39) 168.78,179.79 164.74,179.79 160.44,184.08 159.36,184.08 157.18,186.26 148.64,186.26 148.45,186.45 148.45,186.67 148.26,186.86 147.88,186.86 147.68,186.67 147.68,186.45 147.49,186.26 147.11,186.26 146.92,186.45 146.92,186.67 146.73,186.86 146.35,186.86 146.16,186.67 146.16,186.45 145.97,186.26 114.97,186.26 103.73,197.5 96.23,197.5 95.99,197.26 88.62,189.89 88.62,187.36
  BOTTOM w0.14: v4(170.18,178.39) 171.13,179.35 v2(171.23,179.35)
M_DATA_A15: length 103.1
  TOP w0.14: v4(89.05,187.1) 89.33,186.82 89.33,186.01 CPU1.AK40 ; DIMM1.36 169.82,177.2 168.71,178.32 v4(168.71,178.34)
  L3 w0.191: v4(168.71,178.34) 168.68,178.34 167.64,179.38 164.57,179.38 164.52,179.43 162.3,181.65 160.27,183.68 159.18,183.68 157.04,185.82 116.09,185.82 115.67,185.4 113.68,185.4 113.17,185.92 113.17,186.19 113.61,186.64 113.61,186.95 113.39,187.18 113.08,187.18 112.63,186.73 112.36,186.73 112.07,187.02 112.07,187.28 112.49,187.71 112.49,187.97 112.22,188.24 111.95,188.24 111.53,187.82 111.26,187.82 101.99,197.1 96.4,197.1 89.05,189.75 v4(89.05,187.1)
  BOTTOM w0.14: v2(168.97,179.35) 168.71,179.08 v4(168.71,178.34)
M_DATA_A16: length 93.6
  TOP w0.14: v4(91.04,186.6) 91.37,186.6 91.55,186.42 91.55,186.15 91.38,185.98 CPU1.AM40 ; DIMM1.39 165.72,176.3 v4(165.76,176.34)
  L3 w0.191: v4(165.76,176.34) 165.51,176.59 163.42,176.59 159.69,180.32 158.6,180.32 156.79,182.13 133.09,182.13 132.9,182.32 132.9,182.55 132.71,182.74 132.33,182.74 132.14,182.55 132.14,182.32 131.95,182.13 131.56,182.13 131.37,182.32 131.37,182.55 131.18,182.74 130.8,182.74 130.61,182.55 130.61,182.32 130.42,182.13 130.04,182.13 129.85,182.32 129.85,182.55 129.66,182.74 129.28,182.74 129.09,182.55 129.09,182.32 128.9,182.13 128.52,182.13 128.33,182.32 128.33,182.55 128.14,182.74 127.75,182.74 127.56,182.55 127.56,182.32 127.37,182.13 126.99,182.13 126.8,182.32 126.8,182.55 126.61,182.74 126.23,182.74 126.04,182.55 126.04,182.32 125.85,182.13 125.47,182.13 125.28,182.32 125.28,182.55 125.09,182.74 124.71,182.74 124.52,182.55 124.52,182.32 124.33,182.13 123.94,182.13 123.75,182.32 123.75,182.55 123.56,182.74 123.18,182.74 122.99,182.55 122.99,182.32 122.8,182.13 122.42,182.13 122.23,182.32 122.23,182.55 122.04,182.74 121.66,182.74 121.47,182.55 121.47,182.32 121.28,182.13 120.9,182.13 120.71,182.32 120.71,182.55 120.52,182.74 120.13,182.74 119.94,182.55 119.94,182.32 119.75,182.13 119.37,182.13 119.18,182.32 119.18,182.55 118.99,182.74 118.61,182.74 118.42,182.55 118.42,182.32 118.23,182.13 110.85,182.13 104.8,188.17 98.99,188.17 98.99,188.17 95.91,188.17 95.4,188.69 92.75,188.69 91.22,187.16 91.22,186.77 v4(91.04,186.6)
  BOTTOM w0.14: v4(165.76,176.34) 164.95,177.15 164.87,177.15 164.63,177.39 v2(164.32,177.39)
M_DATA_A17: length 94.3
  TOP w0.14: DIMM1.41 166.57,175.7 v4(167.21,176.34) ; CPU1.AM39 91.12,185.4 90.59,185.93 90.59,186.78 90.66,186.85 v4(90.66,187.3)
  L3 w0.191: v4(167.21,176.34) 166.55,177 163.59,177 159.86,180.73 158.77,180.73 156.96,182.53 136.85,182.53 136.66,182.72 136.66,182.96 136.47,183.15 136.09,183.15 135.9,182.96 135.9,182.72 135.71,182.53 135.33,182.53 135.14,182.72 135.14,182.96 134.95,183.15 134.54,183.15 134.35,182.96 134.35,182.72 134.16,182.53 133.78,182.53 133.59,182.72 133.59,182.96 133.4,183.15 117.13,183.15 116.94,182.96 116.94,182.72 116.75,182.53 116.37,182.53 116.18,182.72 116.18,182.96 115.99,183.15 115.61,183.15 115.42,182.96 115.42,182.72 115.23,182.53 114.85,182.53 114.66,182.72 114.66,182.96 114.47,183.15 114.09,183.15 113.89,182.96 113.89,182.72 113.7,182.53 113.32,182.53 113.13,182.72 113.13,182.96 112.94,183.15 112.56,183.15 112.37,182.96 112.37,182.72 112.18,182.53 111.22,182.53 105.18,188.57 96.02,188.57 95.62,188.98 92.34,188.98 v4(90.66,187.3)
  BOTTOM w0.14: v4(167.21,176.34) 167.21,176.69 v2(166.5,177.41)
M_DATA_A18: length 93.2
  TOP w0.14: v4(166.15,173.02) 165.7,173.02 165.38,172.7 DIMM1.51 ; CPU1.AP38 92.95,184.16 v4(93.43,184.64)
  L3 w0.102: 96.29,186.17 95.98,186.17 95.69,186.46 94.34,186.46 93.93,186.05 93.36,186.05 93.03,185.71 93.03,185.04 v4(93.43,184.64)
  L3 w0.191: 96.29,186.17 98.27,186.17 99.23,185.21 101.66,185.21 102.92,183.96 103.19,183.96 103.69,184.47 103.96,184.47 104.23,184.2 104.23,183.93 103.72,183.42 103.72,183.15 103.99,182.88 104.26,182.88 104.77,183.39 105.04,183.39 105.31,183.12 105.31,182.85 104.8,182.34 104.8,182.07 105.07,181.8 105.34,181.8 105.85,182.31 106.12,182.31 106.39,182.04 106.39,181.77 105.88,181.27 105.88,181 106.15,180.73 106.42,180.73 106.92,181.23 107.19,181.23 107.46,180.96 107.46,180.69 106.96,180.19 106.96,179.92 107.23,179.65 107.5,179.65 108,180.15 108.27,180.15 108.54,179.88 108.54,179.62 108.04,179.11 108.04,178.84 108.43,178.45 147.3,178.45 147.7,178.85 148.87,178.85 149.5,178.22 157.17,178.22 162.36,173.02 v4(166.15,173.02)
  BOTTOM w0.14: v2(165.08,173.05) 166.12,173.05 v4(166.15,173.02)
M_DATA_A19: length 93.3
  TOP w0.14: CPU1.AP39 92.95,185.05 92.54,184.64 v4(92.54,184.62) ; v4(167.68,173.02) 167.2,172.55 165.73,172.55 165.28,172.1 DIMM1.53
  L3 w0.102: 93.6,186.61 92.6,185.61 92.6,184.68 v4(92.54,184.62)
  L3 w0.191: v4(167.68,173.02) 167.16,173.54 162.42,173.54 156.55,179.41 145.26,179.41 144.71,178.86 131.96,178.86 131.77,179.05 131.77,179.22 131.58,179.41 131.2,179.41 131.01,179.22 131.01,179.05 130.82,178.86 130.44,178.86 130.25,179.05 130.25,179.22 130.06,179.41 129.64,179.41 129.45,179.22 129.45,179.05 129.26,178.86 128.88,178.86 128.69,179.05 128.69,179.22 128.5,179.41 128.12,179.41 127.93,179.22 127.93,179.05 127.74,178.86 127.35,178.86 127.16,179.05 127.16,179.22 126.97,179.41 126.59,179.41 126.4,179.22 126.4,179.05 126.21,178.86 116.24,178.86 116.05,179.05 116.05,179.22 115.85,179.41 115.47,179.41 115.28,179.22 115.28,179.05 115.09,178.86 114.71,178.86 114.52,179.05 114.52,179.22 114.33,179.41 113.95,179.41 113.76,179.22 113.76,179.05 113.57,178.86 113.19,178.86 113,179.05 113,179.22 112.81,179.41 112.43,179.41 112.24,179.22 112.24,179.05 112.04,178.86 111.66,178.86 111.47,179.05 111.47,179.22 111.28,179.41 109.83,179.41 103.62,185.62 99.23,185.62 98.14,186.71 93.71,186.71 93.6,186.61
  BOTTOM w0.14: v4(167.68,173.02) 166.8,172.15 v2(166.55,172.15)
M_DATA_A20: length 96.4
  TOP w0.14: CPU1.AM37 91.12,183.26 v4(90.72,183.67) ; v4(170.1,176.31) 170.41,176 DIMM1.40
  L3 w0.102: 90.16,188.19 90.02,188.05 90.02,186.37 90.25,186.14 90.25,184.13 v4(90.72,183.67)
  L3 w0.191: 90.16,188.19 91.54,189.56 96.3,189.56 96.42,189.44 105.71,189.44 111.18,183.96 157.17,183.96 158.68,182.46 159.73,182.46 163.76,178.44 164.38,177.81 169.44,177.81 170.1,177.15 v4(170.1,176.31)
  BOTTOM w0.14: v2(171.33,177.42) 170.57,177.42 170.1,176.95 v4(170.1,176.31)
M_DATA_A21: length 95
  TOP w0.14: DIMM1.42 169.59,175.4 v4(168.66,176.34) ; v4(91.58,183.67) 91.12,184.12 CPU1.AM38
  L3 w0.102: v4(91.58,183.67) 90.68,184.56 90.68,186 90.22,186.45 90.22,187.68 90.27,187.72
  L3 w0.191: 90.27,187.72 91.82,189.27 95.9,189.27 96.14,189.03 105.54,189.03 111.02,183.56 149.78,183.56 150.37,182.97 157.11,182.97 157.13,182.94 157.13,182.94 158.73,181.34 159.82,181.34 163.76,177.4 167.59,177.4 v4(168.66,176.34)
  BOTTOM w0.14: v2(169.04,177.4) 169.04,176.72 v4(168.66,176.34)
M_DATA_A22: length 94.1
  TOP w0.14: CPU1.AP37 93.42,183.7 v4(93.43,183.7) ; v4(170.72,173.02) 170.75,173 DIMM1.50
  L3 w0.102: 93.15,187.81 92.92,187.58 92.92,186.49 92.4,185.97 92.4,185.1 92.11,184.81 92.11,184.44 92.37,184.18 92.95,184.18 v4(93.43,183.7)
  L3 w0.191: 93.15,187.81 93.15,187.81 93.55,187.81 94.06,187.3 98.38,187.3 99.18,186.5 104.11,186.5 110.38,180.22 136.85,180.22 137.04,180.03 137.04,179.86 137.23,179.67 137.61,179.67 137.8,179.86 137.8,180.03 137.99,180.22 138.37,180.22 138.56,180.03 138.56,179.86 138.75,179.67 139.13,179.67 139.32,179.86 139.32,180.03 139.51,180.22 156.55,180.22 156.88,180.22 162.73,174.38 169.37,174.38 v4(170.72,173.02)
  BOTTOM w0.14: v4(170.72,173.02) 171.58,173.88 v2(171.58,173.97)
M_DATA_A23: length 92.2
  TOP w0.14: v4(169.2,173.02) 169.82,172.4 DIMM1.52 ; v4(93.35,187.33) 93.45,187.43 93.84,187.43 94.04,187.23 94.04,186.75 93.27,185.98 CPU1.AP40
  L3 w0.191: v4(93.35,187.33) 93.68,187 98.26,187 99.18,186.09 103.94,186.09 109.97,180.05 110.21,179.82 116.84,179.82 117.03,179.63 117.03,179.45 117.22,179.26 117.6,179.26 117.79,179.45 117.79,179.63 117.98,179.82 118.37,179.82 118.56,179.63 118.56,179.45 118.75,179.26 119.13,179.26 119.32,179.45 119.32,179.63 119.51,179.82 119.89,179.82 120.08,179.63 120.08,179.45 120.27,179.26 120.65,179.26 120.84,179.45 120.84,179.63 121.03,179.82 121.41,179.82 121.6,179.63 121.6,179.45 121.79,179.26 122.18,179.26 122.37,179.45 122.37,179.63 122.56,179.82 132.26,179.82 132.81,179.26 144.54,179.26 145.09,179.82 156.72,179.82 162.58,173.95 168.27,173.95 v4(169.2,173.02)
  BOTTOM w0.14: v4(169.2,173.02) 168.91,173.31 v2(168.91,174.1)
M_DATA_A24: length 85.6
  TOP w0.14: v4(167.18,171.48) 166.6,170.9 DIMM1.57 ; CPU1.AV37 96.61,183.45 96.11,183.94 v4(96.11,184.57)
  L3 w0.191: v4(167.18,171.48) 166.99,171.68 160.79,171.68 157.25,175.22 154.08,175.22 153.62,175.68 149.4,175.68 148.08,177 116.08,177 115.89,176.81 115.89,176.59 115.7,176.4 115.32,176.4 115.13,176.59 115.13,176.81 114.93,177 114.55,177 114.36,176.81 114.36,176.59 114.17,176.4 113.79,176.4 113.6,176.59 113.6,176.81 113.41,177 113.03,177 112.84,176.81 112.84,176.59 112.65,176.4 112.27,176.4 112.08,176.59 112.08,176.81 111.89,177 107.75,177 100.6,184.14 96.55,184.14 v4(96.11,184.57)
  BOTTOM w0.14: v4(167.18,171.48) 165.76,171.48 v2(165.27,170.99)
M_DATA_A25: length 83.8
  TOP w0.14: v4(166.52,169.71) 165.93,170.3 DIMM1.59 ; CPU1.AW37 97.6,183.16 97.76,183.16 97.87,183.28 98.36,183.28 v4(98.78,182.86)
  L3 w0.191: v4(166.52,169.71) 166.05,170.18 160.18,170.18 157.07,173.29 149.33,173.29 148.45,174.16 147.28,174.16 147.09,174.35 147.09,174.67 146.9,174.86 146.52,174.86 146.33,174.67 146.33,174.35 146.14,174.16 145.43,174.16 144.84,174.75 141.63,174.75 141.26,175.12 140.5,175.12 140.13,174.75 139.37,174.75 139,175.12 138.24,175.12 137.87,174.75 137.11,174.75 136.74,175.12 136.17,175.12 135.81,174.75 135.04,174.75 134.68,175.12 133.91,175.12 133.55,174.75 132.78,174.75 132.41,175.12 131.65,175.12 131.28,174.75 130.52,174.75 130.15,175.12 129.39,175.12 129.02,174.75 128.26,174.75 127.89,175.12 127.13,175.12 126.76,174.75 126,174.75 125.63,175.12 124.87,175.12 124.5,174.75 123.74,174.75 123.37,175.12 122.61,175.12 122.24,174.75 121.48,174.75 121.11,175.12 120.35,175.12 119.98,174.75 119.22,174.75 118.85,175.12 118.09,175.12 117.72,174.75 116.96,174.75 116.59,175.12 115.83,175.12 115.46,174.75 114.7,174.75 114.33,175.12 113.57,175.12 113.2,174.75 112.44,174.75 112.07,175.12 111.31,175.12 110.94,174.75 110.18,174.75 109.81,175.12 109.05,175.12 108.68,174.75 108.04,174.75 99.93,182.86 v4(98.78,182.86)
  BOTTOM w0.14: v4(166.52,169.71) 166.52,169.3 166.29,169.07 v2(166.29,168.82)
M_DATA_A26: length 86.7
  TOP w0.14: v4(165.85,167.92) 165.83,167.9 DIMM1.67 ; v4(95.3,181.87) 95.69,181.48 CPU1.AU35
  L3 w0.191: v4(95.3,181.87) 96.33,180.85 96.33,179.75 97.72,178.36 99.75,178.36 104.99,173.12 138.98,173.12 141.1,171 141.72,171 141.91,171.19 141.91,172.64 142.1,172.83 142.48,172.83 142.67,172.64 142.67,171.19 142.86,171 143.24,171 143.43,171.19 143.43,172.64 143.62,172.83 144,172.83 144.19,172.64 144.19,171.19 144.38,171 156.9,171 159.98,167.92 v4(165.85,167.92)
  BOTTOM w0.14: v2(164.83,167.9) 164.83,167.9 164.85,167.92 v4(165.85,167.92)
M_DATA_A27: length 86.3
  TOP w0.14: CPU1.AV35 96.58,181.41 v4(96.16,181.83) ; v4(167.37,167.92) 166.75,167.3 DIMM1.69
  L3 w0.191: v4(167.37,167.92) 166.88,168.41 160.06,168.41 157.75,170.72 157.07,171.41 146.38,171.41 144.26,173.53 105.78,173.53 101.52,177.78 101.52,179.05 100.69,179.89 100.34,179.89 99.57,179.12 99.3,179.12 99.03,179.39 99.03,179.66 99.84,180.47 99.84,180.74 99.57,181.01 99.3,181.01 98.49,180.2 98.22,180.2 96.59,181.83 v4(96.16,181.83)
  BOTTOM w0.14: v2(166.69,166.93) 167.37,167.61 v4(167.37,167.92)
M_DATA_A28: length 87
  TOP w0.14: DIMM1.56 170.46,171.2 v4(170.15,171.51) ; CPU1.AT37 94.78,183.39 94.53,183.65 v4(94.35,183.65)
  L3 w0.102: 96.29,185.56 96.07,185.56 95.53,185.01 95.07,185.01 94.82,184.76 94.82,184.12 v4(94.35,183.65)
  L3 w0.191: v4(170.15,171.51) 169.18,172.49 161.9,172.49 156.58,177.81 108.2,177.81 101.09,184.92 99.03,184.92 98.4,185.56 96.29,185.56
  BOTTOM w0.14: v2(171.07,170.93) 170.74,170.93 v4(170.15,171.51)
M_DATA_A29: length 86.1
  TOP w0.14: v4(168.66,171.48) 169.54,170.6 DIMM1.58 ; CPU1.AU37 95.68,183.24 v4(95.24,183.67)
  L3 w0.102: v4(95.24,183.67) 95.68,184.11 95.68,184.75 96.03,185.1 96.49,185.1
  L3 w0.191: v4(168.66,171.48) 168.06,172.08 160.96,172.08 155.64,177.4 108,177.4 100.94,184.46 98.93,184.46 98.3,185.1 96.49,185.1
  BOTTOM w0.14: v4(168.66,171.48) 168.66,171.39 167.81,170.54 v2(167.77,170.54)
M_DATA_A30: length 88.1
  TOP w0.14: v4(170.42,167.92) 170.74,167.6 DIMM1.68 ; CPU1.AT35 94.78,181.45 v4(94.36,181.86)
  L3 w0.102: 98.76,182.13 98.55,182.13 98.29,182.39 97.49,182.39 97.44,182.34 94.83,182.34 v4(94.36,181.86)
  L3 w0.191: v4(170.42,167.92) 169.11,169.22 160.4,169.22 157.34,172.28 148.32,172.28 148.13,172.47 148.13,173.22 147.94,173.42 147.56,173.42 147.37,173.22 147.37,172.47 147.18,172.28 146.68,172.28 144.61,174.34 107.81,174.34 100.02,182.13 98.76,182.13
  BOTTOM w0.14: v4(170.42,167.92) 171.28,167.92 v2(171.58,167.62)
M_DATA_A31: length 85.1
  TOP w0.14: CPU1.AW35 97.52,181.57 97.91,181.96 v4(98.05,181.96) ; v4(168.9,167.92) 169.81,167 DIMM1.70
  L3 w0.191: v4(168.9,167.92) 168,168.82 160.23,168.82 157.92,171.13 157.23,171.81 146.55,171.81 144.43,173.94 107.43,173.94 104.42,176.94 104.15,176.94 103.84,176.63 103.57,176.63 103.3,176.9 103.3,177.17 103.61,177.48 103.61,177.75 103.34,178.02 103.07,178.02 102.76,177.71 102.49,177.71 102.22,177.98 102.22,178.25 102.53,178.56 102.53,178.83 99.8,181.57 98.44,181.57 v4(98.05,181.96)
  BOTTOM w0.14: v4(168.9,167.92) 168.9,167.99 v2(168.06,168.83)
M_DATA_A32: length 85.3
  TOP w0.14: DIMM1.129 165.02,146.9 165.83,147.71 v4(166.73,147.71) ; v4(97.07,153.14) 97.52,152.69 CPU1.AY6
  L3 w0.191: v4(97.07,153.14) 98.96,153.14 99.23,153.41 131.08,153.41 143.07,141.43 145.09,141.43 145.28,141.24 145.28,141.09 145.47,140.9 145.85,140.9 146.04,141.09 146.04,141.24 146.23,141.43 146.62,141.43 146.81,141.24 146.81,141.09 147,140.9 147.38,140.9 147.57,141.09 147.57,141.24 147.76,141.43 148.14,141.43 148.33,141.24 148.33,141.09 148.52,140.9 148.9,140.9 149.09,141.09 149.09,141.24 149.28,141.43 153.79,141.43 153.99,141.24 153.99,141 154.18,140.81 154.56,140.81 154.75,141 154.75,141.24 154.94,141.43 155.32,141.43 155.51,141.24 155.51,141 155.7,140.81 156.08,140.81 156.27,141 156.27,141.24 156.46,141.43 158.31,141.43 164.59,147.71 v4(166.73,147.71)
  BOTTOM w0.14: v4(166.73,147.71) v2(165.74,147.71)
M_DATA_A33: length 88.4
  TOP w0.14: CPU1.AU6 94.77,152.69 v4(94.33,153.13) ; DIMM1.131 164.96,146.3 165.86,147.2 167.72,147.2 v4(168.2,147.68)
  L3 w0.102: v4(94.33,153.13) 94.8,153.59 95.47,153.59 95.48,153.59 97.46,153.59
  L3 w0.191: 97.46,153.59 98.81,153.59 99.26,154.03 100.51,154.03 100.72,153.82 131.66,153.82 143.64,141.84 158.14,141.84 164.49,148.19 167.7,148.19 v4(168.2,147.68)
  BOTTOM w0.14: v2(168.4,146.67) 168.2,146.87 v4(168.2,147.68)
M_DATA_A34: length 87.2
  TOP w0.14: v4(95.27,151.32) 95.69,150.89 CPU1.AV4 ; v4(165.68,143.24) 165.62,143.3 DIMM1.141
  L3 w0.102: 99.16,150.53 98.94,150.76 95.83,150.76 v4(95.27,151.32)
  L3 w0.191: v4(165.68,143.24) 164.24,143.24 157.38,136.39 149.82,136.39 149.63,136.58 149.63,136.99 149.44,137.18 149.06,137.18 148.87,136.99 148.87,136.58 148.68,136.39 148.29,136.39 148.1,136.58 148.1,136.99 147.91,137.18 147.53,137.18 147.34,136.99 147.34,136.58 147.15,136.39 146.77,136.39 146.58,136.58 146.58,136.99 146.39,137.18 146.01,137.18 145.82,136.99 145.82,136.58 145.63,136.39 145.25,136.39 145.06,136.58 145.06,136.99 144.87,137.18 144.48,137.18 144.29,136.99 144.29,136.58 144.1,136.39 143.7,136.39 129.8,150.29 99.41,150.29 99.16,150.53
  BOTTOM w0.14: v4(165.68,143.24) 165.17,143.76 v2(164.85,143.76)
M_DATA_A35: length 87.9
  TOP w0.14: DIMM1.143 166.62,142.7 v4(167.13,143.21) ; CPU1.AU4 94.75,150.86 94.3,151.32 v4(94.3,151.36)
  L3 w0.102: 98.81,150.28 98.65,150.43 95.51,150.43 94.58,151.36 v4(94.3,151.36)
  L3 w0.191: 98.81,150.28 99.2,149.88 129.63,149.88 143.53,135.98 148.6,135.98 148.79,135.79 148.79,135.51 148.98,135.32 149.36,135.32 149.55,135.51 149.55,135.79 149.74,135.98 157.55,135.98 164.23,142.66 166.57,142.66 v4(167.13,143.21)
  BOTTOM w0.14: v2(167.51,144) 167.51,143.6 v4(167.13,143.21)
M_DATA_A36: length 87.5
  TOP w0.14: v4(170.18,147.18) 170.76,146.6 DIMM1.130 ; CPU1.AW6 96.61,152.7 v4(96.17,153.14)
  L3 w0.102: v4(96.17,153.14) 96.32,153.14 96.76,152.71 99.13,152.71 99.43,153.01 99.62,153.01
  L3 w0.191: v4(170.18,147.18) 169.19,147.18 168.6,146.59 164.04,146.59 157.86,140.4 143.49,140.4 130.89,153.01 99.62,153.01
  BOTTOM w0.14: v4(170.18,147.18) 169.3,148.06 v2(169.3,148.85)
M_DATA_A37: length 87.3
  TOP w0.14: DIMM1.132 171.01,146 170.99,145.98 v4(170.87,145.98) ; CPU1.AV6 95.69,152.76 v4(95.29,153.16)
  L3 w0.102: v4(95.29,153.16) 95.74,152.71 96.32,152.71 96.53,152.5 99.44,152.5 99.54,152.6 99.95,152.6
  L3 w0.191: v4(170.87,145.98) 170.41,146.43 169.26,146.43 169.01,146.18 164.21,146.18 158.03,140 143.32,140 130.72,152.6 99.95,152.6
  BOTTOM w0.14: v2(171.83,146.54) 171.42,146.54 v4(170.87,145.98)
M_DATA_A38: length 85.8
  TOP w0.14: CPU1.AW4 96.61,150.88 97.05,151.32 v4(97.05,151.34) ; DIMM1.140 171.25,143.6 v4(170.92,143.27)
  L3 w0.102: 99.52,151.52 99.24,151.8 97.51,151.8 v4(97.05,151.34)
  L3 w0.191: 99.52,151.52 99.89,151.15 130.35,151.15 143.51,137.99 157.84,137.99 163.99,144.15 170.03,144.15 v4(170.92,143.27)
  BOTTOM w0.14: v4(170.92,143.27) 170.92,143.72 v2(170.64,144)
