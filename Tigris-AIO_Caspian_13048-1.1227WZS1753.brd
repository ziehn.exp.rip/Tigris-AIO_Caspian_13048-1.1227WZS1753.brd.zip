# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKA0#: length 50.5
  TOP w0.127: v4(52.68,99.02) 52.84,99.02 53.15,99.32 53.49,99.32 54.36,98.45 MEM1.K7 ; v4(47.66,99.16) 47.37,99.45 46.55,99.45 R215.1 ; v4(73.75,94.35) 73.73,94.35 73.35,94.73 U13.H25
  L4 w0.152: v4(73.75,94.35) 73.75,94.58 73.62,94.71 73.57,94.71 73.34,94.93 72.9,94.93 72.82,95.01 72,95.01 70.09,96.92 70.09,97 59.41,107.68 53.56,107.68 52.59,106.71 52.59,106.38 52.06,105.86 51.71,105.86 50.1,104.24 50.1,100.99 50.52,100.56 51.22,100.56 51.99,99.8 52.32,99.8 52.7,99.42 52.7,99.03 v4(52.68,99.02) 52.39,99.02 52.24,98.86 49.62,98.86 49.2,99.29 47.79,99.29 v4(47.66,99.16)
  BOTTOM w0.127: v4(52.68,99.02) 52.46,98.8 52.15,98.8 52.1,98.85 51.95,98.85 51.89,98.92 51.43,98.92 51.16,98.65 MEM3.K7 ; v4(47.66,99.16) 47.24,98.74 v2(47.24,98.43)
CLKA1: length 50.1
  TOP w0.127: R352.1 46.48,80.05 47.5,80.05 v4(47.75,79.8) ; MEM2.J7 51.3,79.96 51.8,79.46 52.24,79.46 52.58,79.12 v4(52.58,78.95) ; v4(72.16,81.54) 72.39,81.54 72.55,81.7 U13.G9
  L4 w0.152: v4(47.75,79.8) 47.96,80 48.98,80 49.79,79.19 52.34,79.19 v4(52.58,78.95) 52.77,79.14 52.92,79.14 53.01,79.23 53.77,79.23 54.52,79.99 56.15,79.99 56.31,80.16 58.25,80.16 58.96,80.87 58.96,81.47 59.12,81.63 59.38,81.63 59.71,81.96 59.71,82.52 59.38,82.85 59.12,82.85 58.96,83 58.96,83.3 59.12,83.46 59.38,83.46 59.71,83.79 59.71,84.34 59.38,84.67 59.12,84.67 58.96,84.83 58.96,85.13 59.12,85.28 59.37,85.28 59.68,85.59 59.68,86.2 59.37,86.5 59.12,86.5 58.96,86.66 58.96,87.27 59.75,88.06 60.24,88.06 60.57,88.39 60.57,88.6 60.72,88.76 61.02,88.76 61.18,88.6 61.18,88.39 61.51,88.06 62.06,88.06 62.4,88.39 62.4,88.81 62.52,88.93 62.88,88.93 63,88.81 63,88.39 63.34,88.06 67.03,88.06 67.33,88.35 69.16,88.35 69.61,87.9 69.61,87.33 70.06,86.88 70.64,86.88 71.49,86.03 71.49,84.66 71.64,84.5 71.64,83.09 72.59,82.14 72.59,81.77 72.36,81.54 v4(72.16,81.54)
  BOTTOM w0.127: v4(52.58,78.95) 52.76,79.13 53.4,79.13 54.23,79.96 MEM4.J7
CLKA1#: length 50.5
  TOP w0.127: v4(72.95,81.54) 73.35,81.93 U13.H9 ; v4(47.76,80.61) 47.46,80.3 46.48,80.3 R341.1 ; MEM2.K7 51.49,80.43 51.65,79.99 51.87,79.76 51.91,79.75 52.29,79.75 52.35,79.73 v4(52.74,79.58)
  L4 w0.152: v4(47.76,80.61) 48.06,80.31 49.11,80.31 49.92,79.5 52.66,79.5 v4(52.74,79.58) 52.78,79.54 53.64,79.54 54.4,80.29 56.02,80.29 56.19,80.46 58.13,80.46 58.66,80.99 58.66,81.6 58.99,81.93 59.25,81.93 59.4,82.08 59.4,82.39 59.25,82.54 58.99,82.54 58.66,82.87 58.66,83.43 58.99,83.76 59.25,83.76 59.4,83.91 59.4,84.22 59.25,84.37 58.99,84.37 58.66,84.7 58.66,85.26 58.99,85.59 59.25,85.59 59.37,85.72 59.37,86.07 59.25,86.2 58.99,86.2 58.66,86.53 58.66,87.4 59.63,88.36 60.11,88.36 60.26,88.52 60.26,88.73 60.59,89.06 61.15,89.06 61.48,88.73 61.48,88.52 61.63,88.36 61.94,88.36 62.09,88.52 62.09,88.93 62.4,89.24 63,89.24 63.31,88.93 63.31,88.52 63.46,88.36 66.91,88.36 67.2,88.66 69.29,88.66 69.92,88.03 69.92,87.46 70.19,87.18 70.76,87.18 71.79,86.16 71.79,84.78 71.95,84.63 71.95,83.21 72.9,82.26 72.9,81.59 v4(72.95,81.54)
  BOTTOM w0.127: MEM4.K7 54.36,80.47 53.29,79.4 52.92,79.4 v4(52.74,79.58)
CLKBUF_EN: length 8
  TOP w0.102: R438.2 C248.2 158.94,63.29 159.46,63.81 U21.2 159.46,65.59 160.53,66.66 v1(160.91,66.66)
CLKOUT_PCIE0N: length 198.5
  TOP w0.102: R23.2 107.75,222.6 107.75,222.28 106.23,220.76 106.23,216.16 109.86,212.53 109.86,209.15 106.91,206.21 106.91,129.4 110.25,126.06 110.25,117.74 109.86,117.35 109.86,115.66 110.62,114.9 110.62,113.67 110.34,113.39 110.11,113.39 v3(109.73,113.01) ; U29.AE10 137.84,69.43 v4(137.67,69.43)
  BOTTOM w0.102: v3(109.73,113.01) 110.11,113.39 113.17,113.39 113.81,112.76 115.32,112.76 115.9,112.18 115.9,107.99 113.74,105.82 113.74,69.25 114.13,68.85 114.13,68.84 116.59,66.38 119.05,66.38 121.05,64.37 ; 121.05,64.37 123.08,62.34 130.28,62.34 134.05,66.11 135.14,66.11 136.3,67.27 136.3,68.28 136.27,68.31 136.27,68.84 137.06,69.63 137.46,69.63 v4(137.67,69.43) ; 121.05,64.37 v2(120.85,64.17)
CLKOUT_PCIE0P: length 197.9
  TOP w0.102: v3(109.73,113.9) 109.98,113.65 110.24,113.65 110.36,113.78 110.36,114.79 109.6,115.55 109.6,117.45 109.99,117.85 109.99,125.96 106.65,129.3 106.65,206.31 109.6,209.26 109.6,212.43 105.97,216.05 105.97,220.87 107.49,222.39 107.49,222.75 R22.2 ; v4(137.69,70.09) 137.89,70.09 U29.AE11
  BOTTOM w0.102: 117.63,66.63 116.69,66.63 114.38,68.94 114.38,68.96 113.99,69.35 113.99,105.72 116.15,107.88 116.15,112.28 115.42,113.01 113.91,113.01 113.28,113.65 109.98,113.65 v3(109.73,113.9) ; 117.63,66.63 119.15,66.63 123.19,62.59 130.18,62.59 133.95,66.37 135.04,66.37 136.04,67.37 136.04,68.18 136.02,68.2 136.02,68.94 136.74,69.67 136.74,69.67 136.96,69.89 137.49,69.89 v4(137.69,70.09) ; 117.63,66.63 v2(117.63,66.94)
CLKOUT_PCIE1N: length 197.2
  TOP w0.102: U29.AC6 137.31,66.86 v4(137.69,67.24) ; v3(111,111.9) 111,112.09 111.12,112.22 111.85,112.22 112.15,112.53 112.15,126.58 108.5,130.24 108.5,205.46 111.51,208.46 111.51,213.17 108.84,215.84 108.84,219.89 109.91,220.96 113.16,220.96 113.79,221.6 113.79,222.68 R26.2
  BOTTOM w0.102: v4(137.69,67.24) 131.37,60.92 119.78,60.92 112.15,68.55 112.15,73.64 ; 112.15,73.64 112.15,109.67 111.71,110.11 111.71,112.17 111.63,112.25 111.1,112.25 111,112.15 v3(111,111.9) ; 112.15,73.64 v2(111.86,73.64)
CLKOUT_PCIE1P: length 196.8
  TOP w0.102: v4(137.67,67.93) 137.36,67.63 U29.AC7 ; R25.2 113.54,222.68 113.54,221.7 113.05,221.22 109.81,221.22 108.58,219.99 108.58,215.73 111.25,213.06 111.25,208.57 108.25,205.56 108.25,130.13 111.9,126.48 111.9,112.63 111.74,112.47 111.28,112.47 v3(111,112.76)
  BOTTOM w0.102: v4(137.67,67.93) 137.26,67.52 137.26,67.17 131.9,61.81 ; 131.9,61.81 131.26,61.17 119.89,61.17 112.4,68.66 112.4,109.78 111.96,110.22 111.96,112.28 111.73,112.51 111.25,112.51 v3(111,112.76) ; 131.9,61.81 v2(131.7,62.01)
CLKOUT_PCIE4N: length 178.6
  TOP w0.102: U29.Y4 135.56,65.6 135.25,65.29 135.25,64.63 135.1,64.48 135.1,63.95 134.89,63.75 134.89,63.13 134.85,63.08 134.85,60.94 134.58,60.68 v4(134.28,60.68)
  L3 w0.102: v3(181.58,168.26) 181.89,167.95 181.89,161.51 182.27,161.13 182.27,160.16 183.04,159.39 183.04,153.74 181.13,151.83 181.13,149.36 180.4,148.64 180.32,148.56 180.19,148.42 180.19,123.04 184.65,118.58 184.65,105.56 178.95,99.86 175.24,99.86 174.29,98.9 170.36,98.9 165.48,94.02 165.48,81.43 163.6,79.55 163.6,75.59 160.99,72.98 160.99,71.12 157.89,68.02 157.89,63.22 156.04,61.38 154.02,61.38 151.25,64.14 148.06,64.14 145.89,61.98 145.11,61.98 143.72,60.59 134.37,60.59 v4(134.28,60.68)
  BOTTOM w0.102: 178.31,167.45 177.42,167.45 175.67,165.7 175.67,160 175.36,159.69 175.36,156.88 176.06,156.17 178.72,156.17 178.81,156.08 U39.2 ; 178.31,167.45 v2(178.31,167.75) ; 178.31,167.45 181.68,167.45 181.88,167.64 181.88,167.96 v3(181.58,168.26)
CLKOUT_PCIE4P: length 178.5
  TOP w0.102: v4(134.28,60.04) 134.66,60.42 134.69,60.42 135.1,60.84 135.1,62.98 135.15,63.02 135.15,63.64 135.35,63.84 135.35,64.4 135.5,64.55 135.5,65.11 U29.Y2
  L3 w0.102: v4(134.28,60.04) 134.59,60.36 143.81,60.36 145.21,61.75 145.99,61.75 148.15,63.92 151.16,63.92 153.92,61.15 155.95,61.15 155.95,61.15 156.14,61.15 158.12,63.12 158.12,67.93 161.21,71.03 161.21,72.88 163.83,75.5 163.83,79.45 165.71,81.33 165.71,93.93 170.46,98.68 171.86,98.68 174.38,98.68 175.34,99.63 179.04,99.63 184.87,105.46 184.87,118.67 180.42,123.13 180.42,148.33 180.5,148.41 181.36,149.27 181.36,151.73 183.27,153.64 183.27,159.49 182.5,160.26 182.5,161.22 182.12,161.6 182.12,167.95 v3(182.43,168.26)
  BOTTOM w0.102: 175.62,158.99 175.62,159.59 175.92,159.89 175.92,165.59 177.52,167.19 181.79,167.19 182.13,167.54 182.13,167.96 v3(182.43,168.26) ; 175.62,158.99 v2(176.02,158.99) ; 175.62,158.99 175.62,156.98 176.17,156.43 178.76,156.43 178.81,156.48 U39.3
CLKOUTFLEX1: length 15.9
  TOP w0.102: R446.2 151.84,60.14 151.84,61.09 v3(151.87,61.12) ; U29.AT9 143.98,68.69 v4(144.5,68.69)
  BOTTOM w0.102: v4(144.5,68.69) 144.94,69.12 148.18,69.12 v2(151.47,65.83) 151.87,65.43 151.87,61.13 v3(151.87,61.12)
CLKTESTA: length 11
  TOP w0.102: C764.1 73.66,72.95 73.66,73.52 v4(74.3,74.15) ; v4(74.6,80.74) 74.63,80.77 74.63,80.81 U13.K8
  L3 w0.127: v4(74.3,74.15) 74.3,75.8 73.85,76.25 73.85,78.36 74.1,78.61 74.1,80.25 v4(74.6,80.74)
  BOTTOM w0.102: v4(74.3,74.15) 74.22,74.15 v2(73.58,73.52)
CLKTESTA_C: length 3.4
  TOP w0.102: C764.2 R1207.1 73.18,69.16 v1(73.18,68.51)
CLKTESTB: length 10.7
  TOP w0.102: v4(76.53,80.4) 76.47,80.34 U13.L7
  BOTTOM w0.102: C763.1 80.77,72.62 79,74.39 79,74.39 78.59,74.8 78.59,74.94 78.13,75.4 78.11,75.4 77.7,75.81 77.7,76.15 77.74,76.2 77.74,76.35 77.67,76.43 77.67,76.96 77.77,77.06 77.77,79.28 v2(77.27,79.79) 77.14,79.79 v4(76.53,80.4)
CLKTESTB_C: length 7.5
  TOP w0.102: R1206.1 76.37,69.22 76.91,69.22 v4(77.54,69.86)
  BOTTOM w0.102: C763.2 v2(80.77,70.34) 80.24,69.81 77.59,69.81 v4(77.54,69.86)
CPU_FAN_CTRL_SIO: length 163.1
  TOP w0.165: U24.47 54.07,52.81 54.38,53.12 54.38,53.6 54.49,53.71 54.49,55.37 54.91,55.79 54.91,57.79 53.32,59.38 51.35,59.38 49.79,60.94 47.76,60.94 45.38,63.31 45.38,68.65 39.62,74.41 38.78,74.41 v3(38.77,74.42)
  L4 w0.165: v3(42.98,149.29) 43.05,149.21 43.05,143.04 44.46,141.64 44.46,111.47 39.21,106.23 39.21,89.12 37.2,87.12 37.2,77.71 37.36,77.56 38.77,76.15 v3(38.77,74.42)
  BOTTOM w0.165: v3(42.98,149.29) 39.34,149.29 36.17,152.46 v2(36.17,154.47) 36.17,158.68 33.55,161.3 26.6,161.3 23.22,164.68 23.22,166.15 21.03,168.34 21.03,176.64 16.52,181.15 R810.1
CPU_FAN_TACH_SIO: length 166.6
  TOP w0.165: U24.37 58.07,53.04 58.16,53.13 58.16,53.67 59.37,54.88 59.37,56.76 55.19,60.94 51.99,60.94 50.44,62.5 48.41,62.5 47.29,63.62 47.29,65.91 47.39,66.01 47.39,67.48 39.5,75.37 v3(39.26,75.37)
  L4 w0.165: v3(43.71,149.78) 44.2,149.29 44.2,142.49 44.88,141.81 44.88,111.3 39.63,106.05 39.63,88.95 37.62,86.94 37.62,85.86 37.62,85.64 37.62,77.99 37.78,77.84 37.78,77.74 39.41,76.1 39.41,75.59 39.26,75.44 v3(39.26,75.37)
  BOTTOM w0.165: v3(43.71,149.78) 39.44,149.78 37.05,152.18 v2(37.05,152.59) 37.05,158.49 33.82,161.72 26.77,161.72 23.63,164.86 23.63,166.32 21.45,168.51 21.45,176.93 15.27,183.12 R807.2
CPU_THERMTRIP_N: length 23.6
  TOP w0.102: v3(66.89,182.78) CPU1.F37
  BOTTOM w0.102: R756.2 R771.2 69.71,201.85 69.42,201.56 69.42,200.68 v2(68.59,199.85) 67.96,199.22 67.96,195.88 69.11,194.72 69.11,190.49 66.32,187.7 66.32,183.37 66.89,182.8 v3(66.89,182.78)
CPU_VSS_T8: length 2.1
  TOP w0.102: v3(76.04,154.06) CPU1.T8
  BOTTOM w0.102: TP97.1 76.86,154.88 v3(76.04,154.06)
CPVEE: length 6.5
  TOP w0.305: U16.20 174.15,88.41 173.86,88.12
  TOP w0.508: v3(172.16,84.92) 172.71,85.47 C195.1 172.85,85.9 172.85,87.11 173.86,88.12
CR_1P2V_LDOIN: length 19.5
  BOTTOM w0.508: L29.2 184.77,153.53 185.28,153.02 185.42,153.02 185.85,152.59 185.85,152.45 186.21,152.1 186.21,149.08 v2(184.4,147.28) 181.56,147.28 181.46,147.38 180.01,147.38 179.54,147.85 179.54,150.32 C460.1 178.88,151.05 C458.1 C456.1 178.88,153.84
CR_1P2V_LDOOUT: length 10.3
  L4 w0.508: v3(179.41,160) 179.41,156.64 182.25,153.81 v3(182.35,153.81)
  BOTTOM w0.203: U39.26 182.48,154.36 182.35,154.22 v3(182.35,153.81) ; U39.9 179.78,159.14
  BOTTOM w0.508: v3(182.35,153.81) 182.63,153.53 L29.1
  vias: v2(177.93,159.9)
CR_3P3V_PECI: length 4.8
  TOP w0.508: L7.2 180.31,152.16 C102.2 179.32,153.97 C101.1 179.58,154.29 v3(178.94,154.92) 178.38,154.37 v1(178.38,154.26)
CR_AUX_CAP: length 3.9
  BOTTOM w0.203: U39.11 180.88,160.67 181.12,160.91 v2(181.12,161.77)
  BOTTOM w0.508: v2(181.12,161.77) 180.97,161.91 180.97,162.71 C432.1
CR_CLKREQ_N: length 4.7
  BOTTOM w0.102: U39.23 184.83,156.08 185.08,155.84 185.98,155.84 186.28,156.14 v2(186.92,156.14) 186.92,155.94 186.5,155.52 R833.2
CR_IO_CAP: length 5
  BOTTOM w0.203: v2(185.52,157.66) 185.3,157.44 184.45,157.44 184.21,157.68 U39.19
  BOTTOM w0.508: v2(185.52,157.66) 185.8,157.94 185.8,158.18 186.23,158.61 C445.1 186.5,158.92 185.82,159.61 C441.2
CR_LDOSEL: length 6.3
  BOTTOM w0.102: U39.16 182.88,159.83 183.57,160.51 184.03,160.51 185.48,161.97 185.48,161.97 R817.2 185.58,161.94 R821.1 v2(187.58,161.94)
CR_PE_REXT: length 2.8
  BOTTOM w0.102: v2(177.16,157.87) 177.57,157.47 177.57,157.28 R827.2 177.96,156.88 U39.4
CR_WAKE0_N: length 3.7
  BOTTOM w0.102: R818.2 184.53,161.73 v2(183.82,161.02) 183.75,161.02 182.65,159.92 182.65,159.89 182.48,159.72 U39.15
CSA0#_0: length 44.6
  TOP w0.127: MEM1.L2 50.36,97.37 50.49,97.25 51.39,97.25 51.53,97.38 51.53,97.56 51.64,97.68 52.39,97.68 52.51,97.55 52.51,97.22 52.64,97.09 v4(53.25,97.09) ; v4(72.99,92.72) 72.99,92.34 73.19,92.14 U13.H22
  L3 w0.102: 70.26,94.08 70.55,94.37 71.41,94.37 71.85,93.93 73.09,93.93 73.32,93.7 73.32,93.05 v4(72.99,92.72)
  L3 w0.165: 70.26,94.08 70.09,93.91 69.62,93.91 69.42,94.12 69.42,94.34 69.16,94.6 68.15,94.6 68.01,94.46 68.01,94.14 67.88,94.01 67.26,94.01 67.13,94.14 67.13,94.47 67.01,94.6 66.67,94.6 66.5,94.78 66.23,94.78 65.76,95.25 65.38,95.63 64.36,95.63 64.24,95.5 64.24,94.85 64.11,94.73 60.4,94.73 60.12,94.45 59.82,94.45 59.54,94.73 59.29,94.73 59.11,94.54 58.58,94.54 58.34,94.78 58.34,95.09 58.22,95.22 57.33,95.22 57.22,95.11 55.27,95.11 54.41,95.97 53.82,95.97 53.66,96.12 53.21,96.12 52.94,95.86 52.88,95.86 52.66,95.64 50.01,95.64 49.81,95.84 49.81,97.29 50.04,97.52 51.18,97.52 51.38,97.32 51.38,96.96 51.59,96.76 52.22,96.76 52.7,97.24 53.1,97.24 v4(53.25,97.09)
  BOTTOM w0.127: v4(72.99,92.72) 73.36,93.09 73.36,93.91 v2(72.95,94.32) ; v4(53.25,97.09) 53.25,97.31 53.45,97.51 53.45,97.69 53.58,97.81 53.85,97.81 54,97.66 54,97.31 54.13,97.18 54.44,97.18 54.88,97.62 MEM3.L2
CSA1#_0: length 43.9
  TOP w0.127: v4(52.47,81.64) 52.75,81.92 54.8,81.92 MEM2.L2 ; v4(73.74,83.17) 73.69,83.21 73.69,84.14 73.24,84.6 73.21,84.6 72.86,84.94 U13.G13
  L3 w0.165: v4(73.74,83.17) 73.74,83.02 73.21,82.49 71.93,82.49 71.65,82.76 71.65,82.77 71.39,83.02 69.72,83.02 69.12,83.62 68.05,83.62 67.64,83.21 64.21,83.21 64.05,83.38 59.39,83.38 57.23,85.53 55.81,85.53 55.73,85.61 54.51,85.61 54.38,85.74 54.38,86.29 54.51,86.42 56.34,86.42 v3(56.55,86.22)
  L4 w0.102: v4(52.47,81.64) 52.89,82.06 55.86,82.06 56.12,82.32
  L4 w0.165: 56.12,82.32 56.12,83.83 56.48,84.2 57.35,84.2 57.48,84.32 57.48,85.37 57.29,85.56 57.29,85.63 57.29,85.63 57.29,86.52 57.19,86.62 56.96,86.62 v3(56.55,86.22)
  BOTTOM w0.127: v4(52.47,81.64) 52.11,82.01 51.97,82.01 51.91,82.07 51.55,82.07 51.47,81.99 50.49,81.99 50.36,81.86 MEM4.L2 ; v3(56.55,86.22) 56.62,86.28 v2(56.62,87.49)
CSN1: length 43
  L4 w0.305: v5(38.73,217.41) 39.01,217.69 40.13,217.69 41.12,218.68 41.12,231.23 41.12,231.23 41.12,231.73 41.12,231.86 36.96,236.03 28.32,236.03 v3(27.81,235.52)
  BOTTOM w0.203: U35.15 20.13,238.12 21.17,237.09 21.45,237.09 R674.1
  BOTTOM w0.305: G2.2 38.73,216.9 v5(38.73,217.41) ; C381.2 23.89,236.17 24.04,236.01 C384.1 v2(26.42,236.01) 27.32,236.01 v3(27.81,235.52) ; C381.2 R674.1 ; C381.2 23.39,235.62 23.5,235.52 R682.1
CSN2: length 73.7
  L4 w0.305: v3(17.37,232.67) 21.13,232.67 23.74,235.28 24.17,235.28 26.49,237.6 37.49,237.6 42.55,232.55 42.55,217.97 41.78,217.2 41.78,195.97 40.51,194.7 39.93,194.7 v5(38.86,193.63)
  BOTTOM w0.305: 17.37,232.66 17.37,231.95 R1222.1 ; 17.37,232.66 v3(17.37,232.67) ; 17.37,232.66 18.05,233.33 ; G4.2 v5(38.86,193.63) ; 18.05,233.33 18.05,234 R681.1 ; 18.05,233.33 v2(18.05,233.33)
CSN2_R: length 8.6
  BOTTOM w0.203: U35.19 18.25,236.23 R679.1
  BOTTOM w0.305: R679.1 C388.2 19.39,233.38 19.33,233.32 C392.1 19.1,232.61 R1222.2 18.35,230.82 R1221.1 18.33,230.17 v2(18.69,229.8)
CSN3: length 97.9
  TOP w0.305: v3(26.61,235.11) 26,234.5 25.3,234.5 24.56,235.24 v1(23.67,235.24) 21.31,235.24 v3(20.7,235.85)
  L4 w0.305: v3(20.7,235.85) 21.03,236.18 24.05,236.18 26.49,238.62 38.33,238.62 43.97,232.98 43.97,217.31 42.72,216.06 42.72,189.57 35.06,181.91 v3(33.21,181.91)
  BOTTOM w0.203: 20.68,235.87 19.31,237.24 U35.17
  BOTTOM w0.305: 20.68,235.87 v3(20.7,235.85) 21.42,235.12 R678.1 C387.2 21.42,233.37 21.34,233.28 C393.1 ; R684.1 v3(26.61,235.11) ; G5.2 v3(33.21,181.91)
CSP1: length 47.8
  TOP w0.305: v3(17.25,233.44) 17.22,233.44 17.25,233.46 v1(21.95,233.46) 26.85,233.46 v3(28.8,235.42)
  L4 w0.305: v3(28.8,235.42) 36.58,235.42 40.51,231.48 40.51,218.96 39.85,218.3 v5(38.1,218.3)
  BOTTOM w0.305: v3(28.8,235.42) 27.1,237.12 R671.2 ; v3(17.25,233.44) 17.22,233.41 17.22,233.37 16.48,232.63 16.48,232.6 R687.1 ; G1.2 37.34,218.3 v5(38.1,218.3)
CSP1_R: length 6.8
  BOTTOM w0.203: R674.2 21.83,237.6 21.38,237.6 20.46,238.53 U35.14
  BOTTOM w0.305: v2(25.15,238.11) 25.15,237.99 24.47,237.32 R671.1 23.95,237.12 23.89,237.05 C381.1 R674.2
CSP2: length 70.7
  L4 w0.305: v3(22.35,230.49) 22.35,232.87 24.15,234.67 24.42,234.67 26.75,236.99 37.24,236.99 41.94,232.29 41.94,218.22 41.17,217.46 41.17,196.22 40.26,195.31 37.85,195.31 v5(37.52,194.98)
  BOTTOM w0.305: G3.2 v5(37.52,194.98) ; v3(22.35,230.49) 21.79,229.93 v2(21.36,229.93) 20.85,229.93 R693.1 20.35,230.54 R691.2
CSP2_R: length 5.3
  BOTTOM w0.203: v2(19.56,236) 18.66,236.9 U35.18
  BOTTOM w0.305: R691.1 20.35,233.33 20.28,233.4 C388.1 R679.2 20.28,235.28 v2(19.56,236)
CSP3: length 108.3
  L4 w0.305: v3(24.89,231.12) 23.7,229.93 19.33,229.93 16.69,232.57 16.69,234.58 17.17,235.06 18.69,235.06 20.42,236.79 23.8,236.79 26.24,239.23 38.58,239.23 44.58,233.23 44.58,217.05 43.33,215.81 43.33,189.32 34.52,180.51 v3(31.81,180.51)
  BOTTOM w0.305: G6.2 v3(31.81,180.51) ; R690.2 22.8,231.72 22.99,231.53 R692.1 24.49,231.53 v3(24.89,231.12) v2(25.78,231.12)
CSP3_R: length 6.7
  BOTTOM w0.203: U35.16 19.54,237.48 20.1,236.92 20.6,236.92 21.31,236.2 v2(21.46,236.2) 21.76,235.9 21.76,235.64 R678.2
  BOTTOM w0.305: R690.1 22.38,233.31 22.31,233.37 C387.1 R678.2
CTF_TRIP: length 10.2
  TOP w0.102: R391.2 114.74,81.5 113.72,80.48 113.72,77.32 113.77,77.28 v1(113.77,76.29) 113.6,76.12 C755.1 112.08,76.12 110.58,74.62 110.58,74.15 110.57,74.14 Q48.B
CTFB: length 5.2
  TOP w0.102: v1(109.6,79.94) 109.6,79.94 109.6,79.94 109.16,79.5 R354.2 R360.1 109.16,75.63 Q48.C
D_RSMRST_N_1: length 8.3
  BOTTOM w0.254: R1051.2 58.74,37.4 57.9,38.24 57.17,38.24 57.12,38.29 56.81,38.59 v2(56.01,38.59) 55.65,38.59 54.99,39.25 54,39.25 53.44,38.69 R1052.1 53.15,38.95 53.15,38.96 52.78,39.33 52.77,39.33 52.69,39.4 Q105.B
D_RSMRST_N_2: length 12.8
  BOTTOM w0.254: R1053.2 49.84,37.97 50.34,38.46 51.31,38.46 51.87,39.02 51.87,42.36 52.13,42.62 53.85,42.62 54.6,41.88 Q105.C 55.7,41 v2(55.82,40.88) 56.2,40.5 56.2,40.12 56.21,40.12 56.21,40.04 56.46,39.79 56.54,39.79 56.6,39.72 R1044.1
DCBATOUT_1589:
  vias: v1(35.56,81.14)
DCIN_+12V: length 16.7
  TOP w0.508: ATX2.6 10.55,138.55 ; ATX2.6 9.36,137.36 ; ATX2.6 9.36,139.74 ; 9.36,134.36 ATX2.5 ; ATX2.5 10.55,135.55 ; ATX2.5 9.36,136.74
  BOTTOM w0.508: 9.36,137.36 ATX2.6 ; ATX2.6 10.55,138.55 ; ATX2.6 8.17,138.55 ; ATX2.6 9.36,139.74 ; 9.36,134.36 ATX2.5 ; ATX2.5 10.55,135.55 ; ATX2.5 8.17,135.55 ; ATX2.5 9.36,136.74
  vias: v2(16.97,132.75) v2(18.31,130.18) v2(18.87,146.52)
DDPB_AUX_DN: length 305.3
  TOP w0.102: 102.53,243.65 102.53,242.44 102.75,242.22 103.49,242.22 C1.1 ; 102.53,243.65 v1(102.87,243.65) ; 102.53,243.65 102.53,243.99 102.2,244.32 101.89,244.32 v3(101.6,244.62) ; U29.AK6 140.71,67.41 140.03,68.08 v4(140.03,68.21)
  L3 w0.127: v3(101.6,244.62) 101.87,244.34 102.12,244.34 102.48,244.7 102.48,245.51 103.45,246.48 108.8,246.48 109.66,245.62 116.6,245.62 118.26,243.95 118.26,227.24 120.02,225.49 120.47,225.49 121.36,224.6 180.55,224.6 182.63,226.68 184.15,226.68 185.05,225.78 185.05,187.68 178.84,181.47 178.84,156.19 179.72,155.32 179.72,153.54 178.84,152.67 178.84,150.64 178.51,150.31 178.51,121.74 177.15,120.39 177.15,118.23 180.67,114.72 180.67,105.89 177.56,102.78 170.48,102.78 168.97,101.26 167.2,101.26 162.29,96.36 162.29,92.19 161.64,91.54 161.64,83.77 157.85,79.98 157.85,72.52 151.96,66.62 144.69,66.62 143.76,67.55 141.73,67.55 140.87,68.41 140.23,68.41 v4(140.03,68.21)
DDPB_AUX_DN_C: length 6.2
  TOP w0.102: 105.77,242.22 105.05,242.22 C1.2 ; 105.77,242.22 107.39,242.22 107.7,241.91 108.98,241.91 109.12,242.05 NGFF1.20 ; 105.77,242.22 v1(105.77,242.58)
DDPB_AUX_DP: length 305.2
  TOP w0.102: v4(140.03,68.87) 140.03,68.79 140.71,68.12 U29.AK8 ; 102.31,242.66 102.31,242.35 102.66,242 103.49,242 C2.1 ; 102.31,242.66 102.31,243.9 102.11,244.1 101.89,244.1 v3(101.6,243.8) ; 102.31,242.66 v1(101.96,242.66)
  L3 w0.127: v3(101.6,243.8) 101.87,244.08 102.23,244.08 102.74,244.59 102.74,245.4 103.56,246.21 108.69,246.21 109.55,245.35 116.49,245.35 118,243.84 118,227.13 119.9,225.22 120.36,225.22 121.25,224.33 169.35,224.33 169.49,224.19 169.86,224.19 170,224.33 170.37,224.33 170.51,224.19 170.88,224.19 171.02,224.33 171.39,224.33 171.53,224.19 171.89,224.19 172.03,224.33 172.4,224.33 172.54,224.19 172.91,224.19 173.05,224.33 173.42,224.33 173.56,224.19 173.93,224.19 174.07,224.33 174.43,224.33 174.57,224.19 174.94,224.19 175.08,224.33 175.45,224.33 175.59,224.19 175.96,224.19 176.1,224.33 180.66,224.33 182.74,226.41 184.04,226.41 184.78,225.67 184.78,187.79 178.57,181.58 178.57,156.08 179.45,155.21 179.45,153.65 178.57,152.78 178.57,150.75 178.24,150.42 178.24,121.86 176.89,120.5 176.89,118.12 180.4,114.61 180.4,106 177.45,103.04 170.37,103.04 168.86,101.53 167.09,101.53 162.03,96.47 162.03,93.89 162.03,92.3 161.38,91.65 161.38,83.88 157.58,80.09 157.58,72.63 151.85,66.89 144.8,66.89 143.87,67.81 141.84,67.81 140.98,68.68 140.22,68.68 v4(140.03,68.87)
DDPB_AUX_DP_C: length 6.2
  TOP w0.102: NGFF1.22 109.12,241.55 108.98,241.69 107.61,241.69 107.3,242 106.83,242 ; 106.83,242 105.05,242 C2.2 ; 106.83,242 v1(106.83,241.64)
DDPB_CTRL_CLK: length 5
  TOP w0.102: v4(142.42,62.72) 142.42,63.2 142.01,63.61 U29.AM1
  BOTTOM w0.102: v2(141.86,63.31) 141.86,63.28 v4(142.42,62.72) 142.02,62.33 142.02,61.89 142.26,61.66 142.35,61.66 142.36,61.65 142.54,61.65 R995.2
DDPB_CTRL_DATA: length 2.8
  TOP w0.102: v4(139.98,67.52) 139.98,67.42 140.59,66.81 U29.AJ5
  BOTTOM w0.102: v2(140.79,67.55) 140.76,67.52 v4(139.98,67.52) 139.9,67.43 R985.2
DDPC_CTRL_CLK: length 137.1
  TOP w0.102: v4(143.87,65.52) 143.82,65.57 U29.AN3 ; U32.4 63.39,24.73 64.29,23.83 64.29,22.27 65.04,21.52 66.29,21.52 67.82,19.99 67.82,17.36 v3(67.31,16.85)
  L4 w0.127: v3(67.31,16.85) 73.92,16.85 74.76,16.01 79.2,16.01 80.68,17.5 89.86,17.5 90.69,18.32 93.05,18.32 93.72,17.65 95.97,17.65 97.69,19.36 100.07,19.36 102.81,22.1 128.01,22.1 136.8,30.9 138.91,30.9 142.3,34.29 142.3,37.9 141.66,38.55 141.66,39.49 141.72,39.55 141.72,42.15 141.71,42.16 141.71,42.62 142.09,43 142.09,45.94 142.18,46.03 142.5,46.35 142.5,49.85 142.6,49.94 142.6,61.63 142.85,61.88 142.85,62.23 142.82,62.25 142.82,62.54 142.84,62.55 142.84,62.9 142.82,62.91 142.82,63.61 142.91,63.69 142.91,64.04 142.82,64.12 142.82,64.48 v4(143.87,65.52)
  BOTTOM w0.102: R997.2 143.36,59.85 v2(143.16,60.05) 142.57,60.64 142.57,61.15 142.27,61.45 142.17,61.45 141.79,61.83 141.79,62.47 141.35,62.91 141.35,64.04 142.83,65.52 v4(143.87,65.52)
DDPC_CTRL_CLK_CONN: length 26.3
  TOP w0.102: HDMI1.15 48.83,20.37 49.73,19.47 55.62,19.47 56.79,20.64 56.79,21.41 57.74,22.36 59.76,22.36 60.4,21.72 U33.1 U33.10 60.98,23.48 61.42,23.92 U32.3 59.77,24.73 R599.2 59.05,25.45 59.05,26.65 59.37,26.97 C342.1 60.13,26.97 61.01,27.85 v1(61.01,28.43)
DDPC_CTRL_DATA: length 140.2
  TOP w0.102: U29.AM2 141.95,64.72 141.67,64.43 141.67,64.09 141.78,63.98 141.78,61.32 v3(142.09,61.02) ; v3(64.44,29.73) 64.31,29.73 63.73,29.14 62.81,29.14 62.38,28.71 62.38,27.39 61.42,26.43 U32.1
  L4 w0.127: v3(142.09,61.02) 142.34,60.77 142.34,50.05 142.25,49.95 142.25,46.46 141.92,46.13 141.13,45.34 141.13,43.16 141.45,42.83 141.45,42.05 141.46,42.04 141.46,39.65 141.38,39.57 141.38,38.47 142.05,37.8 142.05,34.79 138.4,31.15 135.68,31.15 132.76,28.23 132.76,27.31 127.81,22.36 102.7,22.36 99.97,19.62 97.49,19.62 95.77,17.9 93.83,17.9 93.15,18.58 90.58,18.58 89.82,17.81 80.46,17.81 78.94,16.29 75.11,16.29 73.89,17.51 v3(66.12,17.51)
  BOTTOM w0.102: R998.2 v2(142.95,58.78) 142.6,59.14 142.6,60.11 142.09,60.61 v3(142.09,61.02) ; v3(64.44,29.73) 64.96,29.73 v2(66.55,28.14) 66.85,27.83 66.85,22.76 66.51,22.41 66.51,17.77 66.25,17.51 v3(66.12,17.51)
DDPC_CTRL_DATA_CONN: length 28.5
  TOP w0.102: HDMI1.16 48.33,20.23 49.32,19.24 55.72,19.24 57.02,20.55 57.02,21.31 57.84,22.13 59.66,22.13 60.88,20.91 61.18,20.91 61.46,21.19 U33.2 U33.9 61.46,23.09 62.23,23.86 62.23,25.78 62.48,26.03 U32.6 63.9,26.03 64.39,26.53 64.39,26.91 64.26,27.03 C322.1 R583.2 v1(66.29,27.86)
DDPD_CTRL_CLK: length 2.1
  TOP w0.102: U29.AN4 142.55,66.63 v4(142.42,66.76)
  BOTTOM w0.102: v2(142.42,67.55) v4(142.42,66.76) 142.42,66.53 R991.2
DDPD_CTRL_DATA: length 3.2
  TOP w0.102: U29.AN2 142.45,64.66 142.45,63.9 v4(142.49,63.86)
  BOTTOM w0.102: R993.2 143.21,62.11 v2(143.21,63.1) 142.49,63.82 v4(142.49,63.86)
DDR3_DRAMRST_N: length 172.3
  TOP w0.102: v4(88.86,169.95) 88.86,169.95 CPU1.AK22
  L4 w0.127: v3(88.14,201.14) 87.6,201.67 87.6,202.52 96.65,211.57 102.88,211.57 104.75,213.44 107.29,213.44 108.11,212.62 109.56,212.62 109.57,212.62 112.86,212.62 113.92,211.57 119.54,211.57 121.4,213.43 128.53,213.43 128.81,213.15 134.51,213.15 136.63,211.03 136.63,208.62 140.81,204.43 142.52,204.43 142.52,204.43 146.53,204.43 153.67,197.29 165.14,197.29 171.92,190.51 v3(174.57,190.51)
  BOTTOM w0.102: v3(88.14,201.14) C412.1 87.23,200.26 85.97,199 85.97,198.99 85.65,198.67 85.64,198.67 85.62,198.65 v2(85.62,191.86) 85.62,177.89 85.26,177.53 85.26,170.55 85.72,170.09 88.72,170.09 v4(88.86,169.95) ; R809.1 164.36,179.92 164.44,179.84 168.12,179.84 169.75,181.47 170.75,181.47 172.02,180.2 R808.1 173.04,178.86 173.23,178.67 174.37,178.67 174.88,179.18 174.88,190.2 v3(174.57,190.51)
DDR3_DRAMRST_N_A_1: length 5.5
  TOP w0.102: DIMM1.30 173.75,179 v4(173.93,179.18)
  BOTTOM w0.102: v2(173.35,182.61) 173.04,182.29 C422.1 173.93,180.32 R808.2 v4(173.93,179.18)
DDR3_DRAMRST_N_B_1: length 5.1
  TOP w0.102: DIMM2.30 158.93,179 v4(159,178.93)
  BOTTOM w0.102: v2(158.12,181.97) 158.12,181.15 C423.1 R809.2 158.31,179.63 v4(159,178.93)
DDR_DRVH: length 22.8
  TOP w0.305: U3.9 181.24,195.48 v5(181.05,195.67)
  TOP w0.635: v5(180.09,214.16) 180.01,214.23 v1(179.07,214.23) R56.1
  L4 w0.635: v5(180.09,214.16) 179.93,214 179.93,196.78 v5(181.05,195.67)
DDR_DRVH_R: length 3.4
  TOP w0.635: R56.2 175.36,214.56 v1(174.4,214.56) 173.99,214.16 Q10.4
DDR_DRVL: length 22.5
  TOP w0.254: v5(183.13,195.44) v1(183.13,196.48)
  TOP w0.305: U3.6 182.74,194.79 183.13,195.18 v5(183.13,195.44)
  TOP w0.635: Q18.4 181.15,203.77 v5(181.15,204.33) ; Q13.4 181.15,212.02 v5(181.15,212.61)
  L4 w0.635: v5(183.13,195.44) 183.13,196.2 182.09,197.24 182.09,197.93 181.15,198.87 v5(181.15,204.33) v5(181.15,212.61)
DDR_EN: length 7.8
  TOP w0.254: R104.2 180.4,187.56 180.4,188.46 180.18,188.68 180.17,188.68 C49.1 179.9,189.02 180.06,189.19 180.24,189.19 180.34,189.29 180.37,189.29 180.63,189.54 180.66,189.54 v3(181.15,190.03) 181.74,190.62 U3.3
  BOTTOM w0.254: v3(181.15,190.03) 181.15,189.51 180.85,189.21 180.85,189.21 v2(180.81,189.18) 180.66,189.02 C49.1
DDR_PG: length 5.6
  TOP w0.254: U3.1 180.25,191.35 R98.2 178.56,190.93 178.56,192.24 179.1,192.77 TP3.1
DDR_RCOMP_0: length 6.9
  TOP w0.305: R145.1 74.88,143.52 75.52,144.15 v3(75.52,146.08) 74.66,146.93 CPU1.R1
DDR_RCOMP_1: length 6.7
  TOP w0.305: CPU1.P1 73.75,146.89 v3(72.64,145.78) 72.58,145.72 R146.1
DDR_RCOMP_2: length 7.6
  TOP w0.305: CPU1.R2 74.23,148.6 v3(74.23,144.64) 73.72,144.13 R147.1
DDR_RF: length 3.8
  TOP w0.254: v1(184.94,189.02) R102.1 184.02,189.53 182.74,190.82 U3.5
DDR_SB: length 2.6
  TOP w0.635: C41.1 v1(178.69,205.57) 177.39,205.57 R76.2
DDR_SHDN: length 19.2
  TOP w0.102: R103.2 177.28,188.01 v1(177.75,187.54) 177.27,187.05 176.56,187.05 175.79,186.29 175.79,185.2 175.84,185.15 U4.5 177.34,185.15 177.42,185.07 177.42,184.59 177.33,184.5 U4.6 176.48,183.88 176.78,183.58 177.98,183.58 178.28,183.27 180.16,183.27 180.33,183.44 183.45,183.44 183.71,183.69 R106.2 R105.2
DDR_SW: length 6.7
  TOP w0.305: C46.1 181.1,196.61 181.74,195.97 U3.8
  TOP w0.635: 179.35,200.14 179.35,198.87 180.59,197.63 180.59,197.6 C46.1
  vias: v2(172.24,208.72) v2(177.06,201.2) v5(169.21,205.77) v5(169.32,210.04) v5(169.37,207.86) v5(169.93,211.87) v5(170.43,204.23) v5(171.5,210.27) v5(171.81,202.4) v5(173,211.74) v5(173.15,204.05) v5(173.3,201.15) v5(174.22,205.75)
DDR_TRIP: length 3.7
  TOP w0.254: U3.2 181.24,190.87 180.62,190.26 180.39,190.26 v1(180.11,189.98) 179.93,189.8 179.59,189.8 R99.2
DDR_V5IIN: length 7.1
  TOP w0.305: v3(182.3,195.94) 182.24,195.94 U3.7
  BOTTOM w0.508: R791.2 184.28,192.47 C416.1 183.01,193.66 182.3,194.37 v2(182.3,194.7) 182.12,194.88 182.12,195.76 v3(182.3,195.94)
DDR_VBST: length 4.8
  TOP w0.203: U3.10 180.74,195.15 180.47,195.42 180.47,195.44 v1(179.93,195.97)
  TOP w0.305: U3.10 179.98,194.45
  TOP w0.508: 179.98,194.45 179.68,194.45 179.45,194.67
  TOP w0.635: 179.45,194.67 179.2,194.93 R96.1
DDR_VBST_R: length 3.6
  TOP w0.254: R96.2 177.01,197.88 v1(176.5,197.88)
  TOP w0.635: C46.2 178.26,197.09 R96.2
DDR_VFB: length 4.7
  TOP w0.254: R100.1 PC3.2 R101.1 183.01,189.16 v1(182.19,189.98) 182.19,190.34 182.24,190.38 U3.4
DDR_VREF_PWR:
  vias: v2(141.07,108.59)
DDRVTT_REF: length 5.6
  BOTTOM w0.203: R857.2 136.59,114.08 R858.1 C481.1 135.98,111.71 v2(135.76,111.49) 135.08,111.49 134.75,111.82 U41.3
DDSP_B_HPD: length 308.3
  TOP w0.102: U29.AJ2 140.63,65.03 140.09,64.49 140.09,62.72 v4(140.21,62.59)
  L3 w0.127: v3(121.74,225.51) 122.19,225.07 155.03,225.07 155.13,225.17 156.07,225.17 156.17,225.07 160.04,225.07 162.26,227.29 168.91,227.29 169.15,227.53 183.91,227.53 185.48,225.96 185.48,187.5 179.53,181.55 179.53,160.69 179.88,160.33 179.88,158.06 179.37,157.56 179.37,156.61 180.15,155.83 180.15,152.61 179.88,152.34 179.88,150.53 178.94,149.59 178.94,121.27 177.58,119.91 177.58,118.56 181.1,115.05 181.1,105.71 177.74,102.35 170.66,102.35 169.15,100.83 168,100.83 166.37,99.21 166.37,98.38 165.64,97.65 164.39,97.65 162.79,96.05 162.79,92.08 162.08,91.36 162.08,83.59 158.28,79.8 158.28,72.34 151.97,66.02 147.83,66.02 146.61,64.8 141.24,64.8 140.21,63.77 v4(140.21,62.59)
  BOTTOM w0.102: Q88.S 103.05,242.4 104.12,243.46 104.32,243.46 104.58,243.72 105.44,243.72 106.36,244.64 v2(106.36,244.66) 106.37,244.66 107.14,245.42 107.7,245.98 113.79,245.98 115.27,247.46 116.7,247.46 118.26,245.9 118.26,226.25 119,225.51 v3(121.74,225.51)
DDSP_B_HPD_CONN: length 17.6
  TOP w0.102: NGFF1.31 116.64,239.3 116.51,239.43 115.75,239.43 v3(115.44,239.12)
  L3 w0.127: v3(115.44,239.12) 111.25,239.12 110.11,240.27 108.08,240.27 v3(107.44,240.9)
  BOTTOM w0.102: Q88.D 103.7,242.17 104.43,242.91 104.55,242.91 104.64,243 R654.1 106.05,243 v2(106.87,242.17) 107.14,241.91 107.14,241.22 107.44,240.92 v3(107.44,240.9)
DDSP_B_TX_DN_0: length 142.9
  TOP w0.102: C5.1 103.74,238.87 103.64,238.77 103.64,238.64 103.53,238.53 101.9,238.53 101.07,237.7 101.07,228.96 102.91,227.12 ; CPU1.F17 66.43,162.72 66.43,162.72 66.87,162.28 v3(66.87,162.28) ; 102.91,227.12 104.69,225.35 104.69,217.7 104.36,217.37 104.18,217.37 v3(103.89,217.66) ; 102.91,227.12 v1(102.64,226.86)
  L3 w0.127: v3(103.89,217.66) 103.72,217.49 101.03,217.49 100.83,217.69 97.32,217.69 90.36,210.74 76.14,210.74 72.54,207.15 72.54,205.95 68.22,201.62 61.43,201.62 57.45,197.65 57.45,197.64 54.5,194.69 54.5,166.24 54.42,166.16 54.16,165.9 54.16,165.9 53.63,165.37 53.63,158.6 56.69,155.54 62.34,155.54 63.71,156.9 65.03,156.9 66.4,158.28 66.4,161.8 v3(66.87,162.28)
DDSP_B_TX_DN_0_C: length 5.9
  TOP w0.102: C5.2 105.56,238.87 105.66,238.77 105.66,238.64 105.76,238.53 106.22,238.53 ; 106.22,238.53 106.67,238.53 107.05,238.91 108.98,238.91 109.12,239.05 NGFF1.32 ; 106.22,238.53 v1(106.22,238.9)
DDSP_B_TX_DN_1: length 138.9
  TOP w0.102: 101.19,240.44 102.09,240.44 C3.1 ; 101.19,240.44 100.91,240.44 100.36,239.89 100.36,227.9 103.8,224.46 103.8,218.64 101.82,216.66 100.6,216.66 v3(100.3,216.95) ; 101.19,240.44 v1(101.19,240.8) ; CPU1.G18 67.35,163.63 v3(66.89,163.17)
  L3 w0.127: v3(100.3,216.95) 100.06,216.71 97.43,216.71 90.49,209.78 77.36,209.78 68.49,200.91 61.71,200.91 55.21,194.41 55.21,165.78 54.39,164.97 54.39,159.18 56.94,156.64 59.75,156.64 60.89,157.79 61.95,157.79 62.71,158.55 62.71,161.05 62.97,161.3 63.41,161.3 64.86,162.75 64.86,163.13 65.37,163.64 66.42,163.64 v3(66.89,163.17)
DDSP_B_TX_DN_1_C: length 7.5
  TOP w0.102: C3.2 103.68,240.41 105.41,240.41 ; v1(105.41,240.78) 105.41,240.41 ; 105.41,240.41 108.98,240.41 109.12,240.55 NGFF1.26
DDSP_B_TX_DN_2: length 134.5
  TOP w0.102: v3(67.81,164.13) 68.26,164.58 CPU1.H19
  L3 w0.127: v3(67.81,164.13) 67.39,164.56 66.72,164.56 66.39,164.23 64.86,164.23 64.44,164.66 63.73,164.66 62.63,163.57 62.63,162.49 61.93,161.79 61.93,160.57 59.67,158.31 56.89,158.31 55.18,160.02 55.18,164.64 55.92,165.37 55.92,192.88 62.14,199.11 69.58,199.11 71.63,201.15 71.63,202.55 73.28,204.2 75.85,204.2 80.41,208.76 90.52,208.76 96.24,214.49 100.88,214.49 101.49,215.1 101.49,215.87 101.37,215.99 v3(101.19,215.99)
  BOTTOM w0.102: C374.1 111.42,237.25 111.42,236.67 110.16,235.42 110.16,226.66 106.81,223.3 ; v2(106.6,223.51) 106.81,223.3 ; 106.81,223.3 101.56,218.06 101.56,216.35 v3(101.19,215.99)
DDSP_B_TX_DN_2_C: length 8.8
  TOP w0.102: NGFF1.25 116.97,240.8 116.83,240.66 115.79,240.66 v3(115.49,240.96)
  BOTTOM w0.102: v3(115.49,240.96) 115.19,240.66 114.33,240.66 ; 114.33,240.66 112.73,240.66 111.46,239.39 111.46,238.76 C374.2 ; 114.33,240.66 v2(114.33,240.95)
DDSP_B_TX_DN_3: length 134.3
  TOP w0.102: v3(66.9,165.95) 66.9,165.94 CPU1.G20
  L3 w0.127: v3(66.9,165.95) 66.49,165.54 63.74,165.54 61.88,163.69 61.88,162.73 61.78,162.63 61.78,162.63 58.66,159.51 57.09,159.51 55.93,160.67 55.93,164.17 56.63,164.86 56.63,192.52 62.01,197.9 71.1,197.9 79.18,205.98 81.92,205.98 83.89,207.95 90.77,207.95 94.83,212.01 98.87,212.01 99.05,212.19 99.05,213.23 v3(98.81,213.47)
  BOTTOM w0.102: v2(98.79,218.98) 99.09,218.98 ; 99.09,218.98 99.09,221.88 102.36,225.15 107.74,225.15 109.54,226.95 109.54,237.84 110.4,238.71 110.4,239.66 C368.1 ; 99.09,218.98 99.09,213.75 v3(98.81,213.47)
DDSP_B_TX_DN_3_C: length 9.6
  TOP w0.102: v3(115.47,242.61) 115.77,242.31 116.06,242.31 116.21,242.16 116.83,242.16 116.97,242.3 NGFF1.19
  BOTTOM w0.102: 114.1,242.31 110.83,242.31 110.45,241.93 110.45,241.18 C368.2 ; 114.1,242.31 v2(114.1,242.6) ; 114.1,242.31 115.17,242.31 v3(115.47,242.61)
DDSP_B_TX_DP_0: length 142.8
  TOP w0.102: C6.1 103.74,237.98 103.64,238.08 103.64,238.22 103.53,238.32 101.99,238.32 101.28,237.61 101.28,236.66 ; v1(101.63,236.66) 101.28,236.66 ; 101.28,236.66 101.28,229.05 104.9,225.44 104.9,217.61 104.45,217.15 104.14,217.15 v3(103.89,216.9) ; CPU1.E17 65.52,162.71 v3(65.96,162.28)
  L3 w0.127: v3(65.96,162.28) 66.13,162.1 66.13,158.39 64.92,157.17 63.6,157.17 62.23,155.8 56.8,155.8 53.9,158.71 53.9,165.26 54.61,165.97 54.76,166.13 54.76,194.58 61.54,201.36 68.33,201.36 72.81,205.84 72.81,207.04 76.25,210.47 77.77,210.47 77.91,210.33 78.28,210.33 78.42,210.47 78.79,210.47 78.93,210.33 79.3,210.33 79.44,210.47 79.81,210.47 79.95,210.33 80.31,210.33 80.45,210.47 80.82,210.47 80.96,210.33 81.33,210.33 81.47,210.47 81.84,210.47 81.98,210.33 82.35,210.33 82.49,210.47 82.85,210.47 82.99,210.33 83.36,210.33 83.5,210.47 83.87,210.47 84.01,210.33 84.38,210.33 84.52,210.47 84.89,210.47 85.03,210.33 85.39,210.33 85.53,210.47 85.9,210.47 86.04,210.33 86.41,210.33 86.55,210.47 86.92,210.47 87.06,210.33 87.43,210.33 87.57,210.47 87.93,210.47 88.07,210.33 88.44,210.33 88.58,210.47 88.95,210.47 89.09,210.33 89.46,210.33 89.6,210.47 90.47,210.47 97.43,217.43 100.72,217.43 100.92,217.23 103.56,217.23 v3(103.89,216.9)
DDSP_B_TX_DP_0_C: length 5.9
  TOP w0.102: 107.57,238.69 107.14,238.69 106.76,238.32 105.76,238.32 105.66,238.22 105.66,238.08 105.56,237.98 C6.2 ; 107.57,238.69 v1(107.57,238.34) ; 107.57,238.69 108.98,238.69 109.12,238.55 NGFF1.34
DDSP_B_TX_DP_1: length 139
  TOP w0.102: CPU1.F18 66.45,163.66 v3(66.9,164.12) ; v3(100.3,216.19) 100.56,216.44 101.91,216.44 104.01,218.55 104.01,224.55 101.1,227.45 ; C4.1 102.09,240.22 101,240.22 100.57,239.8 100.57,227.99 101.1,227.45 ; 101.1,227.45 v1(101.37,227.72)
  L3 w0.127: v3(100.3,216.19) 100.05,216.44 97.54,216.44 90.6,209.51 89.52,209.51 89.38,209.37 89.01,209.37 88.87,209.51 88.51,209.51 88.37,209.37 88,209.37 87.86,209.51 87.49,209.51 87.35,209.37 86.98,209.37 86.84,209.51 86.47,209.51 86.33,209.37 85.97,209.37 85.83,209.51 85.46,209.51 85.32,209.37 84.95,209.37 84.81,209.51 84.44,209.51 84.3,209.37 83.93,209.37 83.79,209.51 83.43,209.51 83.29,209.37 82.92,209.37 82.78,209.51 82.41,209.51 82.27,209.37 81.9,209.37 81.76,209.51 81.39,209.51 81.25,209.37 80.89,209.37 80.75,209.51 77.47,209.51 68.6,200.64 61.82,200.64 55.47,194.3 55.47,165.67 54.66,164.86 54.66,159.29 57.05,156.91 59.64,156.91 60.78,158.05 61.84,158.05 62.45,158.66 62.45,161.16 62.86,161.57 63.3,161.57 64.59,162.86 64.59,163.24 65.26,163.91 66.69,163.91 v3(66.9,164.12)
DDSP_B_TX_DP_1_C: length 7.4
  TOP w0.102: 107.42,240.19 103.62,240.19 C4.2 ; 107.42,240.19 v1(107.42,239.84) ; 107.42,240.19 108.98,240.19 109.12,240.05 NGFF1.28
DDSP_B_TX_DP_2: length 134.5
  TOP w0.102: CPU1.G19 67.35,164.61 v3(67.8,165.06)
  L3 w0.127: v3(102.08,215.99) 102.08,215.99 102.08,215.99 101.88,215.99 101.75,215.86 101.75,214.99 100.99,214.22 96.35,214.22 90.63,208.49 80.52,208.49 75.96,203.93 73.39,203.93 71.89,202.44 71.89,201.04 69.69,198.84 69.33,198.84 69.19,198.7 68.82,198.7 68.68,198.84 68.31,198.84 68.17,198.7 67.8,198.7 67.66,198.84 67.29,198.84 67.15,198.7 66.79,198.7 66.65,198.84 66.28,198.84 66.14,198.7 65.77,198.7 65.63,198.84 62.26,198.84 56.18,192.77 56.18,165.26 55.45,164.53 55.45,160.13 57,158.58 59.56,158.58 61.66,160.68 61.66,161.9 62.36,162.61 62.36,163.68 63.62,164.93 64.55,164.93 64.97,164.5 66.28,164.5 66.61,164.83 67.57,164.83 v3(67.8,165.06)
  BOTTOM w0.102: 106.16,222.35 101.78,217.97 101.78,216.29 102.07,215.99 v3(102.08,215.99) ; 106.16,222.35 110.38,226.57 110.38,235.33 111.63,236.58 111.63,237.16 C376.1 ; 106.16,222.35 v2(106.36,222.14)
DDSP_B_TX_DP_2_C: length 8.5
  TOP w0.102: v3(115.49,240.14) 115.79,240.44 116.83,240.44 116.97,240.3 NGFF1.27
  BOTTOM w0.102: v2(112.42,239.61) 112.2,239.82 ; 112.2,239.82 111.68,239.3 111.68,238.76 C376.2 ; 112.2,239.82 112.82,240.44 115.19,240.44 v3(115.49,240.14)
DDSP_B_TX_DP_3: length 134.3
  TOP w0.102: CPU1.F20 65.96,165.96 65.96,165.98 v3(65.97,165.98)
  L3 w0.127: v3(65.97,165.98) 65.8,165.81 63.62,165.81 63.47,165.65 61.62,163.8 61.62,162.84 61.51,162.74 61.51,162.74 58.55,159.78 57.2,159.78 56.2,160.78 56.2,164.06 56.9,164.75 56.9,192.41 62.12,197.63 62.7,197.63 62.84,197.49 63.21,197.49 63.35,197.63 63.72,197.63 63.86,197.49 64.22,197.49 64.36,197.63 64.73,197.63 64.87,197.49 65.24,197.49 65.38,197.63 65.75,197.63 65.89,197.49 66.26,197.49 66.4,197.63 66.76,197.63 66.9,197.49 67.27,197.49 67.41,197.63 67.78,197.63 67.92,197.49 68.29,197.49 68.43,197.63 68.8,197.63 68.94,197.49 69.3,197.49 69.44,197.63 69.81,197.63 69.95,197.49 70.32,197.49 70.46,197.63 71.21,197.63 79.29,205.71 82.03,205.71 84,207.68 86.79,207.68 86.94,207.53 87.31,207.53 87.45,207.67 87.82,207.67 87.96,207.53 88.33,207.53 88.47,207.67 88.83,207.67 88.97,207.53 89.34,207.53 89.48,207.67 89.85,207.67 89.99,207.53 90.36,207.53 90.5,207.67 90.87,207.67 94.94,211.75 98.98,211.75 99.31,212.08 99.31,213.21 99.57,213.47 v3(99.57,213.47)
  BOTTOM w0.102: 99.3,217.71 99.3,213.74 v3(99.57,213.47) ; 99.3,217.71 99.3,221.79 102.45,224.94 107.83,224.94 109.75,226.86 109.75,237.75 110.62,238.62 110.62,239.57 C373.1 ; 99.3,217.71 v2(99.59,217.71)
DDSP_B_TX_DP_3_C: length 9.3
  TOP w0.102: v3(115.47,241.8) 115.77,242.1 115.97,242.1 116.13,241.94 116.83,241.94 116.97,241.8 NGFF1.21
  BOTTOM w0.102: 112.17,242.1 110.92,242.1 110.66,241.84 110.66,241.18 C373.2 ; 112.17,242.1 v2(112.17,241.8) ; 112.17,242.1 115.17,242.1 v3(115.47,241.8)
DDSP_C_HPD: length 117.8
  TOP w0.102: Q84.S 65.72,22.66 67.06,21.32 68.01,21.32 68.28,21.59 68.28,21.97 68.15,22.09 68.15,23.61 v3(68.14,23.62) 68.15,23.63 68.15,24.32 67.46,25 66.61,25 R600.1 ; U29.AH5 v4(140,66.8)
  L4 w0.127: v3(85.6,23.22) 88.2,25.83 98.46,25.83 101.22,28.58 107.64,28.58 111.88,32.83 117.88,32.83 122.16,37.11 134.21,37.11 135.15,38.04 135.15,41.28 135.15,41.28 135.15,44.81 135.6,45.26 135.6,50.47 136.03,50.9 136.03,58.49 137.41,59.87 137.41,64.26 139.95,66.8 v4(140,66.8)
  BOTTOM w0.102: v3(68.14,23.62) 68.17,23.59 68.17,23.3 68.48,23 68.85,23 68.86,22.98 v2(68.89,22.98) 69.58,22.98 71.88,20.68 83.82,20.68 85.6,22.46 v3(85.6,23.22)
DDSP_C_HPD_CONN: length 32.3
  TOP w0.102: Q84.D 65.26,20.75 64.01,22.01 64.01,22.72 63.37,23.35 62.61,23.35 62.5,23.24 U33.7 U33.4 62.5,20.22 R614.2 62.47,19.35 62.2,19.08 61.2,19.08 60.88,19.4 60.88,20.58 59.57,21.9 57.93,21.9 57.25,21.22 57.25,20.45 55.5,18.7 v3(52.98,18.7) 47.64,18.7 46.58,19.76 46.58,20.28 46.83,20.52 HDMI1.19
  BOTTOM w0.102: v2(53.06,19.52) 53.06,18.78 v3(52.98,18.7)
DDSP_C_TX_DN_0: length 170.7
  TOP w0.102: C323.2 46.02,27.92 v3(45.92,28.03) ; v1(49.48,163.15) 49.48,162.78 ; 49.48,162.78 50.78,162.78 53.15,165.15 64.59,165.15 65.16,164.58 CPU1.E19 ; 49.48,162.78 48.87,162.78 v3(48.59,163.06)
  L4 w0.127: v3(48.59,163.06) 48.34,162.81 47.79,162.81 47.4,162.41 47.4,159.03 47.68,158.75 47.68,150.23 48.65,149.25 48.65,145.85 47.76,144.96 47.76,110.15 42.63,105.02 42.63,77.47 42.63,65.5 31.39,54.26 31.39,45.3 31.56,45.14 31.56,45.03 32.58,44.01 32.58,41.02 33.95,39.65 33.95,37.34 40.96,30.32 42.97,30.32 45,28.29 45.66,28.29 v3(45.92,28.03)
DDSP_C_TX_DN_1: length 174.5
  TOP w0.102: CPU1.D20 64.15,165.95 63.57,165.95 63.55,165.93 52.49,165.93 51.5,164.94 ; C337.2 47.19,25.7 46.61,26.27 v3(46.6,26.27) ; v1(51.23,165.21) 51.5,164.94 ; 51.5,164.94 51.02,164.46 48.91,164.46 v3(48.59,164.79)
  L4 w0.127: v3(46.6,26.27) 46.42,26.46 44.01,26.46 41.31,29.17 40.06,29.17 33.13,36.09 33.13,39.37 31.8,40.7 31.8,43.69 30.62,44.87 30.62,54.58 41.86,65.82 41.86,105.34 46.99,110.47 46.99,145.78 47.88,146.67 47.88,148.37 46.6,149.65 46.6,163.24 47.84,164.49 48.29,164.49 v3(48.59,164.79)
DDSP_C_TX_DN_2: length 169.6
  TOP w0.102: v1(49.53,165.62) 49.53,165.97 ; 49.53,165.97 51.21,165.97 51.85,166.62 54.34,166.62 54.62,166.34 61.61,166.34 62.18,166.91 62.93,166.91 63.08,166.76 63.94,166.76 64.19,166.52 64.19,166.25 64.39,166.05 65.16,166.05 CPU1.E21 ; 49.53,165.97 48.89,165.97 v3(48.56,165.65) ; v3(34.14,27.8) 34.26,27.67 C324.2
  L4 w0.127: v3(48.56,165.65) 48.27,165.95 47.88,165.95 46.04,164.11 46.04,146.3 46.48,145.86 46.48,110.69 41.2,105.4 41.2,65.88 29.76,54.44 29.76,45.45 29.76,44.27 31.29,42.73 31.29,39.03 32.21,38.12 32.21,34.29 35.32,31.17 35.32,30.74 35.32,28.46 34.91,28.05 34.42,28.05 34.16,27.8 v3(34.14,27.8)
DDSP_C_TX_DN_3: length 173.2
  TOP w0.102: 51.08,167.96 55.24,167.96 56.02,167.18 61.1,167.18 61.6,167.68 63.61,167.68 63.64,167.71 64.22,167.71 CPU1.D22 ; 51.08,167.96 48.81,167.96 48.49,168.28 48.49,168.3 v3(48.49,168.31) ; 51.08,167.96 v1(51.08,168.31) ; C339.2 v3(34.06,25.51)
  L4 w0.127: v3(34.06,25.51) 34.06,25.58 33.32,26.32 33.32,31.7 31.17,33.86 31.17,37.68 30.25,38.6 30.25,42.3 28.71,43.83 28.71,54.87 38.61,64.76 38.61,72.45 40.02,73.86 40.02,76.34 38.9,77.46 38.9,87.47 40.16,88.73 40.16,105.83 45.44,111.12 45.44,145.17 44.82,145.8 44.82,165.12 47.64,167.94 48.15,167.94 48.49,168.28 v3(48.49,168.31)
DDSP_C_TX_DP_0: length 169.8
  TOP w0.102: C318.2 46.02,28.81 46,28.79 v3(45.92,28.79) ; 50.47,162.56 48.96,162.56 v3(48.59,162.19) ; 50.47,162.56 50.87,162.56 53.24,164.93 64.5,164.93 64.61,164.83 CPU1.D19 ; 50.47,162.56 v1(50.47,162.16)
  L4 w0.127: v3(48.59,162.19) 48.59,162.21 48.26,162.54 47.9,162.54 47.66,162.3 47.66,159.14 47.94,158.86 47.94,158.43 48.08,158.29 48.08,157.92 47.94,157.78 47.94,157.41 48.08,157.27 48.08,156.91 47.94,156.77 47.94,156.4 48.08,156.26 48.08,155.89 47.94,155.75 47.94,155.38 48.08,155.24 48.08,154.87 47.94,154.73 47.94,154.37 48.08,154.23 48.08,153.86 47.94,153.72 47.94,153.35 48.08,153.21 48.08,152.84 47.94,152.7 47.94,152.33 48.08,152.19 48.08,151.83 47.94,151.69 47.94,150.34 48.92,149.36 48.92,145.74 48.03,144.85 48.03,110.04 42.9,104.91 42.9,77.58 42.9,76.42 42.9,76.42 42.9,65.39 31.66,54.15 31.66,45.41 31.82,45.25 31.82,45.14 32.84,44.12 32.84,41.13 34.21,39.76 34.21,37.45 41.08,30.59 43.08,30.59 45.11,28.56 45.69,28.56 v3(45.92,28.79)
DDSP_C_TX_DP_1: length 173.7
  TOP w0.102: CPU1.C20 63.46,165.72 52.58,165.72 51.1,164.25 50.57,164.25 ; v1(50.57,163.84) 50.57,164.25 ; 50.57,164.25 48.91,164.25 v3(48.59,163.92) ; v3(46.64,27.03) 46.69,27.03 47.09,26.63 C334.2
  L4 w0.127: v3(46.64,27.03) 46.34,26.73 44.12,26.73 41.42,29.43 40.17,29.43 33.4,36.2 33.4,39.48 32.07,40.81 32.07,43.8 30.89,44.98 30.89,54.47 42.13,65.71 42.13,76.74 42.13,76.68 42.13,77.26 42.13,105.23 47.26,110.36 47.26,145.67 48.15,146.56 48.15,148.48 47.63,149 47.63,149.2 47.38,149.46 47.17,149.46 46.86,149.76 46.86,150.46 47.02,150.61 47.02,150.97 46.86,151.12 46.86,151.48 47.02,151.63 47.02,151.98 46.86,152.14 46.86,152.49 47.02,152.64 47.02,153 46.86,153.15 46.86,153.51 47.02,153.66 47.02,154.02 46.86,154.17 46.86,154.52 47.02,154.68 47.02,155.03 46.86,155.18 46.86,155.54 47.02,155.69 47.02,156.05 46.86,156.2 46.86,156.56 47.02,156.71 47.02,157.06 46.86,157.22 46.86,163.13 47.96,164.22 48.29,164.22 v3(48.59,163.92)
DDSP_C_TX_DP_2: length 168.2
  TOP w0.102: C320.2 v3(34.14,28.56) ; v1(50.57,166.53) 50.57,166.19 ; 50.57,166.19 51.12,166.19 51.76,166.84 54.43,166.84 54.71,166.56 61.52,166.56 62.09,167.13 63.02,167.13 63.17,166.98 64.03,166.98 CPU1.D21 ; 50.57,166.19 48.89,166.19 v3(48.56,166.51)
  L4 w0.127: v3(48.56,166.51) 48.27,166.21 47.77,166.21 45.77,164.22 45.77,146.19 46.22,145.75 46.22,110.8 40.93,105.51 40.93,65.99 29.49,54.55 29.49,45.56 29.49,45.56 29.49,44.16 31.03,42.62 31.03,38.92 31.94,38.01 31.94,34.18 35.05,31.06 35.05,30.85 35.05,30.85 35.05,28.57 34.8,28.32 34.4,28.32 34.16,28.56 v3(34.14,28.56)
DDSP_C_TX_DP_3: length 171.8
  TOP w0.102: CPU1.C22 63.55,167.46 61.69,167.46 61.19,166.96 55.93,166.96 55.15,167.75 49.53,167.75 ; C336.2 34.21,26.4 v3(34.09,26.27) ; 49.53,167.75 v1(49.53,167.4) ; 49.53,167.75 48.85,167.75 v3(48.54,167.44)
  L4 w0.127: v3(48.54,167.44) 48.31,167.67 47.75,167.67 47.13,167.05 47.13,166.86 46.87,166.59 46.67,166.59 46.41,166.33 46.41,166.14 46.15,165.88 45.95,165.88 45.09,165.01 45.09,164.64 45.22,164.5 45.22,164.13 45.09,163.99 45.09,163.62 45.22,163.48 45.22,163.12 45.09,162.98 45.09,162.61 45.22,162.47 45.22,162.1 45.09,161.96 45.09,161.59 45.22,161.45 45.22,161.08 45.09,160.94 45.09,160.58 45.22,160.44 45.22,160.07 45.09,159.93 45.09,145.91 45.71,145.28 45.71,111.01 40.42,105.72 40.42,88.62 39.17,87.36 39.17,77.57 40.28,76.45 40.28,73.75 38.87,72.34 38.87,64.65 28.98,54.76 28.98,43.95 30.52,42.41 30.52,38.71 31.43,37.79 31.43,33.97 33.59,31.81 33.59,26.43 33.75,26.27 v3(34.09,26.27)
DDSP_D_TX_N0: length 40.4
  TOP w0.102: R1105.2 50.15,24.95 v3(51.28,24.95)
  TOP w0.254: R1092.2 37.53,29.77 37.49,29.73 v3(37.31,29.73) ; R1101.2 R1094.2 49.07,27.8 v3(48.79,27.52) ; v4(39.01,26.97) R1097.2 38.1,27.1 R1103.2 ; v3(38.02,24.93) 38.02,24.72 37.6,24.3 R1109.2 ; v3(49.99,29.85) 49.78,29.85 49.59,29.66 R1091.2
  L3 w0.254: v3(51.28,24.95) 51.28,25.03 v3(48.79,27.52) ; v3(38.02,24.93) 38.02,24.95 38.23,25.16 38.23,25.94 39.01,26.73 v4(39.01,26.97)
  BOTTOM w0.254: v3(37.31,29.73) 37.24,29.65 37.24,28.99 39.01,27.21 v4(39.01,26.97) 39.26,26.97 40.06,27.77 42.82,27.77 45.16,25.43 47.78,25.43 48.79,26.45 v3(48.79,27.52) 48.79,28.86 v2(49.12,29.19) 49.78,29.85 v3(49.99,29.85) 50.19,29.85 50.83,29.22 53.21,29.22 54.74,30.74 Q113.D
DDSP_D_TX_N2: length 5.6
  BOTTOM w0.102: v2(56.97,32.29) 54.91,32.29 Q113.G 52.66,32.36 R1081.2
DGPU_PWROK: length 231.9
  TOP w0.102: PR75.1 48.27,67.72 v3(46.23,69.76) ; v3(47.41,146.92) PR6.2 PR14.2 ; R1229.1 124.38,106.84 v3(125.35,105.88) ; v3(113.89,59.45) 113.66,59.67 113.66,65.29 112.55,66.41 PR78.1
  L3 w0.127: v3(126.28,98.13) 126.28,98.02 125.83,97.57 125.83,92.69 127.76,90.75 127.76,89.18 127.21,88.63 126.78,88.63 125.76,87.61 124.65,87.61 123.96,86.93 123.96,85.82 125.13,84.65 125.13,82.23 124.84,81.94 124.84,80.63 125.04,80.43 125.04,77.15 124.07,76.18 121.74,76.18 120.88,75.33 120.4,75.33 119.7,74.64 118.38,74.64 112.78,69.03 112.78,68.15 109.73,65.1 v3(109.73,58.53) ; v3(47.41,146.92) 47.16,146.67 47.16,110.93 45.16,108.93 45.16,108.83 44.97,108.64 44.97,87.91 43.85,86.79 43.85,82.09 44.7,81.23 44.7,77.98 44.74,77.94 44.74,74.52 44.74,71.25 v3(46.23,69.76) 46.38,69.61 48.28,69.61 65.91,69.61 66.44,69.61 67.2,70.37 67.87,70.37 68.06,70.18 68.06,70.18 v3(68.25,69.99)
  L4 w0.127: v3(109.73,58.53) 109.86,58.53 110.77,59.45 v3(113.89,59.45)
  BOTTOM w0.102: v3(109.73,58.53) 109.73,59.03 103.63,65.13 103.63,66.4 102.57,67.47 86.97,67.47 85.15,65.64 81.38,65.64 81.2,65.82 v2(71.56,65.82) 70.6,66.78 70.53,66.78 70.08,67.24 70.08,68.16 v3(68.25,69.99) ; v3(125.35,105.88) 125.76,105.47 125.76,103.59 126.85,102.5 126.85,100.52 126.31,99.98 126.31,98.34 126.29,98.31 126.29,98.14 v3(126.28,98.13)
DGPU_PWROK_1D5V: length 4.5
  TOP w0.102: v1(48.67,68.82) 48.8,68.82 49.77,67.85 PR75.2 49.68,67.63 49.68,66.79 PC36.1 49.71,66.7 49.61,66.6 49.61,65.69 Q55.G
DIMM_CA_CPU_VREF_A: length 24.8
  TOP w0.254: CPU1.AB38 v3(82.44,184.61)
  BOTTOM w0.254: v3(82.44,184.61) 81.94,185.11 81.94,187.94 83.16,189.16 v2(83.16,192.06) 83.16,198.59 84.05,199.48 C413.1 83.51,201.13 82.68,201.96 82.68,203.55 83.95,204.82 R741.1 R740.1
DIMM_CA_CPU_VREF_RC: length 2.8
  BOTTOM w0.254: R758.1 84.09,203.36 83.54,203.36 83.29,203.11 v2(83.29,202.78) 83.29,202.32 83.59,202.02 C413.2
DIMM_CA_VREF_A: length 142.2
  TOP w0.254: R141.2 C110.1 175.32,147.56 C832.1 175.13,146.67 v4(174.12,147.68) 174,147.8 DIMM1.126
  L4 w0.254: v3(85.47,206.99) 85.47,203.05 87.92,200.61 89.72,200.61 91.32,202.21 108.87,202.21 114,197.09 146.53,197.09 151.64,191.98 154.41,191.98 163.7,182.69 163.7,155.47 166.28,152.89 170.69,152.89 172.5,151.08 172.5,149.3 v4(174.12,147.68)
  BOTTOM w0.254: v3(85.47,206.99) 86.23,206.99 86.4,206.82 v2(86.4,206.33) 86.4,205.93 86.18,205.7 R740.2
DIMM_CA_VREF_A_L: length 3.7
  TOP w0.254: v1(177.39,147.75) 176.6,148.54 R141.1 176.25,149.58 R139.1 R138.2
