# Allegro board Tigris-AIO_Caspian_13048-1.1227WZS1753.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_PRDY_N: length 56.5
  TOP w0.102: v3(75.74,198.87) 75.74,198.28 72.67,195.21 72.67,189.82 71.51,188.67 71.51,185.81 71.92,185.41 CPU1.L39
  BOTTOM w0.102: v3(75.74,198.87) 75.16,199.45 75.16,206.94 75.29,207.06 75.29,217.2 v2(63.59,228.9) 62.39,230.1 62.39,231.88 62.36,231.91 XDPC1.5
H_PREQ_N: length 59.9
  TOP w0.102: v3(73.13,191.37) 73.13,195.3 76.2,198.38 76.2,199.37 v3(75.69,199.88) ; v3(71.46,182.78) CPU1.L37
  BOTTOM w0.102: v3(73.13,191.37) 73.13,188.84 71.78,187.5 71.78,186.42 71.7,186.34 71.7,184.1 71.89,183.91 71.89,183.46 71.46,183.03 v3(71.46,182.78) ; v3(75.69,199.88) 75.51,200.06 75.51,218.8 v2(71.81,222.51) 71.81,222.5 63.89,230.41 63.27,230.41 62.86,230.83 XDPC1.3
H_PROCHOT_N: length 429.7
  TOP w0.102: v3(60.02,57.16) 60.02,57.03 60.05,57.01 R451.1 ; v3(43.66,238.87) 43.37,238.87 37.02,245.22 23.01,245.22 22,246.24 20.94,246.24 19.52,247.66 17.53,247.66 v3(17.07,247.2)
  L3 w0.127: v3(67.06,205.88) 66.93,206 66.93,215.66 60.57,222.02 53.42,222.02 47.37,228.07 47.37,235.16 v3(43.66,238.87) ; v3(94.63,68.51) 94.63,68.5 94.37,68.24 94.37,67.81 92.94,66.38 92.94,65.69 88.71,61.46 87.33,61.46 84.29,64.5 77.37,64.5 69.6,64.5 62.99,57.9 61.26,57.9 60.52,57.16 v3(60.02,57.16)
  L4 w0.127: v3(67.06,205.88) 69.82,208.64 92.83,208.64 96.38,212.2 102.62,212.2 104.52,214.11 107.52,214.11 108.37,213.25 109.3,213.25 109.3,213.26 113.7,213.26 114.39,212.57 119.64,212.57 122.39,215.31 123.64,215.31 125.1,213.85 128.65,213.85 128.97,213.53 134.66,213.53 137.43,210.77 137.43,209.43 141.62,205.24 146.86,205.24 154.34,197.75 165.82,197.75 172.15,191.42 174.33,191.42 176.15,189.6 176.15,173.58 176.63,173.09 176.63,158.74 177.09,158.28 177.09,154.02 177.15,153.96 177.15,142.5 175.79,141.14 175.79,125.08 168.85,118.14 164.83,118.14 163.41,116.72 152.06,116.72 149.26,113.93 149.26,113.85 148.84,113.43 148.84,112.61 147.72,111.49 147.21,111.49 145.29,109.57 145.29,107.6 133.96,96.27 133.39,96.27 132.12,95 132.12,93.89 132.04,93.81 132.04,93.1 132.12,93.03 132.12,91.2 134.58,88.73 134.58,88.19 134.32,87.93 130.8,87.93 130.33,88.4 128.94,88.4 125.62,85.09 118.41,85.09 112.83,79.51 112.83,79.25 106.68,73.11 v3(101.6,73.11)
  BOTTOM w0.102: v3(17.07,247.2) R630.1 ; v3(94.63,68.51) 94.64,68.51 95.22,67.93 98.17,67.93 v2(98.64,68.4) 101.6,71.36 v3(101.6,73.11) ; v3(67.06,205.88) 67.06,205.72 67.69,205.09 R743.1
H_PROCHOT_N_R: length 5.7
  BOTTOM w0.203: C371.1 18.16,243.47 17.05,242.36 U35.3
  BOTTOM w0.254: C371.1 17.72,244.01 v2(17.14,244.59) 17.07,244.66 R630.2
H_PROCHOT_R_N: length 107.4
  TOP w0.102: R1147.2 51.17,151.3 v3(55.14,155.28) ; v3(68.71,205.09) 68.12,204.5 68.12,202.11 68.43,201.8 69.13,201.1 69.66,201.1 72.34,198.42 72.34,190.2 69.89,187.75 69.89,186.89 70.59,186.18 70.59,185.88 70.99,185.48 71.11,185.48 71.37,185.22 71.37,184.52 CPU1.K38
  L3 w0.127: v3(55.14,155.28) 54.74,155.28 52.46,157.55 52.46,163.33 53.2,164.07 53.2,194 54.61,195.41 54.61,199.07 59.93,204.39 67.13,204.39 67.83,205.09 v3(68.71,205.09)
  BOTTOM w0.102: v3(68.71,205.09) 68.71,204.73 67.98,204.01 R743.2 67.61,203.93 v2(67.61,202.98) 67.61,202.7 66.78,201.86 R774.2
H_PWRGD: length 245.5
  TOP w0.102: v3(71.73,212.56) 71.73,210.7 72.96,209.47 C26.1 R58.2 73.22,207.88 74.17,207.88 74.92,207.13 74.92,206.5 82.04,199.37 82.04,193.8 81.02,192.77 81.02,192.72 80.4,192.1 80.4,187.17 80.79,186.78 80.79,185.3 81.42,184.68 81.42,182.58 81.46,182.54 81.46,181.93 CPU1.AB35 ; U29.D40 127.26,84.86 v4(127.48,84.64)
  L4 w0.127: v3(71.73,212.56) 68.28,209.1 62.56,209.1 62,208.55 62,206.31 56.9,201.2 56.9,188.86 56.29,188.25 56.29,169.7 55.59,169.01 55.59,146.99 79.79,122.79 93.01,122.79 93.26,122.54 113.67,102.13 113.67,92.74 120.1,86.31 123.63,86.31 124.21,86.88 124.21,88.5 v3(124.46,88.76)
  BOTTOM w0.102: v3(124.46,88.76) v2(125.45,87.77) 125.96,87.26 125.96,85.87 127.19,84.64 v4(127.48,84.64) ; R696.1 53.39,227.36 54.53,226.22 56.59,226.22 70.26,212.56 v3(71.73,212.56)
H_RSTOUT_XDP_N: length 7.3
  BOTTOM w0.102: XDPC1.46 52.36,242.45 v2(52.96,243.05) 53.88,243.98 54.51,243.98 54.81,244.28 55.51,244.28 R638.2
H_SKTOCC_N: length 159.1
  TOP w0.102: v3(65.06,183.69) CPU1.D38
  L4 w0.127: v3(65.06,183.69) 63.52,183.69 57.81,177.98 57.81,169.12 56.99,168.3 56.99,149.52 79.4,127.11 93.38,127.11 97.3,123.19 100.95,123.19 103.58,125.82 117.69,125.82 131.51,112 131.51,109.44 130.95,108.89 129.96,108.89 v3(126.95,105.88)
  BOTTOM w0.102: R912.2 139.06,95.25 139.52,95.7 139.52,96.08 138.85,96.76 138.81,96.76 138.54,97.03 138.54,99.12 135.06,102.6 130.23,102.6 v2(128.97,103.86) v3(126.95,105.88)
H_SKTOCC_R_N: length 17.5
  TOP w0.102: U29.AE34 137.78,81.33 v4(137.71,81.33)
  BOTTOM w0.102: R926.1 140.12,94.92 139.23,94.03 R912.1 139.01,93.98 139.01,92.58 139.14,92.45 139.14,92.37 139.47,92.04 139.47,91.74 139.45,91.71 139.45,91.11 140.23,90.32 140.23,89.99 140,89.75 139.66,89.75 139.65,89.76 139.45,89.76 138.15,88.46 138.15,87.74 138.63,87.26 138.63,86.16 v2(138.3,85.84) 138.3,85.33 137.82,84.84 137.82,83.12 138.09,82.85 138.09,81.71 v4(137.71,81.33)
H_TCK: length 65.3
  TOP w0.102: CPU1.D39 65.51,185.07 65.08,185.5 64.51,185.5 64.2,185.81 64.2,187.44 65.76,189 65.76,193.74 v3(68.87,196.85)
  BOTTOM w0.102: v3(68.87,196.85) 69.97,196.85 v2(70.18,197.06) 71.2,198.08 71.2,206.94 69.85,208.29 69.85,211.02 60.84,220.02 60.11,220.02 55.18,224.95 51.45,224.95 49.53,226.87 49.53,228.2 49.07,228.66 R699.2 49.07,230.31 49.36,230.6 XDPC1.57
H_TDI: length 75
  TOP w0.102: v3(68.17,193.63) 69.19,192.62 69.19,189.67 67.69,188.17 67.69,185.81 67.44,185.55 67.31,185.55 66.98,185.22 66.98,184.52 CPU1.F38
  BOTTOM w0.102: v3(68.17,193.63) 67.31,193.63 v2(66.21,194.73) 64.41,196.53 64.41,205.89 63.68,206.63 63.68,208.54 46.37,225.85 46.37,236.17 48.14,237.94 49.61,237.94 49.86,238.19 XDPC1.56 49.86,242.42 R644.2
H_TDO: length 76.8
  TOP w0.102: CPU1.F39 67.9,185.61 67.9,187.92 69.42,189.44 69.42,193.71 v3(68.66,194.47)
  BOTTOM w0.102: R639.2 R640.1 R641.1 R642.2 50.04,243.9 50.86,243.08 XDPC1.52 50.86,238.02 50.29,237.45 48.3,237.45 46.83,235.98 46.83,226.28 64.9,208.21 64.9,198.61 v2(65.54,197.97) 68.66,194.85 v3(68.66,194.47)
H_THERMTRIP_N: length 197.4
  TOP w0.102: v3(108.83,90.3) 113.4,90.3 v1(115.29,88.4) 116.43,87.26 v3(119.77,87.26) 119.85,87.18 125.71,87.18 125.96,86.93 125.96,86.55 126.3,86.2 126.69,86.2 126.9,86 126.9,85.5 U29.C40 ; R360.2 108.08,77.71 107.82,77.96 107.82,79.3 107.72,79.4 107.72,80.2 107.91,80.39 108.01,80.39 v3(108.89,81.26)
  L3 w0.127: v3(108.89,81.26) 109.56,81.94 109.56,89.57 v3(108.83,90.3)
  L4 w0.127: v3(119.77,87.26) 120.51,88 120.51,90.01 114.94,95.59 114.94,102.83 93.83,123.94 80.96,123.94 56.28,148.62 56.28,168.72 56.97,169.42 56.97,187.94 58.04,189.01 58.04,197.1 64.04,203.1 65.98,203.1 66.41,203.53 67,203.53 69.6,200.93 v3(69.6,200.01)
  BOTTOM w0.102: v3(69.6,200.01) 69.98,200.39 R771.1
H_TMS: length 73.1
  TOP w0.102: CPU1.E39 66.43,185.29 66.1,185.62 66.1,188.58 67.69,190.16 v3(67.69,191.7)
  BOTTOM w0.102: v3(67.69,191.7) 67.69,192.31 v2(67.24,192.76) 64.14,195.87 64.14,205.85 63.45,206.53 63.45,208.45 46.14,225.76 46.14,236.26 48.05,238.17 49.23,238.17 49.36,238.29 XDPC1.58 49.36,242.22 47.32,244.26 46.75,244.26 R645.2
H_TRST_N: length 76.1
  TOP w0.102: v3(65.98,182.78) CPU1.E37
  BOTTOM w0.102: v3(65.98,182.78) 65.98,187.68 68.63,190.33 68.63,193.82 v2(65.88,196.58) 64.64,197.81 64.64,208.14 46.6,226.19 46.6,236.07 48.24,237.71 49.93,237.71 50.36,238.13 XDPC1.54 50.36,242.67 48.77,244.26 R643.2
H_VID0: length 112.7
  TOP w0.102: PR39.1 v3(48.51,135.32) PR40.1 v1(49.31,134.32) ; U13.T8 79.96,81.14 v4(80.33,80.77)
  L3 w0.127: v3(48.51,135.32) 48.51,110.63 46.8,108.91 46.8,108.85 46.12,108.17 46.12,86.6 45.85,86.33 45.85,85.59 45.85,85.59 45.85,78.45 45.88,78.42 45.88,74.89 45.88,74.89 45.88,73.62 45.9,73.61 45.9,73.61 48.76,70.75 49.18,70.75 65.96,70.75 66.89,71.68 69.49,71.68 69.66,71.5 76.71,71.5 78.67,71.5 78.78,71.61 80.34,73.17 80.34,80.76 v4(80.33,80.77)
  BOTTOM w0.102: v3(48.51,135.32) PR40.1 v2(49.31,134.35)
H_VID1: length 107.6
  TOP w0.102: v4(79.28,73.26) 79.28,73.8 78.46,74.62 78.46,75.16 78.22,75.4 78.11,75.4 77.34,76.17 77.34,76.94 77.35,76.95 U13.N1 ; PR37.1 v3(48.51,136.33) PR38.1
  L3 w0.127: v4(79.28,73.26) 77.74,71.73 77.18,71.73 77.18,71.73 76.8,71.73 69.76,71.73 69.58,71.9 66.72,71.9 66.11,71.29 66.11,71.25 65.86,71 48.86,71 46.15,73.71 46.15,73.71 46.14,73.73 46.14,74.93 46.14,74.93 46.14,78.52 46.1,78.56 46.1,86.23 46.37,86.5 46.37,108.07 47.18,108.88 47.18,108.91 48.98,110.72 48.98,135.86 v3(48.51,136.33)
  BOTTOM w0.102: v2(47.83,135.77) 48.39,136.33 v3(48.51,136.33) PR38.1
H_VID2: length 113.6
  TOP w0.102: PR35.1 v3(48.51,137.35) PR36.1 ; v4(78.87,81.53) 78.48,81.14 U13.P8
  L3 w0.127: v3(48.51,137.35) 49.24,136.62 49.24,110.82 49.24,110.59 47.54,108.89 47.54,108.88 46.63,107.96 46.63,86.39 46.35,86.12 46.35,78.66 46.39,78.63 46.39,74.97 46.39,74.97 46.39,73.83 46.41,73.82 46.41,73.82 48.97,71.26 65.75,71.26 66.63,72.13 69.82,72.13 70,71.95 77.09,71.95 78.8,73.67 78.98,73.67 80.05,74.74 80.05,76.53 77.85,78.72 77.85,80.51 v4(78.87,81.53)
  BOTTOM w0.102: v2(47.73,137.07) 48.23,137.07 v3(48.51,137.35) PR36.1
H_VID3: length 125.1
  TOP w0.102: PR33.1 v3(48.51,138.36) PR32.1 ; U13.AK10 90.56,82.33 v4(91.36,82.33)
  L3 w0.127: v4(91.36,82.33) 88.49,79.46 84.81,79.46 80.8,75.45 80.8,74.15 80.8,72.91 78.89,71 69.44,71 69.25,71.19 67.13,71.19 66.18,70.24 49.39,70.24 49.39,70.24 48.54,70.24 45.39,73.39 45.39,73.4 45.38,73.41 45.38,74.8 45.38,74.81 45.38,78.21 45.34,78.24 45.34,85.38 45.34,85.38 45.34,86.54 45.61,86.81 45.61,108.38 46.06,108.83 46.06,108.93 47.79,110.66 47.79,111.19 47.79,137.65 48.51,138.36 v3(48.51,138.36)
  BOTTOM w0.102: v2(47.62,138.36) v3(48.51,138.36) PR33.1
H_VID4: length 127.9
  TOP w0.102: PR30.1 v3(48.51,139.38) PR31.1 ; U13.AM10 91.64,82.74 v4(92.02,82.36)
  L3 w0.127: v3(48.51,139.38) 47.54,138.4 47.54,111.09 47.54,110.77 45.7,108.93 45.7,108.83 45.36,108.49 45.36,86.92 45.08,86.65 45.08,85.28 45.09,78.14 45.12,78.1 45.12,74.67 45.12,73.31 45.14,73.29 45.14,73.29 48.44,69.99 49.49,69.99 66.28,69.99 67.24,70.94 69.15,70.94 70.15,69.94 75.06,69.94 75.49,70.37 78.64,70.37 81.03,72.76 81.03,73.81 81.03,74.25 81.03,74.66 81.92,75.55 81.92,75.93 85.22,79.23 88.77,79.23 91.46,81.91 91.54,81.91 91.98,82.36 v4(92.02,82.36)
  BOTTOM w0.102: PR31.1 v3(48.51,139.38) 48.21,139.68 v2(47.62,139.68)
H_VID5: length 119.7
  TOP w0.102: U13.T9 79.9,81.94 80.26,81.58 v4(80.26,81.52) ; PR26.1 v3(48.51,140.4) PR25.1
  L3 w0.127: v4(80.26,81.52) 80.52,81.52 81.03,81.01 81.03,76.01 80.57,75.55 80.57,73.08 78.75,71.26 69.55,71.26 69.42,71.38 69.42,71.38 69.36,71.45 67.02,71.45 66.07,70.49 49.28,70.49 48.65,70.49 45.64,73.5 45.64,73.5 45.63,73.52 45.63,74.85 45.63,78.31 45.59,78.35 45.59,85.49 45.59,85.49 45.59,86.44 45.86,86.71 45.86,108.28 46.43,108.84 46.43,108.92 48.04,110.54 48.04,137.54 48.32,137.82 48.63,137.82 48.98,138.17 48.98,139.93 v3(48.51,140.4)
  BOTTOM w0.102: PR26.1 v3(48.51,140.4) 47.96,140.95 v2(47.75,140.95)
H_VID6: length 3.5
  TOP w0.102: PR23.1 v3(48.51,141.41) PR24.1
  BOTTOM w0.102: v3(48.51,141.41) PR24.1 v2(49.31,142.35)
H_VIDALERT_N: length 3.4
  BOTTOM w0.102: R742.2 v2(61.02,206.05) ; R742.2 61.88,205.09 R746.1 ; R742.2 R749.2
H_VIDALERT_N_1: length 26.4
  TOP w0.152: CPU1.B37 63.47,183.24 61.85,184.87 61.85,186.83 58.41,190.27 58.41,200.41 58.81,200.81 v3(58.83,200.81)
  BOTTOM w0.152: v3(58.83,200.81) 58.87,200.81 59.12,200.56 61.39,200.56 61.59,200.76 61.59,201.28 R768.1 62.21,201.95 v2(62.21,202.93) R746.2
H_VIDALERT_N_VR: length 71.2
  TOP w0.152: v3(43.56,237.09) 43,237.09 35.53,244.56 20.57,244.56 v3(18.72,242.71)
  BOTTOM w0.152: v3(43.56,237.09) 43.08,236.61 43.08,227.38 59.13,211.33 59.13,206.09 v2(59.25,205.97) R742.1 ; U35.5 17.85,241.85 v3(18.72,242.71) 19.3,243.3 R649.2
H_VIDSCK: length 28.1
  TOP w0.152: v3(58.94,199.95) 58.69,199.71 58.69,190.6 62.26,187.03 62.26,184.81 63.35,183.72 64.17,183.72 CPU1.C38
  BOTTOM w0.152: R745.2 R767.2 63.18,201.98 62.74,201.53 62.74,199.91 62.43,199.6 v2(60.83,199.6) 59.33,199.6 58.98,199.95 v3(58.94,199.95)
H_VIDSCK_VR: length 71.1
  TOP w0.152: v3(19.68,242.71) 21.25,244.28 35.42,244.28 42.89,236.81 42.95,236.81 v3(43.56,236.2)
  BOTTOM w0.152: U35.6 18.25,241.53 18.84,242.12 19.09,242.12 v3(19.68,242.71) 20.35,243.37 R648.2 ; R745.1 v2(62.39,205.76) 59.41,208.73 59.41,211.44 43.56,227.29 v3(43.56,236.2)
H_VIDSOUT: length 26.2
  TOP w0.152: CPU1.C37 64.17,182.81 63.48,182.81 61.59,184.7 61.59,186.42 58.13,189.88 58.13,201.12 v3(58.67,201.66)
  BOTTOM w0.152: v2(57.78,201.79) 58.55,201.79 v3(58.67,201.66) 58.93,201.66 59.56,201.03 R770.2 R769.2
H_VIDSOUT_VR: length 78.5
  TOP w0.152: v3(43.56,237.98) 42.55,237.98 35.69,244.84 21.69,244.84 v3(19.33,247.2)
  BOTTOM w0.152: v3(43.56,237.98) 42.8,237.22 42.8,227.26 58.67,211.39 58.67,203.19 v2(59.01,202.86) R770.1 ; v3(19.33,247.2) 19.33,246.43 R629.2 18.67,245.77 18.67,243.37 17.48,242.18 17.48,241.99 17.45,241.96 U35.4
HDD_LED_5V: length 2
  TOP w0.508: 7.62,42.04 PWRCN1.1 8.61,41.05
HDMI_LANE0_DN: length 11.6
  TOP w0.102: TR4.2 53.48,27.96 53.71,28.2 53.81,28.2 54.09,27.92 54.36,27.92 54.49,27.78 U27.2 U27.9 56.15,27.78 56.29,27.92 57.11,27.92 57.32,27.71 57.32,25.34 56.31,24.33 55.51,24.33 54.83,23.65 HDMI1.3
HDMI_LANE0_DN_C: length 4.8
  TOP w0.102: TR4.1 50.65,27.96 R1094.1 49.89,28.39 48.16,28.39 C323.1
HDMI_LANE0_DP: length 12.7
  TOP w0.102: 57.53,27.42 57.53,25.25 56.4,24.11 55.6,24.11 55.19,23.71 55.19,23.56 55.3,23.45 55.7,23.45 55.83,23.33 HDMI1.1 ; 57.53,27.42 v1(57.87,27.42) ; 57.53,27.42 57.53,27.8 57.2,28.13 56.29,28.13 56.15,28.26 U27.10 U27.1 54.49,28.26 54.36,28.13 54.18,28.13 53.9,28.41 53.71,28.41 53.48,28.65 TR4.3
HDMI_LANE0_DP_C: length 5.1
  TOP w0.102: TR4.4 50.9,28.65 R1091.1 50.46,29.07 50,28.61 48.67,28.61 ; 48.67,28.61 v1(48.67,28.97) ; 48.67,28.61 47.89,28.61 C318.1
HDMI_LANE1_DN: length 10.7
  TOP w0.102: TR6.2 53.5,25.81 53.83,26.13 54.24,26.13 54.37,26.26 U27.5 U27.6 56.15,26.26 56.29,26.4 56.39,26.4 56.59,26.19 56.59,25.6 56.04,25.05 53.98,25.05 53.33,24.41 ; v3(53.11,24.62) 53.33,24.41 ; 53.33,24.41 53.24,24.32 53.24,23.61 53.33,23.52 HDMI1.6
HDMI_LANE1_DN_C: length 5.1
  TOP w0.102: v3(48.62,24.86) 48.37,25.11 C337.1 48.74,26.07 50.11,26.07 50.48,25.7 R1105.1 50.78,25.81 TR6.1
HDMI_LANE1_DP: length 11.4
  TOP w0.102: HDMI1.4 54.33,23.35 54.18,23.5 53.65,23.5 53.45,23.7 53.45,24.23 54.06,24.84 56.13,24.84 56.81,25.51 56.81,26.28 56.48,26.61 56.29,26.61 56.15,26.74 U27.7 U27.4 54.55,26.74 54.15,26.35 53.67,26.35 53.53,26.49 TR6.3
HDMI_LANE1_DP_C: length 4
  TOP w0.102: TR6.4 50.78,26.49 R1101.1 50.42,26.78 49.92,26.29 48.72,26.29 C334.1
HDMI_LANE2_DN: length 16
  TOP w0.102: HDMI1.9 51.83,23.29 51.99,23.45 52.43,23.45 52.54,23.57 52.54,23.72 52.1,24.16 47.6,24.16 45.91,25.85 45.91,26.13 44.49,27.56 U31.4 U31.7 42.54,27.56 42.12,27.98 41.74,28.36 41.41,28.36 41.14,28.09 TR5.2
HDMI_LANE2_DN_C: length 4.4
  TOP w0.102: 36.73,28.1 37.99,28.1 R1097.1 38.46,28.09 TR5.1 ; 36.73,28.1 v3(36.73,27.85) ; 36.73,28.1 36.31,28.1 C324.1
HDMI_LANE2_DP: length 17.2
  TOP w0.102: HDMI1.7 52.83,23.13 52.76,23.2 52.76,23.81 52.19,24.38 47.69,24.38 46.13,25.94 46.13,26.22 44.31,28.03 U31.5 U31.6 42.37,28.03 42.27,28.13 41.63,28.77 TR5.3 40.88,29.28 v1(40.26,29.91)
HDMI_LANE2_DP_C: length 5.3
  TOP w0.102: TR5.4 38.33,28.77 R1092.1 38.19,28.88 37.63,28.32 36.12,28.32 C320.1 35.79,28.65 35.79,29.55 v1(35.69,29.65)
HDMI_LANE3_DN: length 13
  TOP w0.102: HDMI1.12 50.33,23.16 50.15,23.34 47.43,23.34 46.62,24.15 44.73,26.04 U31.1 U31.10 42.55,26.04 42.42,26.17 42.17,26.17 41.93,25.93 41.93,25.93 41.44,25.44 ; 41.44,25.44 41.27,25.28 41.01,25.28 40.78,25.04 TR7.2 ; 41.44,25.44 v3(41.66,25.23)
HDMI_LANE3_DN_C: length 5.3
  TOP w0.102: v1(35.28,24.42) 35.28,24.91 C339.1 36.08,25.71 36.69,25.71 R1109.1 37.59,25.57 38.03,25.57 38.31,25.3 38.65,25.3 38.9,25.04 TR7.1
HDMI_LANE3_DP: length 15.4
  TOP w0.102: v1(41.22,26.93) 41.22,26.88 40.43,26.09 TR7.3 40.81,25.72 41.04,25.49 41.18,25.49 42.08,26.38 42.43,26.38 42.56,26.51 U31.9 U31.2 44.31,26.51 44.57,26.25 44.82,26.25 46.71,24.37 47.52,23.56 51,23.56 51.33,23.23 HDMI1.10
HDMI_LANE3_DP_C: length 5.4
  TOP w0.102: C336.1 36.35,25.93 36.93,25.93 R1103.1 37.63,25.79 38.12,25.79 38.4,25.51 38.66,25.51 38.87,25.72 TR7.4 39.23,25.72 39.88,26.37 v1(39.88,26.86)
HPOL_CON: length 16.1
  TOP w0.203: R265.2 186.45,92.95 187.84,94.34 R261.2 188.19,94.05 v3(188.19,93.07) 188.19,92.82 188.42,92.59 R1121.2 188.93,92.61 R262.1 C170.1
  L4 w0.203: UHS1.1 191.5,90.25 191.5,91.54 190.45,92.59 188.67,92.59 v3(188.19,93.07)
  BOTTOM w0.203: v2(189.1,92.06) 189.1,92.16 v3(188.19,93.07) 187.67,92.55 Q97.1
HPOR_CON: length 53.2
  TOP w0.203: v3(190.35,91.45) 190.25,91.55 R1122.2 ; R351.2 178.56,80.06 C210.1 ; C210.1 R337.1 R324.2 ; C210.1 178.63,79.68 v3(179.02,79.28) 179.21,79.47 185.51,79.47 185.88,79.1 192.53,79.1 196.09,82.66 199.19,82.66 UHS1.2
  BOTTOM w0.203: v3(179.02,79.28) 179.02,80.13 180.86,81.98 182.75,81.98 182.91,82.13 188.11,82.13 188.27,82.28 188.29,82.28 189.89,83.88 189.89,90.61 190.35,91.07 v3(190.35,91.45) 189.43,91.45 188.59,90.61 v2(188.59,90.58) Q97.2
HPOUT-JD: length 12
  TOP w0.203: UHS1.6 192.4,80.32 191.64,79.56 186.11,79.56 185.17,80.5 v1(184.4,80.5) 183.83,80.5 R332.1
HPOUT-L: length 32.2
  TOP w0.203: v3(176.63,83.88) 176.96,84.21 177.02,84.21 177.32,84.51 177.32,84.51 177.52,84.71 U16.26 ; v4(186.33,93.74) 186.94,94.34 R261.1
  L4 w0.203: v3(176.63,83.88) 177.22,83.88 179.45,81.64 182.25,81.64 183.95,79.94 188.16,79.94 188.47,80.25 188.47,82.91 186.51,84.87 186.51,93.56 v4(186.33,93.74)
  BOTTOM w0.203: v2(176.63,83.04) v3(176.63,83.88)
HPOUT-R: length 11.2
  TOP w0.203: R351.1 177.11,79.17 176.97,79.31 v1(176.2,79.31) 175.97,79.08 175.2,79.08 174.88,79.4 174.88,82.28 175.87,83.27 176.74,83.27 177.14,83.67 177.14,83.86 177.45,84.18 177.92,84.65 U16.27
HSI_C_DN5: length 197.8
  L3 w0.127: v3(183.03,165.24) 183.49,165.24 184.94,163.79 184.94,162.19 183.84,161.09 183.84,148.53 181.14,145.83 180.99,145.68 180.99,123.37 185.45,118.91 185.45,105.23 181.72,101.5 181.72,100.3 180.48,99.06 176.88,99.06 174.2,96.38 168.97,96.38 166.29,93.7 166.29,80.86 165.01,79.58 165.01,78.2 164.44,77.63 164.44,75.16 161.91,72.63 161.91,70.92 158.97,67.97 158.97,62.38 156.52,59.93 148.55,59.93 147.03,58.42 143.49,58.42 140.3,55.22 140.3,55.21 140.02,54.93 140.01,54.93 139.64,54.57 138.99,54.57 137.2,52.78 130.15,52.78 126.94,55.99 123.16,55.99 122.47,56.69 122.47,63.09 121.62,63.94 121.62,66.2 121.97,66.56 122.73,66.56 122.86,66.43 122.86,66.2 v4(122.56,65.9)
  BOTTOM w0.102: C644.2 125.49,64.54 125.49,64.05 125.18,63.75 123.69,63.75 122.56,64.88 v4(122.56,65.9) ; 181.74,165.77 182.88,165.77 183.03,165.62 v3(183.03,165.24) ; 181.74,165.77 v2(181.74,165.44) ; 181.74,165.77 178.13,165.77 177.32,164.96 177.32,159.65 178.57,158.39 178.72,158.39 178.81,158.48 U39.8
HSI_C_DP5: length 200.4
  L3 w0.127: v4(123.32,65.9) 123.13,66.09 123.13,66.54 122.84,66.82 121.86,66.82 121.35,66.31 121.35,63.83 122.2,62.98 122.2,56.58 123.05,55.72 126.83,55.72 130.04,52.51 137.31,52.51 139.1,54.3 139.75,54.3 140.12,54.67 140.13,54.67 140.56,55.1 140.56,55.11 143.6,58.15 147.14,58.15 148.66,59.66 156.63,59.66 159.23,62.27 159.23,67.86 162.18,70.81 162.18,72.52 164.71,75.05 164.71,77.52 165.28,78.09 165.28,79.47 166.56,80.75 166.56,93.59 169.08,96.11 174.31,96.11 176.99,98.79 180.59,98.79 181.99,100.19 181.99,101.39 185.71,105.11 185.71,119.02 181.25,123.48 181.25,145.57 184.11,148.42 184.11,148.64 184.11,160.98 185.21,162.08 185.21,163.9 183.62,165.49 v3(183.62,165.92)
  BOTTOM w0.102: v3(183.62,165.92) 183.57,165.87 183.08,165.87 182.97,165.99 178.04,165.99 177.1,165.05 177.1,159.56 178.49,158.17 178.72,158.17 178.81,158.08 U39.7 ; v4(123.32,65.9) 123.32,65.64 123.19,65.52 122.9,65.52 122.77,65.39 122.77,64.97 123.78,63.97 125.09,63.97 125.27,64.14 125.27,64.7 125.18,64.8 C643.2
HSI_DN2: length 187.5
  TOP w0.102: v3(111.41,218.35) 111.41,218.15 111.51,218.06 112.33,218.06 114.81,215.58 114.81,206.7 112.89,204.78 112.89,130.33 117.41,125.8 117.41,117.47 117.61,117.28 117.61,116.85 117.71,116.75 118.15,116.75 118.25,116.65 v3(118.25,116.32) ; U29.F14 127.98,70.8 v4(128.14,70.64)
  BOTTOM w0.102: v3(111.41,218.35) 111.11,218.06 110.81,218.06 109.8,217.05 109.09,217.05 107.71,218.44 107.71,223.02 111,226.31 111,231.07 112.36,232.43 112.36,233.05 R664.2 ; 118.05,104.42 119.64,106.01 119.64,113.85 119.64,114.03 117.85,115.83 117.85,116.21 117.95,116.32 v3(118.25,116.32) ; 118.05,104.42 117.47,103.84 117.47,76.54 120.03,73.98 120.03,71.9 121.22,70.71 124.73,70.71 125.32,70.12 128.36,70.12 128.46,70.21 128.46,70.51 128.32,70.64 v4(128.14,70.64) ; 118.05,104.42 v2(118.26,104.2)
HSI_DN3: length 173.8
  TOP w0.102: v4(128.02,69.44) 128.29,69.72 U29.F11 ; v3(114.69,117) 114.69,117.23 114.59,117.33 114.11,117.33 114.01,117.43 114.01,127.05 111.51,129.55 111.51,205.22 113.5,207.21 113.5,212.29 110.22,215.57 110.22,218.56 109.97,218.82 109.79,218.82 v3(109.47,219.14)
  BOTTOM w0.102: v3(109.47,219.14) 109.47,219.13 109.16,218.82 109.03,218.82 108.84,219.01 108.84,220.77 R685.2 ; 121.54,68.88 125.03,68.88 125.48,69.33 127.3,69.33 127.67,68.96 128.24,68.96 128.35,69.06 128.35,69.28 128.18,69.44 v4(128.02,69.44) ; 121.54,68.88 121.12,68.88 119.26,70.74 117.01,70.74 116.22,71.52 116.22,104.61 118.36,106.75 118.36,113.27 115.95,115.68 114.71,115.68 114.24,116.15 114.24,116.91 114.33,117 v3(114.69,117) ; 121.54,68.88 v2(121.54,69.17)
HSI_DN5: length 6.8
  TOP w0.102: v4(128.78,68.18) 128.61,68.18 128.4,68.39 128.4,68.74 128.53,68.87 U29.G9
  BOTTOM w0.102: 127,67.52 126.01,67.52 125.5,67.01 125.5,65.94 C644.1 ; 127,67.52 128.33,67.52 128.52,67.72 128.52,67.93 v4(128.78,68.18) ; 127,67.52 v2(127,67.17)
HSI_DP2: length 187.1
  TOP w0.102: v3(111.41,217.54) 111.71,217.84 112.24,217.84 114.59,215.49 114.59,206.79 112.67,204.87 112.67,130.24 117.2,125.71 117.2,117.38 117.39,117.19 v3(117.39,116.25) ; U29.G14 128.7,70.85 v4(128.91,70.64)
  BOTTOM w0.102: 119.81,73.49 119.81,71.81 121.14,70.49 124.64,70.49 125.23,69.9 128.45,69.9 128.67,70.13 128.67,70.41 v4(128.91,70.64) ; 119.81,73.49 v2(119.51,73.49) ; 119.81,73.49 119.81,73.9 117.26,76.45 117.26,103.93 119.43,106.1 119.43,113.94 117.89,115.47 117.8,115.57 117.8,115.57 117.63,115.74 117.63,116.01 v3(117.39,116.25) ; R659.2 112.14,233.09 112.14,232.52 110.78,231.16 110.78,226.4 107.49,223.11 107.49,218.35 109,216.84 109.89,216.84 110.9,217.84 111.11,217.84 v3(111.41,217.54)
HSI_DP3: length 173.5
  TOP w0.102: v4(128.7,69.48) 129,69.78 U29.H11 ; v3(109.47,218.3) 109.78,218.6 109.88,218.6 110.01,218.47 110.01,215.48 113.28,212.2 113.28,207.3 111.29,205.31 111.29,129.46 113.79,126.96 v3(113.79,117)
  BOTTOM w0.102: 122.78,68.66 125.12,68.66 125.57,69.11 127.21,69.11 127.58,68.75 128.33,68.75 128.56,68.97 128.56,69.34 v4(128.7,69.48) ; 122.78,68.66 v2(122.78,68.36) ; 122.78,68.66 121.03,68.66 119.17,70.52 116.92,70.52 116.01,71.43 116.01,104.7 118.15,106.84 118.15,113.18 115.86,115.47 114.62,115.47 114.03,116.06 114.03,116.77 v3(113.79,117) ; v3(109.47,218.3) 109.17,218.6 108.94,218.6 108.62,218.92 108.62,220.74 R680.2
HSI_DP5: length 6.9
  TOP w0.102: v4(127.99,68.22) 128.18,68.41 128.18,68.67 U29.F9
  BOTTOM w0.102: v4(127.99,68.22) 128.02,68.25 128.2,68.25 128.3,68.15 128.3,67.8 128.24,67.74 125.92,67.74 125.48,67.29 ; 125.48,67.29 v2(125.25,67.52) ; 125.48,67.29 125.29,67.1 125.29,65.96 125.01,65.69 C643.1
HSI_LAN_DN4: length 113.1
  TOP w0.102: 36.91,40.64 36.29,40.64 C285.2 ; 36.91,40.64 v1(36.91,41) ; 36.91,40.64 37.43,40.64 37.94,41.15 37.94,41.92 37.71,42.15 v3(37.54,42.15) ; U29.J11 130.04,69.64 130.04,69.31 v4(130.03,69.3)
  L4 w0.127: v4(130.03,69.3) 130.03,69.06 129.98,69.01 127.77,69.01 126.86,68.1 115.2,68.1 108.81,61.71 96.12,61.71 95.41,60.99 82.3,60.99 81.43,61.86 77.72,61.86 72.27,56.41 62.52,56.41 61.86,55.75 45.28,55.75 37.47,47.94 37.47,43.07 37.84,42.69 37.84,42.45 v3(37.54,42.15)
HSI_LAN_DN4_R: length 7.3
  TOP w0.102: 32.79,39.57 33.18,39.57 34.35,40.73 34.82,40.73 C285.1 ; 32.79,39.57 v1(32.79,39.94) ; 32.79,39.57 30.06,39.57 29.78,39.29 U26.18
HSI_LAN_DP4: length 113.5
  TOP w0.102: C286.2 36.29,40.43 37.52,40.43 37.64,40.55 ; v4(130.67,69.32) 130.6,69.38 U29.L11 ; 37.64,40.55 38.16,41.06 38.16,41.9 v3(38.4,42.15) ; 37.64,40.55 v1(38.04,40.15)
  L4 w0.127: v4(130.67,69.32) 130.09,68.74 127.88,68.74 126.97,67.83 115.31,67.83 108.92,61.44 96.23,61.44 95.52,60.73 82.19,60.73 81.32,61.59 77.83,61.59 72.38,56.14 62.63,56.14 61.97,55.48 45.39,55.48 37.73,47.83 37.73,43.18 38.11,42.8 38.11,42.45 v3(38.4,42.15)
HSI_LAN_DP4_R: length 7.1
  TOP w0.102: U26.17 30.18,38.75 29.99,38.93 29.99,39.2 30.15,39.35 33.27,39.35 33.83,39.91 ; v1(34.09,39.66) 33.83,39.91 ; 33.83,39.91 34.44,40.52 34.64,40.52 C286.1
HSO_C_DN2: length 11.2
  BOTTOM w0.102: v2(117.12,229.09) 116.88,229.33 ; 116.88,229.33 116.24,228.7 115.76,228.7 115.61,228.55 115.61,228.22 C635.1 ; 116.88,229.33 117.44,229.89 117.44,234.9 117.06,235.28 115.54,235.28 R672.2
HSO_C_DN3: length 7
  TOP w0.102: 108.76,221.47 107.61,220.32 107.61,219.59 C641.1 ; 108.76,221.47 109.13,221.84 110.82,221.84 111.23,222.25 111.23,222.66 R27.2 ; 108.76,221.47 v1(109.02,221.22)
HSO_C_DN5: length 205.9
  TOP w0.102: C244.1 117.96,67.25 117.53,67.25 117.4,67.12 117.4,66.23 117.51,66.11 118.43,66.11 118.67,65.87 118.67,65.59 v4(119,65.26)
  L3 w0.127: v4(119,65.26) 118.75,65.01 118.75,65 118.68,64.94 118.68,59.46 122.85,55.29 126.59,55.29 129.95,51.94 137.35,51.94 139.28,53.87 139.95,53.87 140.94,54.86 144.54,54.86 148.91,59.23 156.91,59.23 159.77,62.09 159.77,66.15 162.61,68.99 162.61,72.34 165.71,75.44 165.71,79.29 166.99,80.57 166.99,93.41 169.26,95.68 174.55,95.68 176.41,97.53 177.66,97.53 178.29,98.17 181.12,98.17 182.49,99.54 182.49,100.81 186.14,104.46 186.14,119.2 181.69,123.66 181.69,144.92 186.39,149.62 186.39,162.64 186.4,162.66 186.4,166.31 185.42,167.29 183.74,167.29 183.46,167.57 183.46,167.98 v3(183.19,168.25)
  BOTTOM w0.102: U39.5 178.81,157.28 178.72,157.37 178.4,157.37 176.48,159.3 176.48,165.31 177.79,166.62 182.36,166.62 183.02,167.28 ; v3(183.19,168.25) 183.41,168.03 183.41,167.67 183.02,167.28 ; 183.02,167.28 v2(182.8,167.5)
HSO_C_DP2: length 10.8
  BOTTOM w0.102: 117.22,232.06 117.22,234.81 116.97,235.06 115.51,235.06 R669.2 ; 117.22,232.06 v2(116.89,232.06) ; 117.22,232.06 117.22,229.98 116.15,228.91 115.67,228.91 115.4,228.64 115.4,228.22 C634.1
HSO_C_DP3: length 7
  TOP w0.102: 107.77,220.79 109.04,222.06 110.73,222.06 111.02,222.34 111.02,222.66 R24.2 ; 107.77,220.79 v1(107.52,221.04) ; 107.77,220.79 107.4,220.41 107.4,219.59 C642.1
HSO_C_DP5: length 206.8
  TOP w0.102: 117.18,66.79 117.18,67.21 117.44,67.47 117.96,67.47 C243.1 ; 117.18,66.79 v1(116.84,66.79) ; 117.18,66.79 117.18,66.14 117.42,65.9 118.34,65.9 118.45,65.78 118.45,65.6 v4(118.11,65.26)
  L3 w0.127: v3(184.01,168.25) 183.73,167.97 183.73,167.68 183.85,167.56 185.53,167.56 186.66,166.42 186.66,162.55 186.65,162.53 186.65,149.51 181.95,144.81 181.95,123.77 186.41,119.31 186.41,104.35 182.75,100.69 182.75,99.42 181.23,97.9 178.41,97.9 177.77,97.26 176.52,97.26 174.66,95.41 169.37,95.41 167.26,93.3 167.26,80.46 165.97,79.18 165.97,75.33 162.88,72.23 162.88,68.88 160.03,66.04 160.03,61.98 157.02,58.97 149.03,58.97 144.65,54.59 141.05,54.59 140.06,53.6 139.39,53.6 137.46,51.67 129.84,51.67 126.48,55.03 122.74,55.03 118.41,59.35 118.41,64.96 v4(118.11,65.26)
  BOTTOM w0.102: U39.6 178.81,157.68 178.72,157.59 178.49,157.59 176.7,159.39 176.7,165.22 177.88,166.4 182.45,166.4 183.63,167.59 183.63,167.87 v3(184.01,168.25)
HSO_C_LAN_DN4: length 5.8
  TOP w0.102: v1(33.39,36.47) 33.15,36.23 ; 33.15,36.23 34.63,34.74 34.97,34.74 C295.1 ; 33.15,36.23 32.6,36.78 31.48,36.78 31.38,36.88 U26.14
HSO_C_LAN_DP4: length 5.8
  TOP w0.102: C300.1 34.98,34.53 34.54,34.53 34.34,34.73 ; 34.34,34.73 32.51,36.56 31.5,36.56 31.42,36.48 U26.13 ; 34.34,34.73 v1(34.1,34.49)
HSO_DN2: length 178.8
  TOP w0.102: U29.D11 126.87,69.2 126.48,69.14 126.28,69.09 126.12,69.06 125.95,68.98 125.69,68.98 125.44,69.01 125.43,69.01 125.32,69.01 125.27,69.01 125.2,69.01 125.16,69.01 125.15,69 124.89,69 124.66,68.77 124.13,68.77 v4(123.55,69.36) ; v3(115.95,116.14) 115.7,116.39 115.42,116.39 115.15,116.66 115.15,126.81 112.05,129.9 112.05,205.15 113.96,207.06 113.96,213.1 110.67,216.39 110.67,219.42 111.58,220.33 113.41,220.33 114.94,221.85 114.94,224.55 116.06,225.68 116.4,225.68 v3(116.64,225.92)
  BOTTOM w0.102: v4(123.55,69.36) 123.69,69.5 123.69,69.72 123.57,69.83 120.85,69.83 119.54,71.14 118.35,71.14 117.46,72.03 ; 117.46,72.03 v2(117.25,71.82) ; 117.46,72.03 116.63,72.86 116.63,104.44 118.8,106.61 118.8,113.63 117.29,115.14 116.6,115.83 116.29,116.14 v3(115.95,116.14) ; v3(116.64,225.92) 116.37,225.65 115.99,225.65 115.57,226.07 115.57,226.62 C635.2
HSO_DN3: length 171.3
  TOP w0.102: C641.2 107.62,218.03 107.62,215.88 110.63,212.87 110.63,208.81 107.68,205.86 107.68,129.91 111.02,126.57 111.02,117.42 110.72,117.12 110.72,116.11 110.9,115.93 111.05,115.93 v3(111.25,116.14) ; v4(122.11,67.39) 121.95,67.55 121.95,67.65 122.6,68.3 125.56,68.3 126.01,68.75 U29.B9
  BOTTOM w0.102: 117.78,69.32 117.1,69.32 115.58,70.84 115.58,104.97 117.74,107.14 117.74,113 115.7,115.05 113.17,115.05 112.38,115.83 111.56,115.83 v3(111.25,116.14) ; 117.78,69.32 119.52,69.32 120.78,68.06 121.59,68.06 121.88,67.76 121.88,67.61 122.11,67.39 v4(122.11,67.39) ; 117.78,69.32 v2(117.78,69.63)
HSO_DN4: length 114
  TOP w0.102: v4(123.44,67.29) 123.7,67.55 123.7,67.67 124.05,68.02 125.72,68.02 U29.B8 ; v3(38.83,40.54) 39.14,40.54 39.24,40.44 39.24,39.09 39.41,38.92 39.41,36.91 39.1,36.6 ; C295.2 36.54,34.77 37.27,34.77 39.1,36.6 ; v1(38.84,36.86) 39.1,36.6
  L4 w0.127: v4(123.44,67.29) 123.7,67.04 123.83,67.04 123.94,66.93 123.94,66.69 123.83,66.58 114.68,66.58 109.1,61.01 96.41,61.01 95.7,60.3 84.31,60.3 81.2,57.18 74.04,57.18 72.56,55.71 62.84,55.71 62.18,55.05 45.58,55.05 40.67,50.13 40.67,49.44 40.67,49.29 40.26,48.88 39.65,48.88 38.43,47.66 38.43,43.3 39.24,42.49 39.24,40.73 39.06,40.54 v3(38.83,40.54)
HSO_DN5: length 9.1
  TOP w0.102: U29.B7 125.95,67.51 125.48,67.04 124.95,67.04 124.45,66.53 122.4,66.53 121.77,65.9 120.48,65.9 120.21,66.17 ; 120.21,66.17 v1(119.97,65.92) ; 120.21,66.17 120.06,66.32 120.06,66.99 119.89,67.17 119.44,67.17 C244.2
HSO_DP2: length 178.4
  TOP w0.102: U29.C11 126.42,69.42 126.37,69.4 126.18,69.32 126.05,69.27 125.9,69.2 125.7,69.2 125.45,69.22 125.45,69.22 125.29,69.23 125.28,69.23 125.19,69.22 125.12,69.22 124.81,69.22 124.57,68.98 124.22,68.98 124.12,69.09 124.12,69.31 v4(124.21,69.41) ; v3(115.97,117) 115.97,116.71 115.86,116.61 115.51,116.61 115.36,116.75 115.36,126.9 112.27,129.99 112.27,205.06 114.17,206.97 114.17,213.19 110.88,216.48 110.88,219.33 111.67,220.11 113.5,220.11 115.15,221.76 115.15,224.46 116.15,225.46 116.33,225.46 v3(116.63,225.15)
  BOTTOM w0.102: v3(116.63,225.15) 116.35,225.43 115.9,225.43 115.35,225.98 115.35,226.7 C634.2 ; 116.85,73.75 116.85,104.35 119.01,106.52 119.01,113.72 116.33,116.4 116.33,116.87 116.2,117 v3(115.97,117) ; 116.85,73.75 v2(117.14,73.75) ; 116.85,73.75 116.85,72.95 118.44,71.36 119.63,71.36 120.94,70.05 123.66,70.05 123.9,69.81 123.9,69.72 v4(124.21,69.41)
HSO_DP3: length 171.3
  TOP w0.102: v4(121.41,67.29) 121.67,67.55 121.67,67.67 122.51,68.51 125.15,68.51 U29.A9 ; C642.2 107.4,218.02 107.4,215.8 110.41,212.79 110.41,208.9 107.47,205.95 107.47,129.82 110.81,126.48 110.81,117.51 110.5,117.2 110.5,116.02 110.81,115.72 111.04,115.72 111.25,115.5 v3(111.25,115.27)
  BOTTOM w0.102: 120.01,68.51 119.43,69.1 117.01,69.1 115.36,70.75 115.36,105.06 117.53,107.23 117.53,112.91 115.61,114.83 113.08,114.83 112.29,115.61 111.36,115.61 111.25,115.5 v3(111.25,115.27) ; 120.01,68.51 120.69,67.84 121.5,67.84 121.67,67.67 121.67,67.55 v4(121.41,67.29) ; 120.01,68.51 v2(119.79,68.28)
HSO_DP4: length 114.1
  TOP w0.102: U29.C8 126.3,68.14 125.97,67.81 124.14,67.81 123.98,67.65 123.98,67.52 v4(124.21,67.29) ; 37.84,35.04 39.62,36.82 39.62,39.01 39.46,39.18 39.46,40.31 v3(39.69,40.54) ; 37.84,35.04 v1(38.1,34.78) ; 37.84,35.04 37.36,34.55 36.58,34.55 C300.2
  L4 w0.127: v3(39.69,40.54) 39.51,40.73 39.51,42.6 38.7,43.41 38.7,47.55 39.76,48.61 40.37,48.61 40.93,49.17 40.93,49.55 40.93,50.02 45.69,54.78 62.29,54.78 62.95,55.44 72.67,55.44 74.15,56.91 81.31,56.91 84.42,60.03 95.81,60.03 96.52,60.74 109.21,60.74 114.79,66.32 123.94,66.32 124.21,66.58 v4(124.21,67.29)
HSO_DP5: length 8.1
  TOP w0.102: 121.16,66.11 120.57,66.11 120.28,66.4 120.28,67.08 119.98,67.38 119.61,67.38 C243.2 ; 121.16,66.11 121.68,66.11 122.31,66.75 124.36,66.75 125.01,67.4 U29.A7 ; 121.16,66.11 v1(121.16,66.46)
HSW_PCUDEBUG_0: length 60.5
  TOP w0.102: v3(77.85,195.39) 79.87,193.37 79.87,185.27 80.71,184.43 80.71,183.59 CPU1.AA37
  BOTTOM w0.102: v3(77.85,195.39) 76.31,195.39 74.3,197.41 R776.1 74.93,201.34 74.93,207.03 75.06,207.16 75.06,216.49 v2(71.83,219.72) 61.36,230.19 XDPC1.9
HSW_PCUDEBUG_1: length 60.1
  TOP w0.102: CPU1.Y38 79.3,185.01 79.3,192.13 79.1,192.33 78.15,193.28 77.95,193.28 v3(77.85,193.38)
  BOTTOM w0.102: XDPC1.11 60.86,229.6 v2(72.46,218) 74.83,215.63 74.83,207.25 74.7,207.13 74.7,204.54 R754.1 73.71,203.55 73.71,197.67 76.58,194.8 77.94,194.8 78.31,194.43 78.31,193.84 v3(77.85,193.38)
HSW_PCUDEBUG_2: length 62.2
  TOP w0.102: v3(77.85,194.24) 77.93,194.17 78.21,194.17 79.64,192.73 79.64,185.18 80.48,184.34 80.48,183.5 80.6,183.38 80.6,182.79 CPU1.AA36
  BOTTOM w0.102: XDPC1.15 59.86,230.14 69.14,220.86 69.14,220.07 v2(70.3,218.9) 74.6,214.61 74.6,207.35 74.47,207.22 74.47,205.84 R735.1 73.48,204.85 73.48,197.57 76.53,194.52 77.57,194.52 v3(77.85,194.24)
HSW_PCUDEBUG_3: length 87
  TOP w0.102: CPU1.W38 79.03,184.36 79.03,191.37 v3(77.88,192.52) ; v3(59.36,230.79) 47.12,230.79 v3(45.42,232.5)
  BOTTOM w0.102: v3(45.42,232.5) 45.11,232.8 45.11,243.83 44.5,244.44 44.5,245.21 R646.2 ; v3(77.88,192.52) 73.25,197.14 73.25,205.06 73.41,205.22 73.41,208.45 R722.1 73.91,214.54 68.43,220.02 68.43,220.77 v2(61.53,227.68) 59.36,229.85 v3(59.36,230.79) XDPC1.17
HSW_PCUDEBUG_4: length 59.1
  TOP w0.102: v3(77.85,191.63) 77.39,191.17 77.39,187.08 77.97,186.51 77.97,185.78 78.32,185.42 CPU1.V39
  BOTTOM w0.102: v3(77.85,191.63) 77.85,191.84 72.39,197.3 R777.1 73.03,201.27 73.03,205.16 73.05,205.18 73.05,214.71 68.12,219.64 67.59,219.64 v2(65.64,221.59) 56.86,230.37 XDPC1.27
HSW_PCUDEBUG_5: length 59.3
  TOP w0.102: CPU1.U39 76.85,185.62 76.85,186.18 75.6,187.43 75.6,192.29 v3(76.17,192.87)
  BOTTOM w0.102: v3(76.17,192.87) 71.93,197.11 71.93,203.68 R755.1 72.64,204.39 72.64,205.59 72.82,205.77 72.82,214.06 v2(72.26,214.61) 68.45,218.42 67.76,218.42 56.36,229.83 XDPC1.29
HSW_PCUDEBUG_6: length 57.9
  TOP w0.102: CPU1.U40 77.41,186.34 76.28,187.46 v3(76.28,191.96)
  BOTTOM w0.102: XDPC1.33 55.36,230.38 v2(55.76,229.98) 72.59,213.14 72.59,205.86 R736.1 71.7,204.97 71.7,196.54 v3(76.28,191.96)
HSW_PCUDEBUG_7: length 61.1
  TOP w0.102: CPU1.V38 78.32,184.51 78.65,184.84 78.65,190.06 v3(77.85,190.86)
  BOTTOM w0.102: XDPC1.35 54.86,230.07 v2(56.65,228.28) 72.19,212.75 72.19,209.14 R723.1 71.42,208.38 71.42,196.17 76.73,190.86 v3(77.85,190.86)
HSW_PCUDEBUG_8: length 73.4
  TOP w0.102: v3(79.76,197.49) 78.09,197.49 75.21,194.61 75.21,187.26 CPU1.T40
  BOTTOM w0.102: v3(79.76,197.49) 79.17,198.08 79.17,203.68 R752.1 80.67,205.18 80.67,222.6 74.46,228.81 v2(73.81,228.81) 73.35,228.81 64.72,237.44 64.72,241.6 63.74,242.58 61.92,242.58 61.36,242.02 XDPC1.10
HSW_PCUDEBUG_9: length 76.5
  TOP w0.102: v3(79.69,181.87) CPU1.Y35
  BOTTOM w0.102: v3(79.69,181.87) 80.12,182.3 80.12,185.03 79.66,185.49 79.66,189.15 79.96,189.44 79.96,196.17 80.33,196.53 80.33,204.51 80.9,205.08 80.9,208.45 R718.1 81.41,210.54 81.15,210.8 81.15,210.8 80.98,210.98 80.98,222.62 73.03,230.57 v2(72.57,230.57) 71.92,230.57 64.95,237.54 64.95,242.15 64.29,242.81 61.65,242.81 60.86,242.02 XDPC1.12
HSW_PCUDEBUG_10: length 79.4
  TOP w0.102: v3(80.61,180.95) CPU1.AA34
  BOTTOM w0.102: XDPC1.16 59.86,241.88 61.01,243.04 64.39,243.04 65.18,242.25 65.18,237.63 70.01,232.8 v2(70.48,232.8) 71.12,232.8 81.2,222.71 81.2,211.07 82.09,210.18 82.09,205.97 R731.1 81.13,205 81.13,204.99 80.67,204.53 80.67,196.55 80.19,196.07 80.19,189.35 80.17,189.34 80.17,189.31 79.89,189.03 79.89,185.55 81.04,184.4 81.04,181.38 v3(80.61,180.95)
HSW_PCUDEBUG_11: length 80.2
  TOP w0.102: CPU1.V37 77.94,183.62 77.94,185.37 77.76,185.55 77.76,186.32 77.17,186.92 77.17,195.35 77.66,195.84 v3(80.64,195.84)
  BOTTOM w0.102: XDPC1.18 59.36,241.71 60.92,243.27 64.57,243.27 67.32,240.51 67.32,235.81 68.63,234.5 v2(69.29,234.5) 69.74,234.5 81.43,222.81 81.43,211.17 82.32,210.28 82.32,205.05 R751.1 80.9,203.63 80.9,196.1 v3(80.64,195.84)
HSW_PCUDEBUG_12: length 85.7
  TOP w0.102: v3(79.69,180.04) CPU1.Y34
  BOTTOM w0.102: v3(79.69,180.04) CPU1.Y34 80.76,180.49 81.24,180.98 81.24,186.55 80.4,187.39 80.4,189.24 81.41,190.25 R775.1 81.97,201.27 81.97,204.13 82.55,204.71 82.55,208.77 84.15,210.37 84.15,220.65 69.24,235.56 v2(69.24,237.07) 69.24,238.91 64.66,243.49 58.39,243.49 56.86,241.96 XDPC1.28
HSW_PCUDEBUG_13: length 71.1
  TOP w0.102: v3(77.85,196.61) 76.63,195.39 76.63,192.68 76.36,192.41 76.09,192.41 75.82,192.15 75.82,187.62 77.05,186.39 77.05,185.82 77.33,185.54 77.45,185.54 77.74,185.25 77.74,184.84 77.41,184.51 CPU1.U38
  BOTTOM w0.102: XDPC1.30 56.36,238.14 57.02,237.47 62.31,237.47 78.7,221.09 v2(78.7,212.54) 77.72,211.57 R720.1 77.27,208.51 77.27,205.77 76.81,205.32 76.81,197.65 v3(77.85,196.61)
HSW_PCUDEBUG_14: length 73.8
  TOP w0.102: v3(78.78,180.95) CPU1.W34
  BOTTOM w0.102: XDPC1.34 55.36,238.45 56.56,237.25 62.22,237.25 76.33,223.14 76.33,214.36 76.83,213.85 v2(76.83,212.71) 76.83,205.79 R734.1 76.45,205.15 76.45,197.36 77.66,196.15 78.06,196.15 78.77,195.44 78.77,190.28 78.43,189.94 78.43,184.89 77.94,184.4 77.94,182.57 78.33,182.18 78.33,181.4 v3(78.78,180.95)
HSW_PCUDEBUG_15: length 73.1
  TOP w0.102: v3(77.86,181.87) CPU1.V35
  BOTTOM w0.102: XDPC1.36 54.86,238.45 56.3,237.02 62.12,237.02 75.74,223.4 75.74,213.67 76.2,213.22 v2(76.2,211.41) R721.1 75.74,208.51 75.74,204.78 76.2,204.33 76.2,197.29 77.57,195.92 77.96,195.92 78.54,195.35 78.54,190.63 77.56,189.65 77.56,187.01 78.02,186.55 78.02,184.97 77.74,184.68 77.74,182.17 77.86,182.04 v3(77.86,181.87)
HSW_PCUSTB_0_DN: length 71.7
  TOP w0.102: v3(79.69,183.69) CPU1.Y37
  BOTTOM w0.102: XDPC1.6 62.36,241.79 62.92,242.35 63.64,242.35 64.49,241.5 64.49,237.35 75.01,226.83 v2(75.41,226.83) 76.12,226.83 80.44,222.51 80.44,206.09 R732.1 78.94,204.59 78.94,197.21 79.73,196.42 79.73,189.54 79.44,189.24 79.44,183.95 v3(79.69,183.69)
HSW_PCUSTB_0_DP: length 71.7
  TOP w0.102: v3(79.69,182.78) CPU1.Y36
  BOTTOM w0.102: v3(79.69,182.78) 79.69,182.93 79.24,183.38 79.24,183.88 79.21,183.91 79.21,189.34 79.45,189.58 79.45,196.38 78.71,197.11 78.71,204.8 79.12,205.21 79.12,208.39 79.63,208.9 R719.1 80.14,209.47 80.14,222.49 77.93,224.7 v2(77.17,224.7) 76.75,224.7 64.26,237.18 64.26,241.41 63.55,242.12 63.07,242.12 62.86,241.91 XDPC1.4
HSW_PCUSTB_1_DN: length 71.1
  TOP w0.102: v3(78.78,182.78) CPU1.W36
  BOTTOM w0.102: XDPC1.24 57.86,238.29 58.45,237.7 62.41,237.7 79.23,220.88 v2(79.23,219.74) 79.23,210.15 78.66,209.58 78.66,206.22 R733.1 77.04,204.59 77.04,198.06 78.99,196.11 78.99,189.77 78.66,189.43 78.66,184.83 78.14,184.32 78.14,183.42 v3(78.78,182.78)
HSW_PCUSTB_1_DP: length 73.2
  TOP w0.102: v3(78.76,181.86) 78.32,182.3 CPU1.V36
  BOTTOM w0.102: v3(78.76,181.86) 79.21,182.32 79.21,182.96 78.93,183.24 78.62,183.24 78.35,183.52 78.35,184.11 78.88,184.65 78.88,189.34 79.22,189.68 79.22,196.25 77.27,198.21 77.27,203.68 R753.1 78.89,205.3 78.89,209.48 79.76,210.36 79.76,221.79 v2(78.28,223.28) 77.56,223.28 62.91,237.93 58.72,237.93 58.36,238.3 XDPC1.22
HSW_STRAP_13: length 238.7
  TOP w0.102: v3(78.74,211.31) 78.87,211.44 v3(88.52,211.44)
  L4 w0.127: v3(137.97,101.36) 137.72,101.61 137.72,104.38 137.99,104.65 140.09,104.65 143.64,108.19 143.64,112.89 150.3,119.55 167.42,119.55 170.52,122.66 170.52,122.76 170.8,123.03 170.9,123.03 172.72,124.86 172.72,128.13 173.19,128.6 173.19,128.83 173.3,128.94 173.3,141.04 175.35,143.09 175.35,144.9 174.76,145.48 174.76,145.87 175.35,146.46 175.35,156.21 174.56,156.99 174.56,162.63 175.16,163.23 175.16,172.95 175.01,173.1 175.01,185.6 165.17,195.44 153.9,195.44 146.05,203.29 137.57,203.29 133.9,206.96 133.81,206.96 133.7,207.07 133.31,207.07 133.2,206.96 121.78,206.96 v3(117.6,202.78)
  BOTTOM w0.102: v3(88.52,211.44) v2(90.72,209.23) 90.72,206.19 92.36,204.55 112.24,204.55 114.75,202.04 117.14,202.04 117.6,202.5 v3(117.6,202.78) ; v3(78.74,211.31) 78.36,210.93 78.36,208.64 77.79,208.07 R720.2 ; QF1.3 145.24,99.37 144.74,99.87 141.52,99.87 140.63,100.76 138.56,100.76 v3(137.97,101.36)
HSW_XDP_MBP_0: length 78.8
  TOP w0.102: v3(67.81,184.61) CPU1.G39
  BOTTOM w0.102: XDPC1.21 58.36,235.3 57.05,236.61 48.47,236.61 47.54,235.68 47.54,226.58 62.92,211.2 66.29,211.2 70.74,206.75 70.74,200.42 v2(68.71,198.38) 68.19,197.86 68.19,195.97 69.34,194.81 69.34,190.4 67.46,188.52 67.46,186.09 67.81,185.75 v3(67.81,184.61)
HSW_XDP_MBP_1: length 77.4
  TOP w0.102: v3(69.63,185.52) CPU1.J39
  BOTTOM w0.102: XDPC1.23 57.86,235.47 56.95,236.38 48.56,236.38 47.77,235.59 47.77,226.8 54.46,220.1 56.32,220.1 60.33,216.1 60.33,215.17 64.07,211.43 66.39,211.43 70.97,206.85 70.97,199.3 v2(70.05,198.38) 68.97,197.3 68.68,197.3 68.41,197.04 68.41,196.06 69.57,194.91 69.57,190.3 68.77,189.5 68.77,186.71 69.63,185.85 v3(69.63,185.52)
HSYNC_3P3V: length 23.6
  TOP w0.102: L23.2 33.57,15.31 34.32,14.57 34.4,14.57 C352.1 35.09,14.42 35.17,14.33 35.74,14.33 36.2,14.79 36.2,14.84 v3(36.98,15.63)
  L3 w0.127: VGA1.13 50.89,8.9 49.81,9.98 47.52,9.98 44.15,13.35 44.15,14.56 42.23,16.47 v3(41.07,16.47)
  BOTTOM w0.102: v3(41.07,16.47) 41.07,16.75 40.78,17.04 U44.3 39.46,16.42 37.77,16.42 v3(36.98,15.63)
IGC_EN_N: length 18.9
  TOP w0.102: U29.AC40 136.83,85.1 136.83,85.56 136.69,85.7 136.69,86.26 136.75,86.32 136.75,88.24 135.48,89.51 v4(135.48,90.15)
  L4 w0.127: v4(135.48,90.15) 135.8,90.47 135.8,91.98 135.55,92.24 135.55,92.81 137.72,94.98 137.72,95.79 137.78,95.85 137.78,96.01 138.98,97.22 v3(138.99,97.22)
  BOTTOM w0.102: v3(138.99,97.22) 139.09,97.22 139.42,96.88 v2(140.08,96.88) 141.22,96.88 R877.1 142.46,96.3 R879.1
INA99B_OUT: length 3.2
  TOP w0.152: R1142.1 24.42,146.12 v1(24.99,146.69) 25.48,146.69 26.05,146.13 U47.6
INA991_IN_N: length 4.6
  TOP w0.152: U47.5 26.7,146.44 v1(26.44,146.69) 26.64,146.9 R1151.1 28.7,148.09 C733.2
INA991_IN_P: length 7.2
  TOP w0.152: C733.1 28.73,146.9 28.73,145.78 28.68,145.73 v1(28.68,145.7) 28.65,145.7 28.37,145.42 U47.4 27.35,144.98 27,144.64 25.71,144.64 25.25,145.1 v3(25.25,145.75)
  BOTTOM w0.152: v3(25.25,145.75) 25.25,144.81 R1150.1
INIT_3V: length 5.8
  TOP w0.102: R508.2 124.68,44.02 122.3,41.64 LPC1.2
INTRUDER_DET: length 352
  TOP w0.102: U29.W34 135.12,81.76 v4(134.62,81.26) ; v3(137.31,96.05) 137.34,96.02 138.94,96.02 v3(139.07,95.89)
  L3 w0.127: v3(156.38,89.18) 156.34,89.18 153.73,86.57 153.73,86.41 153.02,85.7 153.02,84.7 153.99,83.73 153.99,82.76 153.52,82.29 153.52,81.73 153.79,81.46 153.79,81.44 153.98,81.25 153.98,80.76 v4(153.97,80.76)
  L4 w0.127: v3(137.31,96.05) 137.31,95.06 134.87,92.62 134.87,92.34 133.45,90.92 v3(133.45,90.89) ; v3(139.07,95.89) 139.07,95.63 142.57,92.12 143.95,92.12 145.04,91.03 148.48,91.03 148.62,91.17 148.96,91.17 149.21,90.92 149.21,90.52 150.55,89.18 v3(156.38,89.18) ; v4(153.97,80.76) 155,79.73 155,72.26 157.3,69.95 157.3,65.47 156.39,64.56 156.39,61.71 155.59,60.91 155.25,60.91 154.53,60.19 154.53,57.48 154.03,56.97 154.03,52.78 152.39,51.14 152.39,46.61 152.83,46.16 153.19,46.16 154.66,44.69 154.66,38.4 153.76,37.49 153.76,29.46 146.56,22.26 146.56,21.59 140.7,15.73 138.59,15.73 131.37,8.52 123.91,8.52 123.07,9.36 119.55,9.36 118.71,8.52 110.12,8.52 109.18,9.46 106.72,9.46 105.78,8.52 97.12,8.52 96.48,9.15 93.77,9.15 93.13,8.52 91.43,8.52 90.84,9.1 87.59,9.1 85.75,10.94 79.98,10.94 78.27,9.24 73.41,9.24 71.67,10.98 67.38,10.98 65.03,8.63 63.16,8.63 61.58,10.21 57.7,10.21 57.47,9.98 56.72,9.98 56.64,10.06 55.26,10.06 55.18,9.98 54.31,9.98 54.23,10.06 52.97,10.06 52.89,9.98 52.02,9.98 51.94,10.06 50.68,10.06 50.6,9.98 49.73,9.98 49.65,10.06 48.39,10.06 48.31,9.98 47.51,9.98 46.93,10.56 43.1,10.56 40.03,13.63 36.19,13.63 32.11,17.71 32.11,20.18 30.36,21.93 29.16,21.93 26.5,24.59 26.5,24.61 25.5,25.61 18.98,25.61 18.7,25.89 16.27,25.89 11.63,30.53 11.63,32.59 10.45,33.77 10.45,41.52 10.75,41.82 10.79,41.86 11.43,42.51 11.43,45.04 16.88,50.49 16.88,99.33 INTRU1.3
  BOTTOM w0.102: v3(133.45,90.89) 133.45,90.54 135.25,88.74 135.25,88.08 135.31,88.03 135.31,81.95 v4(134.62,81.26) ; R937.1 R936.1 155.23,89.18 v3(156.38,89.18)
INV_DET*: length 368.9
  TOP w0.102: CONVT1.7 9.1,118.05 12.5,121.45 15.71,121.45 R165.2 16.19,121.84 16.64,121.4 v3(18.16,121.4) ; v4(132.42,80) 132.76,80.34 U29.R31
  L3 w0.127: v3(18.16,121.4) 19.06,120.49 19.06,96.47 17.56,94.96 17.56,85.42 17.7,85.28 17.7,76.95 19.57,75.08 19.57,74.11 25.11,68.58 25.11,54.21 22.61,51.71 22.61,42.99 20.72,41.11 19.03,41.11 17.59,39.66 17.59,34.52 18.61,33.5 18.61,32.28 21.04,29.84 25.19,29.84 26.53,28.5 26.53,24.9 29.56,21.87 30.34,21.87 30.62,21.59 30.62,20.37 31.5,19.5 31.5,13.53 37.17,7.86 42.66,7.86 43.67,6.86 70.83,6.86 73.08,4.61 82.25,4.61 85.59,7.95 89.82,7.95 90.26,7.5 93.02,7.5 93.63,8.11 103.62,8.11 103.85,7.88 105.76,7.88 106.14,8.26 132.46,8.26 141.58,17.38 152.36,17.38 154.27,19.29 154.27,24.53 150.9,27.9 150.9,31.46 v3(150.8,31.56)
  L4 w0.127: v3(150.8,31.56) 152.68,33.44 152.68,44.52 150.15,47.05 150.15,47.61 150.01,47.75 150.01,52.72 151.07,53.78 151.07,58.44 152.41,59.79 152.41,65.2 153.23,66.02 154.66,66.02 155.07,66.43 155.07,69.45 153.07,71.45 153.07,74.76 152.73,75.09 150.63,75.09 150.05,75.68 150.05,82.06 148.33,83.78 146.03,83.78 143.53,86.28 142.82,86.28 140.68,88.41 138.58,88.41 137.21,87.04 137.21,86.36 135.72,84.87 134.21,84.87 133.02,83.68 133.02,80.6 v4(132.42,80)
IO_SMI_N: length 131.8
  TOP w0.102: U29.AF40 138.73,85.43 138.73,85.72 138.81,85.8 138.81,86.54 138.83,86.56 138.83,87.06 138.35,87.55 138.35,89.44 138.63,89.72 v3(138.63,90.03) 138.35,90.31 R276.2 ; v3(95.94,70.98) 95.94,63.26 v3(94.84,62.16) ; U24.126 58.87,37.38 58.65,37.6 v3(57.78,37.6)
  L3 w0.127: v3(94.84,62.16) 94.48,61.79 94.16,61.79 93.55,61.79 89.93,58.18 85.27,58.18 81.92,61.53 76.82,61.53 72.75,57.45 69.87,57.45 68.44,56.03 66.59,56.03 66.1,55.55 63.37,52.82 61.59,52.82 61.37,52.59 59.79,52.59 56.3,49.1 56.3,47.27 55.37,46.34 55.37,45.86 55.82,45.42 55.82,44.5 55.24,43.93 55.24,41.91 56.32,40.83 56.32,37.66 56.6,37.39 57.57,37.39 v3(57.78,37.6)
  L4 w0.127: v3(138.63,90.03) 138.63,89.7 136.53,87.59 136.53,87.05 135.03,85.56 127.71,85.56 126.02,83.87 119.7,83.87 114.6,78.77 114.6,76.86 108.45,70.71 96.2,70.71 v3(95.94,70.98)
  BOTTOM w0.102: v2(95.12,70.98) v3(95.94,70.98)
ISP_CLK1: length 8.3
  BOTTOM w0.102: Q93.D 117.28,209.98 116.33,209.03 v2(115.85,209.03) 115.8,208.98 115.8,208.29 115.93,208.16 R727.2 116.52,205.53 116.71,205.34 Q95.D
ISP_DAT1: length 13.5
  BOTTOM w0.102: v2(119.28,203.08) 119.28,203.4 Q94.D 118.05,204.52 117.14,205.43 117.14,206.95 117.44,207.25 118.4,207.25 R726.2 119.81,208.66 119.81,209.13 121.09,210.41 Q92.D
JACK_PSID: length 5.2
  TOP w0.102: v1(14.99,153.4) 14.86,153.27 14.86,152.19 L8.1 14.27,151.61 14.27,150.83 14.53,150.58 14.69,150.58 R157.1
JDREF: length 5.1
  TOP w0.203: U16.35 181.12,85.36
  TOP w0.254: R333.1 184.04,82.34 183.4,82.98 183.22,82.98 v1(182.88,83.32) 182.88,83.55 181.91,84.52 181.91,84.57 181.12,85.36
JTAG_TCK_VGA: length 7.2
  TOP w0.102: U13.L3 76.08,77.21 76.08,73.32 76.41,72.98 76.45,72.98 v3(76.81,72.63) 76.89,72.63 77.6,71.92 77.6,71.55 R963.1
JTAG_TDI_VGA: length 8.3
  TOP w0.102: U13.L5 76.13,78.36 76.13,77.59 76.28,77.26 76.28,74.42 v4(76.72,73.99)
  BOTTOM w0.102: R397.1 77.6,71.55 77.6,73.67 v2(77.53,73.74) 77.28,73.99 v4(76.72,73.99)
JTAG_TDO_VGA: length 6.8
  TOP w0.102: U13.K4 75.41,77.88 75.41,76.65 75.6,76.45 75.6,75.5 75.18,75.09 v3(75.18,74.74) 74.84,74.4 74.84,72.78 R399.1
JTAG_TMS_VGA: length 6.1
  TOP w0.102: R398.1 76.45,72.31 75.53,73.23 v3(75.53,73.26) 75.53,74.35 75.8,74.62 75.8,77.09 U13.L1
JTAG_TRST#_VGA: length 11.1
  TOP w0.102: U13.L6 75.26,79.05 v4(75.22,79.05)
  L3 w0.127: v4(76.58,73.39) 76.02,73.95 75.17,73.95 74.71,74.41 74.71,78.54 v4(75.22,79.05)
  BOTTOM w0.102: R396.1 75.63,71.55 v2(75.46,71.71) 75.46,72.06 76.52,73.11 76.52,73.33 v4(76.58,73.39)
KBRST_N: length 119.9
  TOP w0.102: v4(130.01,82.54) 130.08,82.54 130.42,82.88 U29.K36 ; U24.118 55.67,38.96 57.17,40.46 57.84,40.46 58.1,40.73 58.1,41.15 57.6,41.65 v3(57.6,43.77)
  L3 w0.127: v3(124.7,90.9) 124.57,90.9 123.97,90.3 123.97,89.93 124.02,89.88 124.02,88.62 122.54,87.15 122.54,81.66 123.36,80.84 123.36,78.83 120.33,75.8 118.11,75.8 102.5,60.19 94.07,60.19 89.83,55.95 70.49,55.95 69.07,54.53 68.14,54.53 66.17,52.56 65.41,52.56 63.63,50.78 62.74,50.78 61.34,49.39 58.88,49.39 57.62,48.13 57.62,43.79 v3(57.6,43.77)
  BOTTOM w0.102: v4(130.01,82.54) 129.63,82.92 129.63,83.98 129.87,84.22 129.87,84.56 129.63,84.8 129.63,87.55 129.13,88.06 128.34,88.06 v2(127.89,88.5) 127.52,88.5 125.44,90.58 125.44,90.93 124.78,91.6 124.78,91.61 R919.1 123.95,91.42 124.46,90.92 124.69,90.92 v3(124.7,90.9)
KCLK: length 7
  TOP w0.102: U24.113 53.67,35.36 55.21,33.82 RN5.4 54.69,32.38 54.69,30.77 v1(54.99,30.46)
KDAT: length 4.5
  TOP w0.102: U24.114 54.07,35.33 54.83,34.56 v1(55.26,34.56) 55.26,34.14 55.86,33.53 RN5.3
L_AD0: length 166.2
  TOP w0.102: R372.1 160.59,75.99 v3(161.16,75.42) 161.36,75.23 R373.1 ; U24.8 62.58,40.78 62.84,40.52 63.73,40.52 v3(64.14,40.12) ; v3(139.98,41.12) 140.4,40.69 140.4,40.59 140.51,40.48 141.97,40.48 142.06,40.57 U22.26 U23.26 142.06,43.3 142.16,43.41 142.16,43.95 141.84,44.28 141.68,44.28 v3(141.61,44.35)
  L3 w0.127: v3(141.61,44.35) 141.61,44.36 141.68,44.36 142.21,44.89 142.21,49.26 143.86,50.91 146.26,50.91 150.06,54.71 153.67,54.71 154,54.38 159.58,54.38 166.55,61.35 166.55,66.2 v3(166.62,66.28) ; LPC1.5 127.09,38.4 127.95,37.55 129.51,37.55 129.82,37.24 131.11,37.24 132.05,36.31 134.71,36.31 136.32,37.92 139.3,37.92 140.3,38.92 140.3,40.8 v3(139.98,41.12)
  L4 w0.127: v3(166.62,66.28) 166.62,66.3 164.31,68.61 164.31,72.27 v3(161.16,75.42) ; LPC1.5 125.5,38.4 124.65,39.25 121.66,39.25 119.49,37.08 110.54,37.08 106.6,41.01 106.6,48.84 106.6,49.09 103.31,52.38 94.77,52.38 93.04,54.11 83.54,54.11 82.78,53.35 75.54,53.35 73.89,51.7 73.27,51.7 73.02,51.7 70.43,49.12 70.43,44.56 66.71,40.84 64.86,40.84 v3(64.14,40.12)
